VA A 0 1.0
RA B 0 1.0

B1 1 0 V ={ table(V(A), 1.0, 3.0, 0.5, 2.0, 0.0, 1.0) }
R1 1 0 1.0

.DC VA list 0.0 0.1 0.2 0.3 0.4 0.5 0.6 0.7 0.8 0.9 1.0

.print DC V(1)
