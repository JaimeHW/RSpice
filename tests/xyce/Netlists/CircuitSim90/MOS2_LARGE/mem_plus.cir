mem_plus.sp SPICE FILE
m0 0 4 3 0 nenh l=1.1e-06 w=2.28e-05
+ as=6.218e-11 ad=2.855e-11 ps=3.712e-05 pd=1.1e-06
+ nrs=0.12 nrd=0.05
m1 1 4 3 1 penh l=1.1e-06 w=4.04e-05
+ as=9.778e-11 ad=5.759e-11 ps=6.975e-05 pd=1.1e-06
+ nrs=0.06 nrd=0.04
m2 0 6 5 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.64e-12 ad=8.54e-12 ps=4.56e-06 pd=8.9e-06
+ nrs=0.97 nrd=1.09
m3 4 5 0 0 nenh l=1.1e-06 w=8.4e-06
+ as=1.056e-11 ad=2.291e-11 ps=6.2e-06 pd=1.368e-05
+ nrs=0.15 nrd=0.32
m4 1 5 4 1 penh l=1.1e-06 w=1.52e-05
+ as=3.679e-11 ad=2.057e-11 ps=2.624e-05 pd=6.3e-06
+ nrs=0.16 nrd=0.09
m5 5 6 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.54 nrd=0.43
m6 7 8 0 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=2.291e-11 ps=1.7e-06 pd=1.368e-05
+ nrs=0.1 nrd=0.32
m7 1 8 9 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m8 10 11 7 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.48e-12 ad=7.14e-12 ps=3.72e-06 pd=1.7e-06
+ nrs=0.11 nrd=0.1
m9 12 13 10 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.8e-12 ad=4.98e-12 ps=1.97e-06 pd=2.48e-06
+ nrs=0.15 nrd=0.16
m10 14 9 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.527e-11 ps=1.17e-05 pd=9.12e-06
+ nrs=0.37 nrd=0.49
m11 9 15 12 0 nenh l=1.1e-06 w=5.2e-06
+ as=1.106e-11 ad=4.46e-12 ps=1.13e-05 pd=1.83e-06
+ nrs=0.41 nrd=0.16
m12 1 9 14 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m13 16 15 17 0 nenh l=1.1e-06 w=5.2e-06
+ as=4.46e-12 ad=1.106e-11 ps=1.83e-06 pd=1.13e-05
+ nrs=0.16 nrd=0.41
m14 18 19 16 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.98e-12 ad=4.8e-12 ps=2.48e-06 pd=1.97e-06
+ nrs=0.16 nrd=0.15
m15 0 17 20 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=1.148e-11 ps=9.12e-06 pd=1.17e-05
+ nrs=0.49 nrd=0.37
m16 21 11 18 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=7.48e-12 ps=1.7e-06 pd=3.72e-06
+ nrs=0.1 nrd=0.11
m17 1 17 20 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m18 0 8 21 0 nenh l=1.1e-06 w=8.4e-06
+ as=2.291e-11 ad=7.14e-12 ps=1.368e-05 pd=1.7e-06
+ nrs=0.32 nrd=0.1
m19 17 8 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.54 nrd=0.43
m20 22 8 0 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=2.291e-11 ps=1.7e-06 pd=1.368e-05
+ nrs=0.1 nrd=0.32
m21 1 8 23 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.708e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.54
m22 24 25 22 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.48e-12 ad=7.14e-12 ps=3.72e-06 pd=1.7e-06
+ nrs=0.11 nrd=0.1
m23 26 13 24 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.8e-12 ad=4.98e-12 ps=1.97e-06 pd=2.48e-06
+ nrs=0.15 nrd=0.16
m24 27 23 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.527e-11 ps=1.17e-05 pd=9.12e-06
+ nrs=0.37 nrd=0.49
m25 23 15 26 0 nenh l=1.1e-06 w=5.2e-06
+ as=1.106e-11 ad=4.46e-12 ps=1.13e-05 pd=1.83e-06
+ nrs=0.41 nrd=0.16
m26 1 23 27 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m27 28 15 29 0 nenh l=1.1e-06 w=5.2e-06
+ as=4.46e-12 ad=1.106e-11 ps=1.83e-06 pd=1.13e-05
+ nrs=0.16 nrd=0.41
m28 30 19 28 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.98e-12 ad=4.8e-12 ps=2.48e-06 pd=1.97e-06
+ nrs=0.16 nrd=0.15
m29 0 29 31 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=1.148e-11 ps=9.12e-06 pd=1.17e-05
+ nrs=0.49 nrd=0.37
m30 32 25 30 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=7.48e-12 ps=1.7e-06 pd=3.72e-06
+ nrs=0.1 nrd=0.11
m31 1 29 31 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m32 0 8 32 0 nenh l=1.1e-06 w=8.4e-06
+ as=2.291e-11 ad=7.14e-12 ps=1.368e-05 pd=1.7e-06
+ nrs=0.32 nrd=0.1
m33 29 8 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.54 nrd=0.43
m34 33 8 0 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=2.291e-11 ps=1.7e-06 pd=1.368e-05
+ nrs=0.1 nrd=0.32
m35 1 8 34 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.708e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.54
m36 35 11 33 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.48e-12 ad=7.14e-12 ps=3.72e-06 pd=1.7e-06
+ nrs=0.11 nrd=0.1
m37 36 13 35 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.8e-12 ad=4.98e-12 ps=1.97e-06 pd=2.48e-06
+ nrs=0.15 nrd=0.16
m38 37 34 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.527e-11 ps=1.17e-05 pd=9.12e-06
+ nrs=0.37 nrd=0.49
m39 34 38 36 0 nenh l=1.1e-06 w=5.2e-06
+ as=1.106e-11 ad=4.46e-12 ps=1.13e-05 pd=1.83e-06
+ nrs=0.41 nrd=0.16
m40 1 34 37 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m41 39 38 40 0 nenh l=1.1e-06 w=5.2e-06
+ as=4.46e-12 ad=1.106e-11 ps=1.83e-06 pd=1.13e-05
+ nrs=0.16 nrd=0.41
m42 41 19 39 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.98e-12 ad=4.8e-12 ps=2.48e-06 pd=1.97e-06
+ nrs=0.16 nrd=0.15
m43 0 40 42 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=1.148e-11 ps=9.12e-06 pd=1.17e-05
+ nrs=0.49 nrd=0.37
m44 43 11 41 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=7.48e-12 ps=1.7e-06 pd=3.72e-06
+ nrs=0.1 nrd=0.11
m45 1 40 42 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m46 0 8 43 0 nenh l=1.1e-06 w=8.4e-06
+ as=2.291e-11 ad=7.14e-12 ps=1.368e-05 pd=1.7e-06
+ nrs=0.32 nrd=0.1
m47 40 8 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.54 nrd=0.43
m48 44 8 0 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=2.291e-11 ps=1.7e-06 pd=1.368e-05
+ nrs=0.1 nrd=0.32
m49 1 8 45 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.708e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.54
m50 46 25 44 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.48e-12 ad=7.14e-12 ps=3.72e-06 pd=1.7e-06
+ nrs=0.11 nrd=0.1
m51 47 13 46 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.8e-12 ad=4.98e-12 ps=1.97e-06 pd=2.48e-06
+ nrs=0.15 nrd=0.16
m52 48 45 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.527e-11 ps=1.17e-05 pd=9.12e-06
+ nrs=0.37 nrd=0.49
m53 45 38 47 0 nenh l=1.1e-06 w=5.2e-06
+ as=1.106e-11 ad=4.46e-12 ps=1.13e-05 pd=1.83e-06
+ nrs=0.41 nrd=0.16
m54 1 45 48 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m55 49 38 50 0 nenh l=1.1e-06 w=5.2e-06
+ as=4.46e-12 ad=1.106e-11 ps=1.83e-06 pd=1.13e-05
+ nrs=0.16 nrd=0.41
m56 51 19 49 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.98e-12 ad=4.8e-12 ps=2.48e-06 pd=1.97e-06
+ nrs=0.16 nrd=0.15
m57 0 50 52 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=1.148e-11 ps=9.12e-06 pd=1.17e-05
+ nrs=0.49 nrd=0.37
m58 53 25 51 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=7.48e-12 ps=1.7e-06 pd=3.72e-06
+ nrs=0.1 nrd=0.11
m59 1 50 52 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m60 0 8 53 0 nenh l=1.1e-06 w=8.4e-06
+ as=2.291e-11 ad=7.14e-12 ps=1.368e-05 pd=1.7e-06
+ nrs=0.32 nrd=0.1
m61 50 8 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.54 nrd=0.43
m62 54 8 0 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=2.291e-11 ps=1.7e-06 pd=1.368e-05
+ nrs=0.1 nrd=0.32
m63 1 8 55 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.708e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.54
m64 56 11 54 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.48e-12 ad=7.14e-12 ps=3.72e-06 pd=1.7e-06
+ nrs=0.11 nrd=0.1
m65 57 13 56 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.8e-12 ad=4.98e-12 ps=1.97e-06 pd=2.48e-06
+ nrs=0.15 nrd=0.16
m66 58 55 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.527e-11 ps=1.17e-05 pd=9.12e-06
+ nrs=0.37 nrd=0.49
m67 55 59 57 0 nenh l=1.1e-06 w=5.2e-06
+ as=1.106e-11 ad=4.46e-12 ps=1.13e-05 pd=1.83e-06
+ nrs=0.41 nrd=0.16
m68 1 55 58 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m69 60 59 61 0 nenh l=1.1e-06 w=5.2e-06
+ as=4.46e-12 ad=1.106e-11 ps=1.83e-06 pd=1.13e-05
+ nrs=0.16 nrd=0.41
m70 62 19 60 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.98e-12 ad=4.8e-12 ps=2.48e-06 pd=1.97e-06
+ nrs=0.16 nrd=0.15
m71 0 61 63 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=1.148e-11 ps=9.12e-06 pd=1.17e-05
+ nrs=0.49 nrd=0.37
m72 64 11 62 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=7.48e-12 ps=1.7e-06 pd=3.72e-06
+ nrs=0.1 nrd=0.11
m73 1 61 63 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m74 0 8 64 0 nenh l=1.1e-06 w=8.4e-06
+ as=2.291e-11 ad=7.14e-12 ps=1.368e-05 pd=1.7e-06
+ nrs=0.32 nrd=0.1
m75 61 8 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.54 nrd=0.43
m76 65 8 0 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=2.291e-11 ps=1.7e-06 pd=1.368e-05
+ nrs=0.1 nrd=0.32
m77 1 8 66 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.708e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.54
m78 67 25 65 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.48e-12 ad=7.14e-12 ps=3.72e-06 pd=1.7e-06
+ nrs=0.11 nrd=0.1
m79 68 13 67 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.8e-12 ad=4.98e-12 ps=1.97e-06 pd=2.48e-06
+ nrs=0.15 nrd=0.16
m80 69 66 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.527e-11 ps=1.17e-05 pd=9.12e-06
+ nrs=0.37 nrd=0.49
m81 66 59 68 0 nenh l=1.1e-06 w=5.2e-06
+ as=1.106e-11 ad=4.46e-12 ps=1.13e-05 pd=1.83e-06
+ nrs=0.41 nrd=0.16
m82 1 66 69 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m83 70 59 71 0 nenh l=1.1e-06 w=5.2e-06
+ as=4.46e-12 ad=1.106e-11 ps=1.83e-06 pd=1.13e-05
+ nrs=0.16 nrd=0.41
m84 72 19 70 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.98e-12 ad=4.8e-12 ps=2.48e-06 pd=1.97e-06
+ nrs=0.16 nrd=0.15
m85 0 71 73 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=1.148e-11 ps=9.12e-06 pd=1.17e-05
+ nrs=0.49 nrd=0.37
m86 74 25 72 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=7.48e-12 ps=1.7e-06 pd=3.72e-06
+ nrs=0.1 nrd=0.11
m87 1 71 73 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m88 0 8 74 0 nenh l=1.1e-06 w=8.4e-06
+ as=2.291e-11 ad=7.14e-12 ps=1.368e-05 pd=1.7e-06
+ nrs=0.32 nrd=0.1
m89 71 8 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.54 nrd=0.43
m90 75 8 0 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=2.291e-11 ps=1.7e-06 pd=1.368e-05
+ nrs=0.1 nrd=0.32
m91 1 8 76 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.708e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.54
m92 77 11 75 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.48e-12 ad=7.14e-12 ps=3.72e-06 pd=1.7e-06
+ nrs=0.11 nrd=0.1
m93 78 13 77 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.8e-12 ad=4.98e-12 ps=1.97e-06 pd=2.48e-06
+ nrs=0.15 nrd=0.16
m94 79 76 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.527e-11 ps=1.17e-05 pd=9.12e-06
+ nrs=0.37 nrd=0.49
m95 76 80 78 0 nenh l=1.1e-06 w=5.2e-06
+ as=1.106e-11 ad=4.46e-12 ps=1.13e-05 pd=1.83e-06
+ nrs=0.41 nrd=0.16
m96 1 76 79 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m97 81 80 82 0 nenh l=1.1e-06 w=5.2e-06
+ as=4.46e-12 ad=1.106e-11 ps=1.83e-06 pd=1.13e-05
+ nrs=0.16 nrd=0.41
m98 83 19 81 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.98e-12 ad=4.8e-12 ps=2.48e-06 pd=1.97e-06
+ nrs=0.16 nrd=0.15
m99 0 82 84 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=1.148e-11 ps=9.12e-06 pd=1.17e-05
+ nrs=0.49 nrd=0.37
m100 85 11 83 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=7.48e-12 ps=1.7e-06 pd=3.72e-06
+ nrs=0.1 nrd=0.11
m101 1 82 84 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m102 0 8 85 0 nenh l=1.1e-06 w=8.4e-06
+ as=2.291e-11 ad=7.14e-12 ps=1.368e-05 pd=1.7e-06
+ nrs=0.32 nrd=0.1
m103 82 8 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.54 nrd=0.43
m104 86 8 0 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=2.291e-11 ps=1.7e-06 pd=1.368e-05
+ nrs=0.1 nrd=0.32
m105 1 8 87 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.708e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.54
m106 88 25 86 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.48e-12 ad=7.14e-12 ps=3.72e-06 pd=1.7e-06
+ nrs=0.11 nrd=0.1
m107 89 13 88 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.8e-12 ad=4.98e-12 ps=1.97e-06 pd=2.48e-06
+ nrs=0.15 nrd=0.16
m108 90 87 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.527e-11 ps=1.17e-05 pd=9.12e-06
+ nrs=0.37 nrd=0.49
m109 87 80 89 0 nenh l=1.1e-06 w=5.2e-06
+ as=1.106e-11 ad=4.46e-12 ps=1.13e-05 pd=1.83e-06
+ nrs=0.41 nrd=0.16
m110 1 87 90 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m111 91 80 92 0 nenh l=1.1e-06 w=5.2e-06
+ as=4.46e-12 ad=1.106e-11 ps=1.83e-06 pd=1.13e-05
+ nrs=0.16 nrd=0.41
m112 93 19 91 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.98e-12 ad=4.8e-12 ps=2.48e-06 pd=1.97e-06
+ nrs=0.16 nrd=0.15
m113 0 92 94 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=1.148e-11 ps=9.12e-06 pd=1.17e-05
+ nrs=0.49 nrd=0.37
m114 95 25 93 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=7.48e-12 ps=1.7e-06 pd=3.72e-06
+ nrs=0.1 nrd=0.11
m115 1 92 94 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m116 0 8 95 0 nenh l=1.1e-06 w=8.4e-06
+ as=2.291e-11 ad=7.14e-12 ps=1.368e-05 pd=1.7e-06
+ nrs=0.32 nrd=0.1
m117 92 8 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.54 nrd=0.43
m118 96 8 0 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=2.291e-11 ps=1.7e-06 pd=1.368e-05
+ nrs=0.1 nrd=0.32
m119 1 8 97 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.708e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.54
m120 98 11 96 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.48e-12 ad=7.14e-12 ps=3.72e-06 pd=1.7e-06
+ nrs=0.11 nrd=0.1
m121 99 13 98 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.8e-12 ad=4.98e-12 ps=1.97e-06 pd=2.48e-06
+ nrs=0.15 nrd=0.16
m122 100 97 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.527e-11 ps=1.17e-05 pd=9.12e-06
+ nrs=0.37 nrd=0.49
m123 97 101 99 0 nenh l=1.1e-06 w=5.2e-06
+ as=1.106e-11 ad=4.46e-12 ps=1.13e-05 pd=1.83e-06
+ nrs=0.41 nrd=0.16
m124 1 97 100 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m125 102 101 103 0 nenh l=1.1e-06 w=5.2e-06
+ as=4.46e-12 ad=1.106e-11 ps=1.83e-06 pd=1.13e-05
+ nrs=0.16 nrd=0.41
m126 104 19 102 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.98e-12 ad=4.8e-12 ps=2.48e-06 pd=1.97e-06
+ nrs=0.16 nrd=0.15
m127 0 103 105 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=1.148e-11 ps=9.12e-06 pd=1.17e-05
+ nrs=0.49 nrd=0.37
m128 106 11 104 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=7.48e-12 ps=1.7e-06 pd=3.72e-06
+ nrs=0.1 nrd=0.11
m129 1 103 105 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m130 0 8 106 0 nenh l=1.1e-06 w=8.4e-06
+ as=2.291e-11 ad=7.14e-12 ps=1.368e-05 pd=1.7e-06
+ nrs=0.32 nrd=0.1
m131 103 8 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.54 nrd=0.43
m132 107 8 0 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=2.291e-11 ps=1.7e-06 pd=1.368e-05
+ nrs=0.1 nrd=0.32
m133 1 8 108 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.708e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.54
m134 109 25 107 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.48e-12 ad=7.14e-12 ps=3.72e-06 pd=1.7e-06
+ nrs=0.11 nrd=0.1
m135 110 13 109 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.8e-12 ad=4.98e-12 ps=1.97e-06 pd=2.48e-06
+ nrs=0.15 nrd=0.16
m136 111 108 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.527e-11 ps=1.17e-05 pd=9.12e-06
+ nrs=0.37 nrd=0.49
m137 108 101 110 0 nenh l=1.1e-06 w=5.2e-06
+ as=1.106e-11 ad=4.46e-12 ps=1.13e-05 pd=1.83e-06
+ nrs=0.41 nrd=0.16
m138 1 108 111 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m139 112 101 113 0 nenh l=1.1e-06 w=5.2e-06
+ as=4.46e-12 ad=1.106e-11 ps=1.83e-06 pd=1.13e-05
+ nrs=0.16 nrd=0.41
m140 114 19 112 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.98e-12 ad=4.8e-12 ps=2.48e-06 pd=1.97e-06
+ nrs=0.16 nrd=0.15
m141 0 113 115 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=1.148e-11 ps=9.12e-06 pd=1.17e-05
+ nrs=0.49 nrd=0.37
m142 116 25 114 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=7.48e-12 ps=1.7e-06 pd=3.72e-06
+ nrs=0.1 nrd=0.11
m143 1 113 115 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m144 0 8 116 0 nenh l=1.1e-06 w=8.4e-06
+ as=2.291e-11 ad=7.14e-12 ps=1.368e-05 pd=1.7e-06
+ nrs=0.32 nrd=0.1
m145 113 8 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.54 nrd=0.43
m146 117 8 0 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=2.291e-11 ps=1.7e-06 pd=1.368e-05
+ nrs=0.1 nrd=0.32
m147 1 8 118 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.708e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.54
m148 119 11 117 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.48e-12 ad=7.14e-12 ps=3.72e-06 pd=1.7e-06
+ nrs=0.11 nrd=0.1
m149 120 13 119 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.8e-12 ad=4.98e-12 ps=1.97e-06 pd=2.48e-06
+ nrs=0.15 nrd=0.16
m150 121 118 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.527e-11 ps=1.17e-05 pd=9.12e-06
+ nrs=0.37 nrd=0.49
m151 118 122 120 0 nenh l=1.1e-06 w=5.2e-06
+ as=1.106e-11 ad=4.46e-12 ps=1.13e-05 pd=1.83e-06
+ nrs=0.41 nrd=0.16
m152 1 118 121 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m153 123 122 124 0 nenh l=1.1e-06 w=5.2e-06
+ as=4.46e-12 ad=1.106e-11 ps=1.83e-06 pd=1.13e-05
+ nrs=0.16 nrd=0.41
m154 125 19 123 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.98e-12 ad=4.8e-12 ps=2.48e-06 pd=1.97e-06
+ nrs=0.16 nrd=0.15
m155 0 124 126 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=1.148e-11 ps=9.12e-06 pd=1.17e-05
+ nrs=0.49 nrd=0.37
m156 127 11 125 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=7.48e-12 ps=1.7e-06 pd=3.72e-06
+ nrs=0.1 nrd=0.11
m157 1 124 126 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m158 0 8 127 0 nenh l=1.1e-06 w=8.4e-06
+ as=2.291e-11 ad=7.14e-12 ps=1.368e-05 pd=1.7e-06
+ nrs=0.32 nrd=0.1
m159 124 8 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.54 nrd=0.43
m160 128 8 0 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=2.291e-11 ps=1.7e-06 pd=1.368e-05
+ nrs=0.1 nrd=0.32
m161 1 8 129 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.708e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.54
m162 130 25 128 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.48e-12 ad=7.14e-12 ps=3.72e-06 pd=1.7e-06
+ nrs=0.11 nrd=0.1
m163 131 13 130 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.8e-12 ad=4.98e-12 ps=1.97e-06 pd=2.48e-06
+ nrs=0.15 nrd=0.16
m164 132 129 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.527e-11 ps=1.17e-05 pd=9.12e-06
+ nrs=0.37 nrd=0.49
m165 129 122 131 0 nenh l=1.1e-06 w=5.2e-06
+ as=1.106e-11 ad=4.46e-12 ps=1.13e-05 pd=1.83e-06
+ nrs=0.41 nrd=0.16
m166 1 129 132 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m167 133 122 134 0 nenh l=1.1e-06 w=5.2e-06
+ as=4.46e-12 ad=1.106e-11 ps=1.83e-06 pd=1.13e-05
+ nrs=0.16 nrd=0.41
m168 135 19 133 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.98e-12 ad=4.8e-12 ps=2.48e-06 pd=1.97e-06
+ nrs=0.16 nrd=0.15
m169 0 134 136 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=1.148e-11 ps=9.12e-06 pd=1.17e-05
+ nrs=0.49 nrd=0.37
m170 137 25 135 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=7.48e-12 ps=1.7e-06 pd=3.72e-06
+ nrs=0.1 nrd=0.11
m171 1 134 136 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m172 0 8 137 0 nenh l=1.1e-06 w=8.4e-06
+ as=2.291e-11 ad=7.14e-12 ps=1.368e-05 pd=1.7e-06
+ nrs=0.32 nrd=0.1
m173 134 8 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.54 nrd=0.43
m174 138 8 0 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=2.291e-11 ps=1.7e-06 pd=1.368e-05
+ nrs=0.1 nrd=0.32
m175 1 8 139 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.708e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.54
m176 140 11 138 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.48e-12 ad=7.14e-12 ps=3.72e-06 pd=1.7e-06
+ nrs=0.11 nrd=0.1
m177 141 13 140 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.8e-12 ad=4.98e-12 ps=1.97e-06 pd=2.48e-06
+ nrs=0.15 nrd=0.16
m178 142 139 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.527e-11 ps=1.17e-05 pd=9.12e-06
+ nrs=0.37 nrd=0.49
m179 139 143 141 0 nenh l=1.1e-06 w=5.2e-06
+ as=1.106e-11 ad=4.46e-12 ps=1.13e-05 pd=1.83e-06
+ nrs=0.41 nrd=0.16
m180 1 139 142 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m181 144 143 145 0 nenh l=1.1e-06 w=5.2e-06
+ as=4.46e-12 ad=1.106e-11 ps=1.83e-06 pd=1.13e-05
+ nrs=0.16 nrd=0.41
m182 146 19 144 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.98e-12 ad=4.8e-12 ps=2.48e-06 pd=1.97e-06
+ nrs=0.16 nrd=0.15
m183 0 145 147 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=1.148e-11 ps=9.12e-06 pd=1.17e-05
+ nrs=0.49 nrd=0.37
m184 148 11 146 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=7.48e-12 ps=1.7e-06 pd=3.72e-06
+ nrs=0.1 nrd=0.11
m185 1 145 147 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m186 0 8 148 0 nenh l=1.1e-06 w=8.4e-06
+ as=2.291e-11 ad=7.14e-12 ps=1.368e-05 pd=1.7e-06
+ nrs=0.32 nrd=0.1
m187 145 8 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.54 nrd=0.43
m188 149 8 0 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=2.291e-11 ps=1.7e-06 pd=1.368e-05
+ nrs=0.1 nrd=0.32
m189 1 8 150 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.708e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.54
m190 151 25 149 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.48e-12 ad=7.14e-12 ps=3.72e-06 pd=1.7e-06
+ nrs=0.11 nrd=0.1
m191 152 13 151 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.8e-12 ad=4.98e-12 ps=1.97e-06 pd=2.48e-06
+ nrs=0.15 nrd=0.16
m192 153 150 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.527e-11 ps=1.17e-05 pd=9.12e-06
+ nrs=0.37 nrd=0.49
m193 150 143 152 0 nenh l=1.1e-06 w=5.2e-06
+ as=1.106e-11 ad=4.46e-12 ps=1.13e-05 pd=1.83e-06
+ nrs=0.41 nrd=0.16
m194 1 150 153 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m195 154 143 155 0 nenh l=1.1e-06 w=5.2e-06
+ as=4.46e-12 ad=1.106e-11 ps=1.83e-06 pd=1.13e-05
+ nrs=0.16 nrd=0.41
m196 156 19 154 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.98e-12 ad=4.8e-12 ps=2.48e-06 pd=1.97e-06
+ nrs=0.16 nrd=0.15
m197 0 155 157 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=1.148e-11 ps=9.12e-06 pd=1.17e-05
+ nrs=0.49 nrd=0.37
m198 158 25 156 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=7.48e-12 ps=1.7e-06 pd=3.72e-06
+ nrs=0.1 nrd=0.11
m199 1 155 157 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m200 0 8 158 0 nenh l=1.1e-06 w=8.4e-06
+ as=2.291e-11 ad=7.14e-12 ps=1.368e-05 pd=1.7e-06
+ nrs=0.32 nrd=0.1
m201 155 8 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.54 nrd=0.43
m202 159 8 0 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=2.291e-11 ps=1.7e-06 pd=1.368e-05
+ nrs=0.1 nrd=0.32
m203 1 8 160 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.708e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.54
m204 161 11 159 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.48e-12 ad=7.14e-12 ps=3.72e-06 pd=1.7e-06
+ nrs=0.11 nrd=0.1
m205 162 13 161 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.8e-12 ad=4.98e-12 ps=1.97e-06 pd=2.48e-06
+ nrs=0.15 nrd=0.16
m206 163 160 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.527e-11 ps=1.17e-05 pd=9.12e-06
+ nrs=0.37 nrd=0.49
m207 160 164 162 0 nenh l=1.1e-06 w=5.2e-06
+ as=1.106e-11 ad=4.46e-12 ps=1.13e-05 pd=1.83e-06
+ nrs=0.41 nrd=0.16
m208 1 160 163 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m209 165 164 166 0 nenh l=1.1e-06 w=5.2e-06
+ as=4.46e-12 ad=1.106e-11 ps=1.83e-06 pd=1.13e-05
+ nrs=0.16 nrd=0.41
m210 167 19 165 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.98e-12 ad=4.8e-12 ps=2.48e-06 pd=1.97e-06
+ nrs=0.16 nrd=0.15
m211 0 166 168 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=1.148e-11 ps=9.12e-06 pd=1.17e-05
+ nrs=0.49 nrd=0.37
m212 169 11 167 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=7.48e-12 ps=1.7e-06 pd=3.72e-06
+ nrs=0.1 nrd=0.11
m213 1 166 168 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m214 0 8 169 0 nenh l=1.1e-06 w=8.4e-06
+ as=2.291e-11 ad=7.14e-12 ps=1.368e-05 pd=1.7e-06
+ nrs=0.32 nrd=0.1
m215 166 8 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.54 nrd=0.43
m216 170 8 0 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=2.291e-11 ps=1.7e-06 pd=1.368e-05
+ nrs=0.1 nrd=0.32
m217 1 8 171 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.708e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.54
m218 172 25 170 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.48e-12 ad=7.14e-12 ps=3.72e-06 pd=1.7e-06
+ nrs=0.11 nrd=0.1
m219 173 13 172 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.8e-12 ad=4.98e-12 ps=1.97e-06 pd=2.48e-06
+ nrs=0.15 nrd=0.16
m220 174 171 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.527e-11 ps=1.17e-05 pd=9.12e-06
+ nrs=0.37 nrd=0.49
m221 171 164 173 0 nenh l=1.1e-06 w=5.2e-06
+ as=1.106e-11 ad=4.46e-12 ps=1.13e-05 pd=1.83e-06
+ nrs=0.41 nrd=0.16
m222 1 171 174 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m223 175 164 176 0 nenh l=1.1e-06 w=5.2e-06
+ as=4.46e-12 ad=1.106e-11 ps=1.83e-06 pd=1.13e-05
+ nrs=0.16 nrd=0.41
m224 177 19 175 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.98e-12 ad=4.8e-12 ps=2.48e-06 pd=1.97e-06
+ nrs=0.16 nrd=0.15
m225 0 176 178 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=1.148e-11 ps=9.12e-06 pd=1.17e-05
+ nrs=0.49 nrd=0.37
m226 179 25 177 0 nenh l=1.1e-06 w=8.4e-06
+ as=7.14e-12 ad=7.48e-12 ps=1.7e-06 pd=3.72e-06
+ nrs=0.1 nrd=0.11
m227 1 176 178 1 penh l=1.1e-06 w=2.84e-05
+ as=6.874e-11 ad=3.778e-11 ps=4.903e-05 pd=1.1e-06
+ nrs=0.09 nrd=0.05
m228 0 8 179 0 nenh l=1.1e-06 w=8.4e-06
+ as=2.291e-11 ad=7.14e-12 ps=1.368e-05 pd=1.7e-06
+ nrs=0.32 nrd=0.1
m229 176 8 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.54 nrd=0.43
m230 1 3 180 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m231 181 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m232 1 3 182 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m233 183 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m234 1 3 184 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m235 185 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m236 1 3 186 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m237 187 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m238 1 3 188 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m239 189 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m240 1 3 190 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m241 191 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m242 1 3 192 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m243 193 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m244 1 3 194 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m245 195 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m246 1 3 196 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m247 197 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m248 1 3 198 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m249 199 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m250 1 3 200 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m251 201 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m252 1 3 202 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m253 203 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m254 1 3 204 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m255 205 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m256 1 3 206 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m257 207 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m258 1 3 208 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m259 209 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m260 1 3 210 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m261 211 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m262 1 3 212 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m263 213 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m264 1 3 214 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m265 215 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m266 1 3 216 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m267 217 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m268 1 3 218 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m269 219 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m270 1 3 220 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m271 221 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m272 1 3 222 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m273 223 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m274 1 3 224 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m275 225 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m276 1 3 226 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m277 227 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m278 1 3 228 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m279 229 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m280 1 3 230 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m281 231 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m282 1 3 232 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m283 233 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m284 1 3 234 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m285 235 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m286 1 3 236 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m287 237 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m288 1 3 238 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m289 239 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m290 1 3 240 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m291 241 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m292 1 3 242 1 penh l=1.1e-06 w=6e-06
+ as=1.452e-11 ad=1.19e-11 ps=1.036e-05 pd=1.21e-05
+ nrs=0.4 nrd=0.33
m293 243 3 1 1 penh l=1.1e-06 w=6e-06
+ as=1.19e-11 ad=1.452e-11 ps=1.21e-05 pd=1.036e-05
+ nrs=0.33 nrd=0.4
m294 1 245 244 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m295 1 244 245 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m296 1 247 246 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m297 1 246 247 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m298 0 245 244 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m299 245 244 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m300 0 247 246 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m301 247 246 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m302 184 174 244 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m303 185 174 245 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m304 186 174 246 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m305 187 174 247 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m306 248 178 184 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m307 249 178 185 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m308 250 178 186 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m309 251 178 187 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m310 0 249 248 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m311 249 248 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m312 0 251 250 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m313 251 250 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m314 1 249 248 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m315 249 248 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m316 1 251 250 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m317 251 250 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m318 1 253 252 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m319 1 252 253 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m320 1 255 254 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m321 1 254 255 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m322 0 253 252 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m323 253 252 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m324 0 255 254 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m325 255 254 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m326 183 178 252 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m327 182 178 253 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m328 181 178 254 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m329 180 178 255 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m330 256 174 183 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m331 257 174 182 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m332 258 174 181 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m333 259 174 180 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m334 0 257 256 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m335 257 256 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m336 0 259 258 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m337 259 258 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m338 1 257 256 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m339 257 256 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m340 1 259 258 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m341 259 258 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m342 1 261 260 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m343 1 260 261 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m344 1 263 262 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m345 1 262 263 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m346 0 261 260 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m347 261 260 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m348 0 263 262 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m349 263 262 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m350 192 174 260 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m351 193 174 261 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m352 194 174 262 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m353 195 174 263 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m354 264 178 192 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m355 265 178 193 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m356 266 178 194 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m357 267 178 195 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m358 0 265 264 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m359 265 264 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m360 0 267 266 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m361 267 266 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m362 1 265 264 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m363 265 264 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m364 1 267 266 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m365 267 266 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m366 1 269 268 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m367 1 268 269 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m368 1 271 270 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m369 1 270 271 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m370 0 269 268 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m371 269 268 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m372 0 271 270 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m373 271 270 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m374 191 178 268 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m375 190 178 269 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m376 189 178 270 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m377 188 178 271 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m378 272 174 191 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m379 273 174 190 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m380 274 174 189 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m381 275 174 188 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m382 0 273 272 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m383 273 272 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m384 0 275 274 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m385 275 274 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m386 1 273 272 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m387 273 272 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m388 1 275 274 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m389 275 274 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m390 1 277 276 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m391 1 276 277 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m392 1 279 278 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m393 1 278 279 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m394 0 277 276 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m395 277 276 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m396 0 279 278 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m397 279 278 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m398 200 174 276 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m399 201 174 277 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m400 202 174 278 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m401 203 174 279 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m402 280 178 200 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m403 281 178 201 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m404 282 178 202 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m405 283 178 203 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m406 0 281 280 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m407 281 280 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m408 0 283 282 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m409 283 282 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m410 1 281 280 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m411 281 280 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m412 1 283 282 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m413 283 282 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m414 1 285 284 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m415 1 284 285 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m416 1 287 286 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m417 1 286 287 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m418 0 285 284 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m419 285 284 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m420 0 287 286 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m421 287 286 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m422 199 178 284 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m423 198 178 285 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m424 197 178 286 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m425 196 178 287 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m426 288 174 199 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m427 289 174 198 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m428 290 174 197 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m429 291 174 196 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m430 0 289 288 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m431 289 288 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m432 0 291 290 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m433 291 290 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m434 1 289 288 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m435 289 288 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m436 1 291 290 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m437 291 290 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m438 1 293 292 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m439 1 292 293 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m440 1 295 294 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m441 1 294 295 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m442 0 293 292 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m443 293 292 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m444 0 295 294 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m445 295 294 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m446 208 174 292 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m447 209 174 293 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m448 210 174 294 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m449 211 174 295 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m450 296 178 208 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m451 297 178 209 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m452 298 178 210 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m453 299 178 211 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m454 0 297 296 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m455 297 296 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m456 0 299 298 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m457 299 298 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m458 1 297 296 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m459 297 296 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m460 1 299 298 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m461 299 298 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m462 1 301 300 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m463 1 300 301 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m464 1 303 302 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m465 1 302 303 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m466 0 301 300 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m467 301 300 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m468 0 303 302 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m469 303 302 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m470 207 178 300 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m471 206 178 301 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m472 205 178 302 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m473 204 178 303 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m474 304 174 207 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m475 305 174 206 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m476 306 174 205 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m477 307 174 204 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m478 0 305 304 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m479 305 304 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m480 0 307 306 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m481 307 306 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m482 1 305 304 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m483 305 304 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m484 1 307 306 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m485 307 306 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m486 1 309 308 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m487 1 308 309 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m488 1 311 310 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m489 1 310 311 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m490 0 309 308 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m491 309 308 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m492 0 311 310 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m493 311 310 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m494 216 174 308 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m495 217 174 309 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m496 218 174 310 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m497 219 174 311 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m498 312 178 216 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m499 313 178 217 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m500 314 178 218 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m501 315 178 219 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m502 0 313 312 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m503 313 312 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m504 0 315 314 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m505 315 314 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m506 1 313 312 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m507 313 312 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m508 1 315 314 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m509 315 314 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m510 1 317 316 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m511 1 316 317 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m512 1 319 318 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m513 1 318 319 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m514 0 317 316 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m515 317 316 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m516 0 319 318 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m517 319 318 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m518 215 178 316 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m519 214 178 317 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m520 213 178 318 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m521 212 178 319 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m522 320 174 215 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m523 321 174 214 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m524 322 174 213 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m525 323 174 212 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m526 0 321 320 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m527 321 320 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m528 0 323 322 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m529 323 322 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m530 1 321 320 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m531 321 320 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m532 1 323 322 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m533 323 322 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m534 1 325 324 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m535 1 324 325 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m536 1 327 326 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m537 1 326 327 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m538 0 325 324 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m539 325 324 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m540 0 327 326 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m541 327 326 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m542 224 174 324 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m543 225 174 325 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m544 226 174 326 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m545 227 174 327 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m546 328 178 224 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m547 329 178 225 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m548 330 178 226 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m549 331 178 227 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m550 0 329 328 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m551 329 328 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m552 0 331 330 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m553 331 330 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m554 1 329 328 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m555 329 328 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m556 1 331 330 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m557 331 330 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m558 1 333 332 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m559 1 332 333 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m560 1 335 334 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m561 1 334 335 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m562 0 333 332 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m563 333 332 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m564 0 335 334 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m565 335 334 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m566 223 178 332 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m567 222 178 333 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m568 221 178 334 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m569 220 178 335 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m570 336 174 223 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m571 337 174 222 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m572 338 174 221 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m573 339 174 220 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m574 0 337 336 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m575 337 336 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m576 0 339 338 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m577 339 338 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m578 1 337 336 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m579 337 336 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m580 1 339 338 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m581 339 338 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m582 1 341 340 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m583 1 340 341 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m584 1 343 342 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m585 1 342 343 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m586 0 341 340 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m587 341 340 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m588 0 343 342 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m589 343 342 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m590 232 174 340 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m591 233 174 341 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m592 234 174 342 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m593 235 174 343 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m594 344 178 232 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m595 345 178 233 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m596 346 178 234 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m597 347 178 235 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m598 0 345 344 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m599 345 344 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m600 0 347 346 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m601 347 346 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m602 1 345 344 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m603 345 344 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m604 1 347 346 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m605 347 346 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m606 1 349 348 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m607 1 348 349 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m608 1 351 350 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m609 1 350 351 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m610 0 349 348 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m611 349 348 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m612 0 351 350 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m613 351 350 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m614 231 178 348 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m615 230 178 349 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m616 229 178 350 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m617 228 178 351 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m618 352 174 231 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m619 353 174 230 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m620 354 174 229 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m621 355 174 228 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m622 0 353 352 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m623 353 352 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m624 0 355 354 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m625 355 354 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m626 1 353 352 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m627 353 352 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m628 1 355 354 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m629 355 354 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m630 1 357 356 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m631 1 356 357 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m632 1 359 358 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m633 1 358 359 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m634 0 357 356 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m635 357 356 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m636 0 359 358 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m637 359 358 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m638 240 174 356 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m639 241 174 357 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m640 242 174 358 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m641 243 174 359 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m642 360 178 240 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m643 361 178 241 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m644 362 178 242 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m645 363 178 243 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m646 0 361 360 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m647 361 360 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m648 0 363 362 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m649 363 362 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m650 1 361 360 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m651 361 360 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m652 1 363 362 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m653 363 362 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m654 1 365 364 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m655 1 364 365 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m656 1 367 366 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m657 1 366 367 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m658 0 365 364 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m659 365 364 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m660 0 367 366 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m661 367 366 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m662 239 178 364 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m663 238 178 365 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m664 237 178 366 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m665 236 178 367 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m666 368 174 239 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m667 369 174 238 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m668 370 174 237 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m669 371 174 236 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m670 0 369 368 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m671 369 368 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m672 0 371 370 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m673 371 370 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m674 1 369 368 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m675 369 368 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m676 1 371 370 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m677 371 370 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m678 1 373 372 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m679 1 372 373 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m680 1 375 374 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m681 1 374 375 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m682 0 373 372 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m683 373 372 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m684 0 375 374 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m685 375 374 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m686 184 163 372 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m687 185 163 373 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m688 186 163 374 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m689 187 163 375 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m690 376 168 184 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m691 377 168 185 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m692 378 168 186 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m693 379 168 187 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m694 0 377 376 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m695 377 376 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m696 0 379 378 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m697 379 378 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m698 1 377 376 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m699 377 376 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m700 1 379 378 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m701 379 378 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m702 1 381 380 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m703 1 380 381 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m704 1 383 382 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m705 1 382 383 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m706 0 381 380 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m707 381 380 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m708 0 383 382 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m709 383 382 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m710 183 168 380 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m711 182 168 381 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m712 181 168 382 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m713 180 168 383 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m714 384 163 183 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m715 385 163 182 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m716 386 163 181 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m717 387 163 180 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m718 0 385 384 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m719 385 384 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m720 0 387 386 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m721 387 386 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m722 1 385 384 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m723 385 384 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m724 1 387 386 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m725 387 386 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m726 1 389 388 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m727 1 388 389 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m728 1 391 390 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m729 1 390 391 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m730 0 389 388 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m731 389 388 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m732 0 391 390 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m733 391 390 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m734 192 163 388 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m735 193 163 389 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m736 194 163 390 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m737 195 163 391 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m738 392 168 192 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m739 393 168 193 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m740 394 168 194 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m741 395 168 195 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m742 0 393 392 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m743 393 392 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m744 0 395 394 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m745 395 394 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m746 1 393 392 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m747 393 392 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m748 1 395 394 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m749 395 394 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m750 1 397 396 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m751 1 396 397 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m752 1 399 398 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m753 1 398 399 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m754 0 397 396 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m755 397 396 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m756 0 399 398 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m757 399 398 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m758 191 168 396 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m759 190 168 397 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m760 189 168 398 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m761 188 168 399 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m762 400 163 191 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m763 401 163 190 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m764 402 163 189 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m765 403 163 188 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m766 0 401 400 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m767 401 400 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m768 0 403 402 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m769 403 402 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m770 1 401 400 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m771 401 400 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m772 1 403 402 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m773 403 402 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m774 1 405 404 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m775 1 404 405 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m776 1 407 406 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m777 1 406 407 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m778 0 405 404 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m779 405 404 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m780 0 407 406 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m781 407 406 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m782 200 163 404 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m783 201 163 405 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m784 202 163 406 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m785 203 163 407 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m786 408 168 200 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m787 409 168 201 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m788 410 168 202 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m789 411 168 203 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m790 0 409 408 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m791 409 408 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m792 0 411 410 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m793 411 410 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m794 1 409 408 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m795 409 408 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m796 1 411 410 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m797 411 410 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m798 1 413 412 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m799 1 412 413 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m800 1 415 414 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m801 1 414 415 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m802 0 413 412 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m803 413 412 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m804 0 415 414 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m805 415 414 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m806 199 168 412 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m807 198 168 413 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m808 197 168 414 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m809 196 168 415 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m810 416 163 199 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m811 417 163 198 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m812 418 163 197 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m813 419 163 196 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m814 0 417 416 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m815 417 416 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m816 0 419 418 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m817 419 418 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m818 1 417 416 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m819 417 416 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m820 1 419 418 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m821 419 418 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m822 1 421 420 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m823 1 420 421 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m824 1 423 422 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m825 1 422 423 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m826 0 421 420 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m827 421 420 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m828 0 423 422 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m829 423 422 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m830 208 163 420 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m831 209 163 421 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m832 210 163 422 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m833 211 163 423 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m834 424 168 208 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m835 425 168 209 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m836 426 168 210 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m837 427 168 211 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m838 0 425 424 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m839 425 424 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m840 0 427 426 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m841 427 426 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m842 1 425 424 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m843 425 424 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m844 1 427 426 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m845 427 426 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m846 1 429 428 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m847 1 428 429 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m848 1 431 430 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m849 1 430 431 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m850 0 429 428 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m851 429 428 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m852 0 431 430 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m853 431 430 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m854 207 168 428 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m855 206 168 429 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m856 205 168 430 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m857 204 168 431 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m858 432 163 207 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m859 433 163 206 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m860 434 163 205 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m861 435 163 204 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m862 0 433 432 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m863 433 432 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m864 0 435 434 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m865 435 434 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m866 1 433 432 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m867 433 432 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m868 1 435 434 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m869 435 434 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m870 1 437 436 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m871 1 436 437 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m872 1 439 438 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m873 1 438 439 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m874 0 437 436 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m875 437 436 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m876 0 439 438 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m877 439 438 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m878 216 163 436 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m879 217 163 437 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m880 218 163 438 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m881 219 163 439 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m882 440 168 216 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m883 441 168 217 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m884 442 168 218 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m885 443 168 219 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m886 0 441 440 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m887 441 440 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m888 0 443 442 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m889 443 442 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m890 1 441 440 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m891 441 440 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m892 1 443 442 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m893 443 442 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m894 1 445 444 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m895 1 444 445 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m896 1 447 446 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m897 1 446 447 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m898 0 445 444 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m899 445 444 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m900 0 447 446 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m901 447 446 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m902 215 168 444 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m903 214 168 445 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m904 213 168 446 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m905 212 168 447 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m906 448 163 215 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m907 449 163 214 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m908 450 163 213 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m909 451 163 212 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m910 0 449 448 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m911 449 448 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m912 0 451 450 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m913 451 450 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m914 1 449 448 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m915 449 448 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m916 1 451 450 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m917 451 450 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m918 1 453 452 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m919 1 452 453 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m920 1 455 454 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m921 1 454 455 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m922 0 453 452 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m923 453 452 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m924 0 455 454 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m925 455 454 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m926 224 163 452 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m927 225 163 453 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m928 226 163 454 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m929 227 163 455 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m930 456 168 224 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m931 457 168 225 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m932 458 168 226 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m933 459 168 227 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m934 0 457 456 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m935 457 456 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m936 0 459 458 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m937 459 458 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m938 1 457 456 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m939 457 456 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m940 1 459 458 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m941 459 458 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m942 1 461 460 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m943 1 460 461 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m944 1 463 462 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m945 1 462 463 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m946 0 461 460 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m947 461 460 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m948 0 463 462 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m949 463 462 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m950 223 168 460 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m951 222 168 461 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m952 221 168 462 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m953 220 168 463 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m954 464 163 223 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m955 465 163 222 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m956 466 163 221 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m957 467 163 220 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m958 0 465 464 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m959 465 464 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m960 0 467 466 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m961 467 466 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m962 1 465 464 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m963 465 464 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m964 1 467 466 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m965 467 466 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m966 1 469 468 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m967 1 468 469 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m968 1 471 470 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m969 1 470 471 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m970 0 469 468 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m971 469 468 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m972 0 471 470 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m973 471 470 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m974 232 163 468 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m975 233 163 469 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m976 234 163 470 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m977 235 163 471 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m978 472 168 232 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m979 473 168 233 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m980 474 168 234 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m981 475 168 235 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m982 0 473 472 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m983 473 472 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m984 0 475 474 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m985 475 474 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m986 1 473 472 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m987 473 472 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m988 1 475 474 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m989 475 474 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m990 1 477 476 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m991 1 476 477 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m992 1 479 478 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m993 1 478 479 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m994 0 477 476 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m995 477 476 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m996 0 479 478 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m997 479 478 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m998 231 168 476 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m999 230 168 477 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1000 229 168 478 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1001 228 168 479 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1002 480 163 231 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1003 481 163 230 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1004 482 163 229 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1005 483 163 228 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1006 0 481 480 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1007 481 480 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1008 0 483 482 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1009 483 482 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1010 1 481 480 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1011 481 480 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1012 1 483 482 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1013 483 482 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1014 1 485 484 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1015 1 484 485 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1016 1 487 486 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1017 1 486 487 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1018 0 485 484 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1019 485 484 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1020 0 487 486 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1021 487 486 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1022 240 163 484 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1023 241 163 485 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1024 242 163 486 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1025 243 163 487 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m1026 488 168 240 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1027 489 168 241 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1028 490 168 242 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1029 491 168 243 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m1030 0 489 488 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1031 489 488 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1032 0 491 490 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1033 491 490 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1034 1 489 488 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1035 489 488 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1036 1 491 490 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1037 491 490 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1038 1 493 492 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1039 1 492 493 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1040 1 495 494 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1041 1 494 495 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1042 0 493 492 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1043 493 492 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1044 0 495 494 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1045 495 494 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1046 239 168 492 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1047 238 168 493 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1048 237 168 494 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1049 236 168 495 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1050 496 163 239 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1051 497 163 238 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1052 498 163 237 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1053 499 163 236 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1054 0 497 496 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1055 497 496 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1056 0 499 498 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1057 499 498 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1058 1 497 496 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1059 497 496 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1060 1 499 498 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1061 499 498 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1062 1 501 500 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1063 1 500 501 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1064 1 503 502 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1065 1 502 503 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1066 0 501 500 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1067 501 500 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1068 0 503 502 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1069 503 502 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1070 184 153 500 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1071 185 153 501 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1072 186 153 502 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1073 187 153 503 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m1074 504 157 184 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1075 505 157 185 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1076 506 157 186 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1077 507 157 187 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m1078 0 505 504 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1079 505 504 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1080 0 507 506 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1081 507 506 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1082 1 505 504 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1083 505 504 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1084 1 507 506 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1085 507 506 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1086 1 509 508 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1087 1 508 509 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1088 1 511 510 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1089 1 510 511 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1090 0 509 508 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1091 509 508 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1092 0 511 510 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1093 511 510 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1094 183 157 508 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1095 182 157 509 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1096 181 157 510 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1097 180 157 511 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1098 512 153 183 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1099 513 153 182 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1100 514 153 181 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1101 515 153 180 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1102 0 513 512 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1103 513 512 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1104 0 515 514 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1105 515 514 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1106 1 513 512 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1107 513 512 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1108 1 515 514 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1109 515 514 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1110 1 517 516 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1111 1 516 517 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1112 1 519 518 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1113 1 518 519 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1114 0 517 516 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1115 517 516 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1116 0 519 518 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1117 519 518 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1118 192 153 516 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1119 193 153 517 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1120 194 153 518 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1121 195 153 519 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m1122 520 157 192 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1123 521 157 193 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1124 522 157 194 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1125 523 157 195 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m1126 0 521 520 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1127 521 520 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1128 0 523 522 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1129 523 522 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1130 1 521 520 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1131 521 520 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1132 1 523 522 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1133 523 522 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1134 1 525 524 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1135 1 524 525 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1136 1 527 526 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1137 1 526 527 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1138 0 525 524 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1139 525 524 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1140 0 527 526 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1141 527 526 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1142 191 157 524 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1143 190 157 525 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1144 189 157 526 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1145 188 157 527 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1146 528 153 191 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1147 529 153 190 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1148 530 153 189 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1149 531 153 188 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1150 0 529 528 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1151 529 528 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1152 0 531 530 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1153 531 530 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1154 1 529 528 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1155 529 528 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1156 1 531 530 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1157 531 530 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1158 1 533 532 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1159 1 532 533 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1160 1 535 534 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1161 1 534 535 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1162 0 533 532 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1163 533 532 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1164 0 535 534 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1165 535 534 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1166 200 153 532 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1167 201 153 533 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1168 202 153 534 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1169 203 153 535 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m1170 536 157 200 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1171 537 157 201 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1172 538 157 202 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1173 539 157 203 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m1174 0 537 536 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1175 537 536 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1176 0 539 538 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1177 539 538 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1178 1 537 536 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1179 537 536 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1180 1 539 538 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1181 539 538 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1182 1 541 540 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1183 1 540 541 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1184 1 543 542 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1185 1 542 543 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1186 0 541 540 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1187 541 540 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1188 0 543 542 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1189 543 542 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1190 199 157 540 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1191 198 157 541 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1192 197 157 542 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1193 196 157 543 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1194 544 153 199 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1195 545 153 198 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1196 546 153 197 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1197 547 153 196 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1198 0 545 544 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1199 545 544 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1200 0 547 546 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1201 547 546 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1202 1 545 544 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1203 545 544 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1204 1 547 546 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1205 547 546 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1206 1 549 548 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1207 1 548 549 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1208 1 551 550 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1209 1 550 551 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1210 0 549 548 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1211 549 548 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1212 0 551 550 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1213 551 550 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1214 208 153 548 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1215 209 153 549 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1216 210 153 550 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1217 211 153 551 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m1218 552 157 208 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1219 553 157 209 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1220 554 157 210 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1221 555 157 211 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m1222 0 553 552 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1223 553 552 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1224 0 555 554 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1225 555 554 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1226 1 553 552 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1227 553 552 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1228 1 555 554 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1229 555 554 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1230 1 557 556 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1231 1 556 557 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1232 1 559 558 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1233 1 558 559 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1234 0 557 556 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1235 557 556 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1236 0 559 558 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1237 559 558 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1238 207 157 556 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1239 206 157 557 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1240 205 157 558 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1241 204 157 559 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1242 560 153 207 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1243 561 153 206 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1244 562 153 205 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1245 563 153 204 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1246 0 561 560 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1247 561 560 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1248 0 563 562 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1249 563 562 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1250 1 561 560 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1251 561 560 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1252 1 563 562 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1253 563 562 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1254 1 565 564 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1255 1 564 565 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1256 1 567 566 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1257 1 566 567 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1258 0 565 564 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1259 565 564 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1260 0 567 566 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1261 567 566 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1262 216 153 564 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1263 217 153 565 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1264 218 153 566 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1265 219 153 567 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m1266 568 157 216 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1267 569 157 217 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1268 570 157 218 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1269 571 157 219 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m1270 0 569 568 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1271 569 568 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1272 0 571 570 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1273 571 570 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1274 1 569 568 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1275 569 568 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1276 1 571 570 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1277 571 570 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1278 1 573 572 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1279 1 572 573 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1280 1 575 574 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1281 1 574 575 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1282 0 573 572 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1283 573 572 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1284 0 575 574 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1285 575 574 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1286 215 157 572 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1287 214 157 573 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1288 213 157 574 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1289 212 157 575 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1290 576 153 215 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1291 577 153 214 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1292 578 153 213 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1293 579 153 212 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1294 0 577 576 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1295 577 576 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1296 0 579 578 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1297 579 578 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1298 1 577 576 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1299 577 576 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1300 1 579 578 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1301 579 578 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1302 1 581 580 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1303 1 580 581 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1304 1 583 582 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1305 1 582 583 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1306 0 581 580 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1307 581 580 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1308 0 583 582 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1309 583 582 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1310 224 153 580 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1311 225 153 581 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1312 226 153 582 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1313 227 153 583 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m1314 584 157 224 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1315 585 157 225 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1316 586 157 226 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1317 587 157 227 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m1318 0 585 584 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1319 585 584 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1320 0 587 586 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1321 587 586 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1322 1 585 584 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1323 585 584 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1324 1 587 586 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1325 587 586 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1326 1 589 588 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1327 1 588 589 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1328 1 591 590 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1329 1 590 591 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1330 0 589 588 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1331 589 588 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1332 0 591 590 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1333 591 590 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1334 223 157 588 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1335 222 157 589 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1336 221 157 590 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1337 220 157 591 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1338 592 153 223 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1339 593 153 222 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1340 594 153 221 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1341 595 153 220 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1342 0 593 592 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1343 593 592 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1344 0 595 594 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1345 595 594 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1346 1 593 592 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1347 593 592 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1348 1 595 594 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1349 595 594 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1350 1 597 596 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1351 1 596 597 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1352 1 599 598 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1353 1 598 599 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1354 0 597 596 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1355 597 596 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1356 0 599 598 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1357 599 598 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1358 232 153 596 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1359 233 153 597 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1360 234 153 598 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1361 235 153 599 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m1362 600 157 232 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1363 601 157 233 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1364 602 157 234 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1365 603 157 235 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m1366 0 601 600 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1367 601 600 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1368 0 603 602 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1369 603 602 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1370 1 601 600 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1371 601 600 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1372 1 603 602 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1373 603 602 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1374 1 605 604 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1375 1 604 605 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1376 1 607 606 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1377 1 606 607 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1378 0 605 604 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1379 605 604 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1380 0 607 606 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1381 607 606 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1382 231 157 604 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1383 230 157 605 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1384 229 157 606 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1385 228 157 607 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1386 608 153 231 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1387 609 153 230 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1388 610 153 229 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1389 611 153 228 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1390 0 609 608 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1391 609 608 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1392 0 611 610 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1393 611 610 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1394 1 609 608 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1395 609 608 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1396 1 611 610 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1397 611 610 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1398 1 613 612 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1399 1 612 613 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1400 1 615 614 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1401 1 614 615 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1402 0 613 612 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1403 613 612 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1404 0 615 614 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1405 615 614 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1406 240 153 612 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1407 241 153 613 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1408 242 153 614 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1409 243 153 615 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m1410 616 157 240 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1411 617 157 241 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1412 618 157 242 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1413 619 157 243 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m1414 0 617 616 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1415 617 616 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1416 0 619 618 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1417 619 618 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1418 1 617 616 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1419 617 616 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1420 1 619 618 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1421 619 618 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1422 1 621 620 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1423 1 620 621 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1424 1 623 622 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1425 1 622 623 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1426 0 621 620 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1427 621 620 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1428 0 623 622 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1429 623 622 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1430 239 157 620 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1431 238 157 621 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1432 237 157 622 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1433 236 157 623 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1434 624 153 239 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1435 625 153 238 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1436 626 153 237 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1437 627 153 236 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1438 0 625 624 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1439 625 624 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1440 0 627 626 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1441 627 626 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1442 1 625 624 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1443 625 624 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1444 1 627 626 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1445 627 626 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1446 1 629 628 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1447 1 628 629 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1448 1 631 630 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1449 1 630 631 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1450 0 629 628 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1451 629 628 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1452 0 631 630 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1453 631 630 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1454 184 142 628 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1455 185 142 629 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1456 186 142 630 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1457 187 142 631 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m1458 632 147 184 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1459 633 147 185 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1460 634 147 186 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1461 635 147 187 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m1462 0 633 632 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1463 633 632 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1464 0 635 634 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1465 635 634 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1466 1 633 632 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1467 633 632 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1468 1 635 634 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1469 635 634 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1470 1 637 636 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1471 1 636 637 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1472 1 639 638 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1473 1 638 639 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1474 0 637 636 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1475 637 636 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1476 0 639 638 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1477 639 638 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1478 183 147 636 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1479 182 147 637 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1480 181 147 638 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1481 180 147 639 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1482 640 142 183 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1483 641 142 182 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1484 642 142 181 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1485 643 142 180 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1486 0 641 640 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1487 641 640 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1488 0 643 642 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1489 643 642 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1490 1 641 640 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1491 641 640 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1492 1 643 642 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1493 643 642 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1494 1 645 644 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1495 1 644 645 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1496 1 647 646 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1497 1 646 647 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1498 0 645 644 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1499 645 644 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1500 0 647 646 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1501 647 646 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1502 192 142 644 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1503 193 142 645 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1504 194 142 646 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1505 195 142 647 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m1506 648 147 192 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1507 649 147 193 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1508 650 147 194 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1509 651 147 195 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m1510 0 649 648 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1511 649 648 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1512 0 651 650 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1513 651 650 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1514 1 649 648 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1515 649 648 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1516 1 651 650 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1517 651 650 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1518 1 653 652 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1519 1 652 653 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1520 1 655 654 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1521 1 654 655 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1522 0 653 652 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1523 653 652 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1524 0 655 654 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1525 655 654 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1526 191 147 652 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1527 190 147 653 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1528 189 147 654 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1529 188 147 655 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1530 656 142 191 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1531 657 142 190 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1532 658 142 189 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1533 659 142 188 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1534 0 657 656 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1535 657 656 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1536 0 659 658 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1537 659 658 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1538 1 657 656 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1539 657 656 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1540 1 659 658 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1541 659 658 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1542 1 661 660 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1543 1 660 661 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1544 1 663 662 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1545 1 662 663 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1546 0 661 660 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1547 661 660 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1548 0 663 662 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1549 663 662 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1550 200 142 660 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1551 201 142 661 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1552 202 142 662 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1553 203 142 663 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m1554 664 147 200 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1555 665 147 201 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1556 666 147 202 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1557 667 147 203 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m1558 0 665 664 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1559 665 664 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1560 0 667 666 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1561 667 666 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1562 1 665 664 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1563 665 664 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1564 1 667 666 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1565 667 666 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1566 1 669 668 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1567 1 668 669 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1568 1 671 670 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1569 1 670 671 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1570 0 669 668 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1571 669 668 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1572 0 671 670 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1573 671 670 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1574 199 147 668 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1575 198 147 669 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1576 197 147 670 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1577 196 147 671 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1578 672 142 199 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1579 673 142 198 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1580 674 142 197 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1581 675 142 196 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1582 0 673 672 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1583 673 672 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1584 0 675 674 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1585 675 674 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1586 1 673 672 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1587 673 672 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1588 1 675 674 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1589 675 674 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1590 1 677 676 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1591 1 676 677 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1592 1 679 678 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1593 1 678 679 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1594 0 677 676 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1595 677 676 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1596 0 679 678 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1597 679 678 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1598 208 142 676 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1599 209 142 677 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1600 210 142 678 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1601 211 142 679 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m1602 680 147 208 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1603 681 147 209 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1604 682 147 210 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1605 683 147 211 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m1606 0 681 680 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1607 681 680 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1608 0 683 682 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1609 683 682 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1610 1 681 680 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1611 681 680 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1612 1 683 682 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1613 683 682 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1614 1 685 684 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1615 1 684 685 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1616 1 687 686 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1617 1 686 687 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1618 0 685 684 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1619 685 684 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1620 0 687 686 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1621 687 686 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1622 207 147 684 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1623 206 147 685 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1624 205 147 686 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1625 204 147 687 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1626 688 142 207 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1627 689 142 206 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1628 690 142 205 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1629 691 142 204 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1630 0 689 688 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1631 689 688 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1632 0 691 690 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1633 691 690 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1634 1 689 688 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1635 689 688 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1636 1 691 690 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1637 691 690 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1638 1 693 692 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1639 1 692 693 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1640 1 695 694 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1641 1 694 695 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1642 0 693 692 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1643 693 692 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1644 0 695 694 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1645 695 694 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1646 216 142 692 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1647 217 142 693 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1648 218 142 694 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1649 219 142 695 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m1650 696 147 216 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1651 697 147 217 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1652 698 147 218 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1653 699 147 219 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m1654 0 697 696 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1655 697 696 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1656 0 699 698 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1657 699 698 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1658 1 697 696 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1659 697 696 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1660 1 699 698 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1661 699 698 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1662 1 701 700 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1663 1 700 701 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1664 1 703 702 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1665 1 702 703 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1666 0 701 700 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1667 701 700 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1668 0 703 702 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1669 703 702 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1670 215 147 700 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1671 214 147 701 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1672 213 147 702 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1673 212 147 703 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1674 704 142 215 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1675 705 142 214 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1676 706 142 213 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1677 707 142 212 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1678 0 705 704 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1679 705 704 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1680 0 707 706 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1681 707 706 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1682 1 705 704 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1683 705 704 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1684 1 707 706 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1685 707 706 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1686 1 709 708 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1687 1 708 709 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1688 1 711 710 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1689 1 710 711 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1690 0 709 708 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1691 709 708 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1692 0 711 710 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1693 711 710 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1694 224 142 708 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1695 225 142 709 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1696 226 142 710 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1697 227 142 711 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m1698 712 147 224 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1699 713 147 225 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1700 714 147 226 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1701 715 147 227 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m1702 0 713 712 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1703 713 712 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1704 0 715 714 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1705 715 714 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1706 1 713 712 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1707 713 712 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1708 1 715 714 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1709 715 714 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1710 1 717 716 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1711 1 716 717 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1712 1 719 718 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1713 1 718 719 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1714 0 717 716 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1715 717 716 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1716 0 719 718 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1717 719 718 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1718 223 147 716 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1719 222 147 717 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1720 221 147 718 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1721 220 147 719 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1722 720 142 223 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1723 721 142 222 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1724 722 142 221 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1725 723 142 220 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1726 0 721 720 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1727 721 720 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1728 0 723 722 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1729 723 722 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1730 1 721 720 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1731 721 720 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1732 1 723 722 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1733 723 722 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1734 1 725 724 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1735 1 724 725 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1736 1 727 726 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1737 1 726 727 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1738 0 725 724 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1739 725 724 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1740 0 727 726 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1741 727 726 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1742 232 142 724 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1743 233 142 725 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1744 234 142 726 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1745 235 142 727 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m1746 728 147 232 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1747 729 147 233 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1748 730 147 234 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1749 731 147 235 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m1750 0 729 728 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1751 729 728 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1752 0 731 730 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1753 731 730 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1754 1 729 728 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1755 729 728 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1756 1 731 730 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1757 731 730 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1758 1 733 732 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1759 1 732 733 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1760 1 735 734 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1761 1 734 735 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1762 0 733 732 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1763 733 732 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1764 0 735 734 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1765 735 734 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1766 231 147 732 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1767 230 147 733 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1768 229 147 734 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1769 228 147 735 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1770 736 142 231 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1771 737 142 230 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1772 738 142 229 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1773 739 142 228 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1774 0 737 736 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1775 737 736 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1776 0 739 738 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1777 739 738 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1778 1 737 736 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1779 737 736 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1780 1 739 738 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1781 739 738 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1782 1 741 740 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1783 1 740 741 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1784 1 743 742 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1785 1 742 743 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1786 0 741 740 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1787 741 740 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1788 0 743 742 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1789 743 742 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1790 240 142 740 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1791 241 142 741 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1792 242 142 742 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1793 243 142 743 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m1794 744 147 240 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1795 745 147 241 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1796 746 147 242 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1797 747 147 243 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m1798 0 745 744 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1799 745 744 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1800 0 747 746 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1801 747 746 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1802 1 745 744 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1803 745 744 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1804 1 747 746 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1805 747 746 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1806 1 749 748 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1807 1 748 749 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1808 1 751 750 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1809 1 750 751 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1810 0 749 748 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1811 749 748 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1812 0 751 750 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1813 751 750 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1814 239 147 748 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1815 238 147 749 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1816 237 147 750 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1817 236 147 751 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1818 752 142 239 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1819 753 142 238 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1820 754 142 237 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1821 755 142 236 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1822 0 753 752 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1823 753 752 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1824 0 755 754 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1825 755 754 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1826 1 753 752 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1827 753 752 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1828 1 755 754 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1829 755 754 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1830 1 757 756 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1831 1 756 757 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1832 1 759 758 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1833 1 758 759 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1834 0 757 756 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1835 757 756 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1836 0 759 758 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1837 759 758 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1838 184 132 756 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1839 185 132 757 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1840 186 132 758 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1841 187 132 759 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m1842 760 136 184 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1843 761 136 185 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1844 762 136 186 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1845 763 136 187 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m1846 0 761 760 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1847 761 760 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1848 0 763 762 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1849 763 762 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1850 1 761 760 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1851 761 760 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1852 1 763 762 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1853 763 762 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1854 1 765 764 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1855 1 764 765 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1856 1 767 766 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1857 1 766 767 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1858 0 765 764 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1859 765 764 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1860 0 767 766 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1861 767 766 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1862 183 136 764 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1863 182 136 765 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1864 181 136 766 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1865 180 136 767 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1866 768 132 183 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1867 769 132 182 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1868 770 132 181 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1869 771 132 180 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1870 0 769 768 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1871 769 768 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1872 0 771 770 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1873 771 770 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1874 1 769 768 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1875 769 768 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1876 1 771 770 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1877 771 770 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1878 1 773 772 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1879 1 772 773 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1880 1 775 774 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1881 1 774 775 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1882 0 773 772 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1883 773 772 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1884 0 775 774 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1885 775 774 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1886 192 132 772 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1887 193 132 773 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1888 194 132 774 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1889 195 132 775 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m1890 776 136 192 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1891 777 136 193 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1892 778 136 194 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1893 779 136 195 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m1894 0 777 776 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1895 777 776 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1896 0 779 778 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1897 779 778 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1898 1 777 776 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1899 777 776 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1900 1 779 778 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1901 779 778 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1902 1 781 780 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1903 1 780 781 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1904 1 783 782 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1905 1 782 783 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1906 0 781 780 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1907 781 780 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1908 0 783 782 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1909 783 782 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1910 191 136 780 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1911 190 136 781 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1912 189 136 782 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1913 188 136 783 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1914 784 132 191 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1915 785 132 190 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1916 786 132 189 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1917 787 132 188 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1918 0 785 784 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1919 785 784 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1920 0 787 786 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1921 787 786 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1922 1 785 784 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1923 785 784 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1924 1 787 786 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1925 787 786 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1926 1 789 788 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1927 1 788 789 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1928 1 791 790 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1929 1 790 791 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1930 0 789 788 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1931 789 788 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1932 0 791 790 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1933 791 790 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1934 200 132 788 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1935 201 132 789 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1936 202 132 790 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1937 203 132 791 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m1938 792 136 200 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1939 793 136 201 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1940 794 136 202 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1941 795 136 203 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m1942 0 793 792 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1943 793 792 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1944 0 795 794 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1945 795 794 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1946 1 793 792 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1947 793 792 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1948 1 795 794 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1949 795 794 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1950 1 797 796 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1951 1 796 797 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1952 1 799 798 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1953 1 798 799 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1954 0 797 796 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1955 797 796 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1956 0 799 798 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1957 799 798 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1958 199 136 796 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1959 198 136 797 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1960 197 136 798 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1961 196 136 799 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1962 800 132 199 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1963 801 132 198 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1964 802 132 197 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1965 803 132 196 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1966 0 801 800 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1967 801 800 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1968 0 803 802 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1969 803 802 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1970 1 801 800 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1971 801 800 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1972 1 803 802 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1973 803 802 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1974 1 805 804 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1975 1 804 805 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1976 1 807 806 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1977 1 806 807 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1978 0 805 804 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1979 805 804 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1980 0 807 806 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1981 807 806 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1982 208 132 804 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m1983 209 132 805 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m1984 210 132 806 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m1985 211 132 807 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m1986 808 136 208 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m1987 809 136 209 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m1988 810 136 210 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m1989 811 136 211 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m1990 0 809 808 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m1991 809 808 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m1992 0 811 810 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m1993 811 810 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m1994 1 809 808 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1995 809 808 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1996 1 811 810 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1997 811 810 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m1998 1 813 812 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m1999 1 812 813 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2000 1 815 814 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2001 1 814 815 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2002 0 813 812 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2003 813 812 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2004 0 815 814 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2005 815 814 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2006 207 136 812 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2007 206 136 813 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2008 205 136 814 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2009 204 136 815 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2010 816 132 207 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2011 817 132 206 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2012 818 132 205 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2013 819 132 204 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2014 0 817 816 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2015 817 816 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2016 0 819 818 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2017 819 818 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2018 1 817 816 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2019 817 816 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2020 1 819 818 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2021 819 818 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2022 1 821 820 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2023 1 820 821 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2024 1 823 822 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2025 1 822 823 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2026 0 821 820 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2027 821 820 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2028 0 823 822 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2029 823 822 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2030 216 132 820 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2031 217 132 821 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2032 218 132 822 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2033 219 132 823 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m2034 824 136 216 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2035 825 136 217 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2036 826 136 218 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2037 827 136 219 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m2038 0 825 824 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2039 825 824 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2040 0 827 826 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2041 827 826 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2042 1 825 824 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2043 825 824 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2044 1 827 826 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2045 827 826 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2046 1 829 828 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2047 1 828 829 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2048 1 831 830 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2049 1 830 831 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2050 0 829 828 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2051 829 828 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2052 0 831 830 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2053 831 830 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2054 215 136 828 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2055 214 136 829 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2056 213 136 830 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2057 212 136 831 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2058 832 132 215 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2059 833 132 214 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2060 834 132 213 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2061 835 132 212 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2062 0 833 832 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2063 833 832 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2064 0 835 834 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2065 835 834 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2066 1 833 832 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2067 833 832 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2068 1 835 834 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2069 835 834 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2070 1 837 836 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2071 1 836 837 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2072 1 839 838 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2073 1 838 839 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2074 0 837 836 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2075 837 836 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2076 0 839 838 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2077 839 838 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2078 224 132 836 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2079 225 132 837 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2080 226 132 838 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2081 227 132 839 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m2082 840 136 224 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2083 841 136 225 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2084 842 136 226 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2085 843 136 227 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m2086 0 841 840 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2087 841 840 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2088 0 843 842 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2089 843 842 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2090 1 841 840 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2091 841 840 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2092 1 843 842 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2093 843 842 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2094 1 845 844 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2095 1 844 845 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2096 1 847 846 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2097 1 846 847 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2098 0 845 844 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2099 845 844 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2100 0 847 846 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2101 847 846 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2102 223 136 844 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2103 222 136 845 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2104 221 136 846 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2105 220 136 847 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2106 848 132 223 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2107 849 132 222 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2108 850 132 221 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2109 851 132 220 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2110 0 849 848 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2111 849 848 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2112 0 851 850 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2113 851 850 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2114 1 849 848 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2115 849 848 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2116 1 851 850 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2117 851 850 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2118 1 853 852 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2119 1 852 853 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2120 1 855 854 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2121 1 854 855 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2122 0 853 852 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2123 853 852 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2124 0 855 854 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2125 855 854 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2126 232 132 852 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2127 233 132 853 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2128 234 132 854 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2129 235 132 855 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m2130 856 136 232 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2131 857 136 233 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2132 858 136 234 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2133 859 136 235 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m2134 0 857 856 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2135 857 856 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2136 0 859 858 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2137 859 858 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2138 1 857 856 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2139 857 856 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2140 1 859 858 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2141 859 858 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2142 1 861 860 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2143 1 860 861 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2144 1 863 862 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2145 1 862 863 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2146 0 861 860 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2147 861 860 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2148 0 863 862 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2149 863 862 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2150 231 136 860 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2151 230 136 861 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2152 229 136 862 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2153 228 136 863 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2154 864 132 231 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2155 865 132 230 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2156 866 132 229 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2157 867 132 228 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2158 0 865 864 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2159 865 864 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2160 0 867 866 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2161 867 866 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2162 1 865 864 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2163 865 864 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2164 1 867 866 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2165 867 866 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2166 1 869 868 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2167 1 868 869 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2168 1 871 870 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2169 1 870 871 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2170 0 869 868 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2171 869 868 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2172 0 871 870 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2173 871 870 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2174 240 132 868 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2175 241 132 869 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2176 242 132 870 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2177 243 132 871 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m2178 872 136 240 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2179 873 136 241 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2180 874 136 242 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2181 875 136 243 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m2182 0 873 872 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2183 873 872 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2184 0 875 874 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2185 875 874 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2186 1 873 872 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2187 873 872 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2188 1 875 874 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2189 875 874 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2190 1 877 876 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2191 1 876 877 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2192 1 879 878 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2193 1 878 879 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2194 0 877 876 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2195 877 876 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2196 0 879 878 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2197 879 878 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2198 239 136 876 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2199 238 136 877 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2200 237 136 878 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2201 236 136 879 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2202 880 132 239 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2203 881 132 238 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2204 882 132 237 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2205 883 132 236 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2206 0 881 880 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2207 881 880 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2208 0 883 882 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2209 883 882 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2210 1 881 880 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2211 881 880 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2212 1 883 882 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2213 883 882 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2214 1 885 884 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2215 1 884 885 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2216 1 887 886 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2217 1 886 887 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2218 0 885 884 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2219 885 884 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2220 0 887 886 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2221 887 886 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2222 184 121 884 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2223 185 121 885 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2224 186 121 886 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2225 187 121 887 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m2226 888 126 184 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2227 889 126 185 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2228 890 126 186 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2229 891 126 187 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m2230 0 889 888 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2231 889 888 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2232 0 891 890 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2233 891 890 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2234 1 889 888 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2235 889 888 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2236 1 891 890 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2237 891 890 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2238 1 893 892 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2239 1 892 893 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2240 1 895 894 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2241 1 894 895 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2242 0 893 892 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2243 893 892 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2244 0 895 894 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2245 895 894 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2246 183 126 892 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2247 182 126 893 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2248 181 126 894 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2249 180 126 895 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2250 896 121 183 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2251 897 121 182 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2252 898 121 181 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2253 899 121 180 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2254 0 897 896 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2255 897 896 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2256 0 899 898 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2257 899 898 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2258 1 897 896 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2259 897 896 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2260 1 899 898 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2261 899 898 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2262 1 901 900 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2263 1 900 901 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2264 1 903 902 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2265 1 902 903 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2266 0 901 900 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2267 901 900 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2268 0 903 902 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2269 903 902 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2270 192 121 900 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2271 193 121 901 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2272 194 121 902 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2273 195 121 903 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m2274 904 126 192 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2275 905 126 193 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2276 906 126 194 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2277 907 126 195 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m2278 0 905 904 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2279 905 904 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2280 0 907 906 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2281 907 906 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2282 1 905 904 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2283 905 904 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2284 1 907 906 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2285 907 906 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2286 1 909 908 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2287 1 908 909 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2288 1 911 910 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2289 1 910 911 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2290 0 909 908 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2291 909 908 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2292 0 911 910 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2293 911 910 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2294 191 126 908 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2295 190 126 909 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2296 189 126 910 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2297 188 126 911 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2298 912 121 191 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2299 913 121 190 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2300 914 121 189 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2301 915 121 188 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2302 0 913 912 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2303 913 912 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2304 0 915 914 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2305 915 914 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2306 1 913 912 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2307 913 912 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2308 1 915 914 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2309 915 914 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2310 1 917 916 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2311 1 916 917 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2312 1 919 918 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2313 1 918 919 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2314 0 917 916 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2315 917 916 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2316 0 919 918 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2317 919 918 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2318 200 121 916 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2319 201 121 917 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2320 202 121 918 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2321 203 121 919 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m2322 920 126 200 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2323 921 126 201 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2324 922 126 202 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2325 923 126 203 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m2326 0 921 920 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2327 921 920 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2328 0 923 922 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2329 923 922 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2330 1 921 920 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2331 921 920 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2332 1 923 922 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2333 923 922 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2334 1 925 924 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2335 1 924 925 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2336 1 927 926 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2337 1 926 927 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2338 0 925 924 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2339 925 924 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2340 0 927 926 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2341 927 926 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2342 199 126 924 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2343 198 126 925 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2344 197 126 926 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2345 196 126 927 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2346 928 121 199 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2347 929 121 198 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2348 930 121 197 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2349 931 121 196 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2350 0 929 928 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2351 929 928 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2352 0 931 930 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2353 931 930 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2354 1 929 928 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2355 929 928 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2356 1 931 930 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2357 931 930 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2358 1 933 932 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2359 1 932 933 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2360 1 935 934 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2361 1 934 935 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2362 0 933 932 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2363 933 932 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2364 0 935 934 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2365 935 934 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2366 208 121 932 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2367 209 121 933 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2368 210 121 934 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2369 211 121 935 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m2370 936 126 208 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2371 937 126 209 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2372 938 126 210 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2373 939 126 211 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m2374 0 937 936 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2375 937 936 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2376 0 939 938 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2377 939 938 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2378 1 937 936 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2379 937 936 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2380 1 939 938 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2381 939 938 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2382 1 941 940 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2383 1 940 941 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2384 1 943 942 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2385 1 942 943 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2386 0 941 940 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2387 941 940 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2388 0 943 942 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2389 943 942 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2390 207 126 940 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2391 206 126 941 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2392 205 126 942 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2393 204 126 943 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2394 944 121 207 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2395 945 121 206 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2396 946 121 205 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2397 947 121 204 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2398 0 945 944 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2399 945 944 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2400 0 947 946 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2401 947 946 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2402 1 945 944 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2403 945 944 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2404 1 947 946 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2405 947 946 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2406 1 949 948 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2407 1 948 949 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2408 1 951 950 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2409 1 950 951 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2410 0 949 948 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2411 949 948 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2412 0 951 950 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2413 951 950 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2414 216 121 948 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2415 217 121 949 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2416 218 121 950 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2417 219 121 951 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m2418 952 126 216 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2419 953 126 217 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2420 954 126 218 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2421 955 126 219 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m2422 0 953 952 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2423 953 952 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2424 0 955 954 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2425 955 954 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2426 1 953 952 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2427 953 952 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2428 1 955 954 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2429 955 954 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2430 1 957 956 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2431 1 956 957 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2432 1 959 958 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2433 1 958 959 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2434 0 957 956 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2435 957 956 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2436 0 959 958 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2437 959 958 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2438 215 126 956 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2439 214 126 957 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2440 213 126 958 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2441 212 126 959 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2442 960 121 215 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2443 961 121 214 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2444 962 121 213 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2445 963 121 212 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2446 0 961 960 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2447 961 960 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2448 0 963 962 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2449 963 962 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2450 1 961 960 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2451 961 960 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2452 1 963 962 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2453 963 962 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2454 1 965 964 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2455 1 964 965 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2456 1 967 966 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2457 1 966 967 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2458 0 965 964 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2459 965 964 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2460 0 967 966 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2461 967 966 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2462 224 121 964 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2463 225 121 965 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2464 226 121 966 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2465 227 121 967 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m2466 968 126 224 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2467 969 126 225 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2468 970 126 226 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2469 971 126 227 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m2470 0 969 968 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2471 969 968 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2472 0 971 970 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2473 971 970 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2474 1 969 968 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2475 969 968 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2476 1 971 970 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2477 971 970 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2478 1 973 972 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2479 1 972 973 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2480 1 975 974 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2481 1 974 975 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2482 0 973 972 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2483 973 972 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2484 0 975 974 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2485 975 974 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2486 223 126 972 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2487 222 126 973 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2488 221 126 974 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2489 220 126 975 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2490 976 121 223 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2491 977 121 222 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2492 978 121 221 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2493 979 121 220 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2494 0 977 976 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2495 977 976 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2496 0 979 978 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2497 979 978 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2498 1 977 976 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2499 977 976 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2500 1 979 978 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2501 979 978 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2502 1 981 980 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2503 1 980 981 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2504 1 983 982 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2505 1 982 983 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2506 0 981 980 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2507 981 980 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2508 0 983 982 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2509 983 982 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2510 232 121 980 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2511 233 121 981 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2512 234 121 982 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2513 235 121 983 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m2514 984 126 232 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2515 985 126 233 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2516 986 126 234 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2517 987 126 235 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m2518 0 985 984 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2519 985 984 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2520 0 987 986 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2521 987 986 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2522 1 985 984 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2523 985 984 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2524 1 987 986 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2525 987 986 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2526 1 989 988 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2527 1 988 989 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2528 1 991 990 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2529 1 990 991 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2530 0 989 988 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2531 989 988 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2532 0 991 990 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2533 991 990 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2534 231 126 988 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2535 230 126 989 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2536 229 126 990 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2537 228 126 991 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2538 992 121 231 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2539 993 121 230 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2540 994 121 229 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2541 995 121 228 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2542 0 993 992 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2543 993 992 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2544 0 995 994 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2545 995 994 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2546 1 993 992 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2547 993 992 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2548 1 995 994 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2549 995 994 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2550 1 997 996 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2551 1 996 997 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2552 1 999 998 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2553 1 998 999 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2554 0 997 996 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2555 997 996 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2556 0 999 998 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2557 999 998 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2558 240 121 996 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2559 241 121 997 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2560 242 121 998 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2561 243 121 999 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m2562 1000 126 240 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2563 1001 126 241 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2564 1002 126 242 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2565 1003 126 243 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m2566 0 1001 1000 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2567 1001 1000 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2568 0 1003 1002 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2569 1003 1002 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2570 1 1001 1000 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2571 1001 1000 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2572 1 1003 1002 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2573 1003 1002 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2574 1 1005 1004 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2575 1 1004 1005 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2576 1 1007 1006 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2577 1 1006 1007 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2578 0 1005 1004 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2579 1005 1004 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2580 0 1007 1006 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2581 1007 1006 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2582 239 126 1004 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2583 238 126 1005 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2584 237 126 1006 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2585 236 126 1007 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2586 1008 121 239 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2587 1009 121 238 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2588 1010 121 237 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2589 1011 121 236 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2590 0 1009 1008 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2591 1009 1008 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2592 0 1011 1010 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2593 1011 1010 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2594 1 1009 1008 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2595 1009 1008 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2596 1 1011 1010 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2597 1011 1010 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2598 1 1013 1012 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2599 1 1012 1013 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2600 1 1015 1014 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2601 1 1014 1015 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2602 0 1013 1012 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2603 1013 1012 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2604 0 1015 1014 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2605 1015 1014 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2606 184 111 1012 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2607 185 111 1013 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2608 186 111 1014 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2609 187 111 1015 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m2610 1016 115 184 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2611 1017 115 185 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2612 1018 115 186 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2613 1019 115 187 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m2614 0 1017 1016 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2615 1017 1016 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2616 0 1019 1018 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2617 1019 1018 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2618 1 1017 1016 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2619 1017 1016 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2620 1 1019 1018 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2621 1019 1018 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2622 1 1021 1020 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2623 1 1020 1021 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2624 1 1023 1022 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2625 1 1022 1023 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2626 0 1021 1020 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2627 1021 1020 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2628 0 1023 1022 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2629 1023 1022 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2630 183 115 1020 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2631 182 115 1021 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2632 181 115 1022 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2633 180 115 1023 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2634 1024 111 183 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2635 1025 111 182 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2636 1026 111 181 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2637 1027 111 180 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2638 0 1025 1024 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2639 1025 1024 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2640 0 1027 1026 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2641 1027 1026 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2642 1 1025 1024 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2643 1025 1024 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2644 1 1027 1026 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2645 1027 1026 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2646 1 1029 1028 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2647 1 1028 1029 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2648 1 1031 1030 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2649 1 1030 1031 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2650 0 1029 1028 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2651 1029 1028 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2652 0 1031 1030 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2653 1031 1030 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2654 192 111 1028 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2655 193 111 1029 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2656 194 111 1030 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2657 195 111 1031 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m2658 1032 115 192 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2659 1033 115 193 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2660 1034 115 194 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2661 1035 115 195 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m2662 0 1033 1032 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2663 1033 1032 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2664 0 1035 1034 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2665 1035 1034 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2666 1 1033 1032 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2667 1033 1032 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2668 1 1035 1034 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2669 1035 1034 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2670 1 1037 1036 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2671 1 1036 1037 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2672 1 1039 1038 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2673 1 1038 1039 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2674 0 1037 1036 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2675 1037 1036 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2676 0 1039 1038 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2677 1039 1038 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2678 191 115 1036 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2679 190 115 1037 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2680 189 115 1038 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2681 188 115 1039 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2682 1040 111 191 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2683 1041 111 190 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2684 1042 111 189 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2685 1043 111 188 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2686 0 1041 1040 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2687 1041 1040 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2688 0 1043 1042 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2689 1043 1042 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2690 1 1041 1040 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2691 1041 1040 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2692 1 1043 1042 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2693 1043 1042 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2694 1 1045 1044 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2695 1 1044 1045 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2696 1 1047 1046 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2697 1 1046 1047 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2698 0 1045 1044 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2699 1045 1044 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2700 0 1047 1046 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2701 1047 1046 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2702 200 111 1044 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2703 201 111 1045 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2704 202 111 1046 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2705 203 111 1047 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m2706 1048 115 200 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2707 1049 115 201 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2708 1050 115 202 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2709 1051 115 203 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m2710 0 1049 1048 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2711 1049 1048 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2712 0 1051 1050 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2713 1051 1050 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2714 1 1049 1048 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2715 1049 1048 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2716 1 1051 1050 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2717 1051 1050 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2718 1 1053 1052 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2719 1 1052 1053 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2720 1 1055 1054 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2721 1 1054 1055 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2722 0 1053 1052 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2723 1053 1052 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2724 0 1055 1054 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2725 1055 1054 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2726 199 115 1052 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2727 198 115 1053 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2728 197 115 1054 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2729 196 115 1055 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2730 1056 111 199 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2731 1057 111 198 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2732 1058 111 197 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2733 1059 111 196 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2734 0 1057 1056 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2735 1057 1056 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2736 0 1059 1058 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2737 1059 1058 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2738 1 1057 1056 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2739 1057 1056 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2740 1 1059 1058 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2741 1059 1058 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2742 1 1061 1060 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2743 1 1060 1061 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2744 1 1063 1062 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2745 1 1062 1063 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2746 0 1061 1060 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2747 1061 1060 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2748 0 1063 1062 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2749 1063 1062 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2750 208 111 1060 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2751 209 111 1061 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2752 210 111 1062 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2753 211 111 1063 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m2754 1064 115 208 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2755 1065 115 209 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2756 1066 115 210 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2757 1067 115 211 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m2758 0 1065 1064 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2759 1065 1064 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2760 0 1067 1066 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2761 1067 1066 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2762 1 1065 1064 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2763 1065 1064 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2764 1 1067 1066 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2765 1067 1066 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2766 1 1069 1068 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2767 1 1068 1069 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2768 1 1071 1070 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2769 1 1070 1071 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2770 0 1069 1068 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2771 1069 1068 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2772 0 1071 1070 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2773 1071 1070 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2774 207 115 1068 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2775 206 115 1069 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2776 205 115 1070 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2777 204 115 1071 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2778 1072 111 207 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2779 1073 111 206 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2780 1074 111 205 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2781 1075 111 204 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2782 0 1073 1072 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2783 1073 1072 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2784 0 1075 1074 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2785 1075 1074 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2786 1 1073 1072 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2787 1073 1072 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2788 1 1075 1074 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2789 1075 1074 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2790 1 1077 1076 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2791 1 1076 1077 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2792 1 1079 1078 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2793 1 1078 1079 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2794 0 1077 1076 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2795 1077 1076 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2796 0 1079 1078 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2797 1079 1078 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2798 216 111 1076 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2799 217 111 1077 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2800 218 111 1078 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2801 219 111 1079 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m2802 1080 115 216 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2803 1081 115 217 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2804 1082 115 218 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2805 1083 115 219 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m2806 0 1081 1080 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2807 1081 1080 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2808 0 1083 1082 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2809 1083 1082 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2810 1 1081 1080 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2811 1081 1080 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2812 1 1083 1082 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2813 1083 1082 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2814 1 1085 1084 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2815 1 1084 1085 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2816 1 1087 1086 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2817 1 1086 1087 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2818 0 1085 1084 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2819 1085 1084 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2820 0 1087 1086 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2821 1087 1086 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2822 215 115 1084 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2823 214 115 1085 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2824 213 115 1086 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2825 212 115 1087 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2826 1088 111 215 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2827 1089 111 214 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2828 1090 111 213 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2829 1091 111 212 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2830 0 1089 1088 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2831 1089 1088 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2832 0 1091 1090 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2833 1091 1090 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2834 1 1089 1088 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2835 1089 1088 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2836 1 1091 1090 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2837 1091 1090 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2838 1 1093 1092 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2839 1 1092 1093 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2840 1 1095 1094 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2841 1 1094 1095 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2842 0 1093 1092 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2843 1093 1092 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2844 0 1095 1094 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2845 1095 1094 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2846 224 111 1092 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2847 225 111 1093 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2848 226 111 1094 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2849 227 111 1095 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m2850 1096 115 224 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2851 1097 115 225 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2852 1098 115 226 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2853 1099 115 227 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m2854 0 1097 1096 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2855 1097 1096 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2856 0 1099 1098 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2857 1099 1098 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2858 1 1097 1096 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2859 1097 1096 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2860 1 1099 1098 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2861 1099 1098 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2862 1 1101 1100 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2863 1 1100 1101 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2864 1 1103 1102 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2865 1 1102 1103 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2866 0 1101 1100 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2867 1101 1100 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2868 0 1103 1102 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2869 1103 1102 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2870 223 115 1100 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2871 222 115 1101 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2872 221 115 1102 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2873 220 115 1103 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2874 1104 111 223 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2875 1105 111 222 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2876 1106 111 221 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2877 1107 111 220 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2878 0 1105 1104 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2879 1105 1104 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2880 0 1107 1106 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2881 1107 1106 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2882 1 1105 1104 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2883 1105 1104 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2884 1 1107 1106 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2885 1107 1106 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2886 1 1109 1108 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2887 1 1108 1109 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2888 1 1111 1110 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2889 1 1110 1111 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2890 0 1109 1108 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2891 1109 1108 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2892 0 1111 1110 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2893 1111 1110 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2894 232 111 1108 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2895 233 111 1109 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2896 234 111 1110 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2897 235 111 1111 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m2898 1112 115 232 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2899 1113 115 233 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2900 1114 115 234 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2901 1115 115 235 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m2902 0 1113 1112 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2903 1113 1112 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2904 0 1115 1114 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2905 1115 1114 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2906 1 1113 1112 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2907 1113 1112 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2908 1 1115 1114 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2909 1115 1114 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2910 1 1117 1116 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2911 1 1116 1117 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2912 1 1119 1118 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2913 1 1118 1119 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2914 0 1117 1116 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2915 1117 1116 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2916 0 1119 1118 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2917 1119 1118 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2918 231 115 1116 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2919 230 115 1117 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2920 229 115 1118 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2921 228 115 1119 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2922 1120 111 231 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2923 1121 111 230 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2924 1122 111 229 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2925 1123 111 228 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2926 0 1121 1120 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2927 1121 1120 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2928 0 1123 1122 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2929 1123 1122 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2930 1 1121 1120 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2931 1121 1120 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2932 1 1123 1122 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2933 1123 1122 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2934 1 1125 1124 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2935 1 1124 1125 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2936 1 1127 1126 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2937 1 1126 1127 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2938 0 1125 1124 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2939 1125 1124 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2940 0 1127 1126 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2941 1127 1126 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2942 240 111 1124 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2943 241 111 1125 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2944 242 111 1126 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2945 243 111 1127 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m2946 1128 115 240 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2947 1129 115 241 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2948 1130 115 242 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2949 1131 115 243 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m2950 0 1129 1128 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2951 1129 1128 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2952 0 1131 1130 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2953 1131 1130 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2954 1 1129 1128 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2955 1129 1128 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2956 1 1131 1130 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2957 1131 1130 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2958 1 1133 1132 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2959 1 1132 1133 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2960 1 1135 1134 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2961 1 1134 1135 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2962 0 1133 1132 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2963 1133 1132 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2964 0 1135 1134 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2965 1135 1134 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2966 239 115 1132 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2967 238 115 1133 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2968 237 115 1134 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2969 236 115 1135 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2970 1136 111 239 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2971 1137 111 238 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2972 1138 111 237 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2973 1139 111 236 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2974 0 1137 1136 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2975 1137 1136 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2976 0 1139 1138 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2977 1139 1138 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2978 1 1137 1136 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2979 1137 1136 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2980 1 1139 1138 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2981 1139 1138 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m2982 1 1141 1140 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2983 1 1140 1141 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2984 1 1143 1142 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2985 1 1142 1143 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m2986 0 1141 1140 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2987 1141 1140 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m2988 0 1143 1142 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m2989 1143 1142 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m2990 184 100 1140 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m2991 185 100 1141 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m2992 186 100 1142 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m2993 187 100 1143 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m2994 1144 105 184 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m2995 1145 105 185 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m2996 1146 105 186 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m2997 1147 105 187 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m2998 0 1145 1144 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m2999 1145 1144 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3000 0 1147 1146 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3001 1147 1146 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3002 1 1145 1144 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3003 1145 1144 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3004 1 1147 1146 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3005 1147 1146 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3006 1 1149 1148 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3007 1 1148 1149 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3008 1 1151 1150 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3009 1 1150 1151 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3010 0 1149 1148 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3011 1149 1148 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3012 0 1151 1150 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3013 1151 1150 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3014 183 105 1148 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3015 182 105 1149 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3016 181 105 1150 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3017 180 105 1151 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3018 1152 100 183 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3019 1153 100 182 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3020 1154 100 181 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3021 1155 100 180 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3022 0 1153 1152 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3023 1153 1152 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3024 0 1155 1154 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3025 1155 1154 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3026 1 1153 1152 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3027 1153 1152 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3028 1 1155 1154 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3029 1155 1154 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3030 1 1157 1156 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3031 1 1156 1157 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3032 1 1159 1158 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3033 1 1158 1159 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3034 0 1157 1156 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3035 1157 1156 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3036 0 1159 1158 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3037 1159 1158 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3038 192 100 1156 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3039 193 100 1157 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3040 194 100 1158 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3041 195 100 1159 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m3042 1160 105 192 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3043 1161 105 193 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3044 1162 105 194 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3045 1163 105 195 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m3046 0 1161 1160 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3047 1161 1160 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3048 0 1163 1162 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3049 1163 1162 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3050 1 1161 1160 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3051 1161 1160 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3052 1 1163 1162 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3053 1163 1162 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3054 1 1165 1164 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3055 1 1164 1165 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3056 1 1167 1166 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3057 1 1166 1167 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3058 0 1165 1164 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3059 1165 1164 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3060 0 1167 1166 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3061 1167 1166 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3062 191 105 1164 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3063 190 105 1165 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3064 189 105 1166 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3065 188 105 1167 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3066 1168 100 191 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3067 1169 100 190 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3068 1170 100 189 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3069 1171 100 188 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3070 0 1169 1168 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3071 1169 1168 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3072 0 1171 1170 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3073 1171 1170 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3074 1 1169 1168 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3075 1169 1168 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3076 1 1171 1170 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3077 1171 1170 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3078 1 1173 1172 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3079 1 1172 1173 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3080 1 1175 1174 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3081 1 1174 1175 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3082 0 1173 1172 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3083 1173 1172 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3084 0 1175 1174 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3085 1175 1174 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3086 200 100 1172 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3087 201 100 1173 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3088 202 100 1174 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3089 203 100 1175 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m3090 1176 105 200 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3091 1177 105 201 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3092 1178 105 202 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3093 1179 105 203 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m3094 0 1177 1176 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3095 1177 1176 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3096 0 1179 1178 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3097 1179 1178 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3098 1 1177 1176 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3099 1177 1176 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3100 1 1179 1178 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3101 1179 1178 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3102 1 1181 1180 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3103 1 1180 1181 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3104 1 1183 1182 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3105 1 1182 1183 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3106 0 1181 1180 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3107 1181 1180 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3108 0 1183 1182 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3109 1183 1182 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3110 199 105 1180 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3111 198 105 1181 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3112 197 105 1182 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3113 196 105 1183 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3114 1184 100 199 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3115 1185 100 198 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3116 1186 100 197 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3117 1187 100 196 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3118 0 1185 1184 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3119 1185 1184 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3120 0 1187 1186 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3121 1187 1186 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3122 1 1185 1184 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3123 1185 1184 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3124 1 1187 1186 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3125 1187 1186 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3126 1 1189 1188 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3127 1 1188 1189 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3128 1 1191 1190 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3129 1 1190 1191 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3130 0 1189 1188 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3131 1189 1188 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3132 0 1191 1190 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3133 1191 1190 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3134 208 100 1188 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3135 209 100 1189 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3136 210 100 1190 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3137 211 100 1191 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m3138 1192 105 208 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3139 1193 105 209 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3140 1194 105 210 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3141 1195 105 211 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m3142 0 1193 1192 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3143 1193 1192 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3144 0 1195 1194 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3145 1195 1194 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3146 1 1193 1192 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3147 1193 1192 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3148 1 1195 1194 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3149 1195 1194 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3150 1 1197 1196 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3151 1 1196 1197 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3152 1 1199 1198 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3153 1 1198 1199 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3154 0 1197 1196 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3155 1197 1196 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3156 0 1199 1198 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3157 1199 1198 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3158 207 105 1196 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3159 206 105 1197 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3160 205 105 1198 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3161 204 105 1199 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3162 1200 100 207 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3163 1201 100 206 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3164 1202 100 205 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3165 1203 100 204 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3166 0 1201 1200 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3167 1201 1200 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3168 0 1203 1202 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3169 1203 1202 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3170 1 1201 1200 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3171 1201 1200 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3172 1 1203 1202 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3173 1203 1202 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3174 1 1205 1204 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3175 1 1204 1205 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3176 1 1207 1206 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3177 1 1206 1207 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3178 0 1205 1204 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3179 1205 1204 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3180 0 1207 1206 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3181 1207 1206 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3182 216 100 1204 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3183 217 100 1205 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3184 218 100 1206 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3185 219 100 1207 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m3186 1208 105 216 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3187 1209 105 217 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3188 1210 105 218 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3189 1211 105 219 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m3190 0 1209 1208 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3191 1209 1208 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3192 0 1211 1210 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3193 1211 1210 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3194 1 1209 1208 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3195 1209 1208 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3196 1 1211 1210 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3197 1211 1210 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3198 1 1213 1212 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3199 1 1212 1213 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3200 1 1215 1214 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3201 1 1214 1215 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3202 0 1213 1212 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3203 1213 1212 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3204 0 1215 1214 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3205 1215 1214 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3206 215 105 1212 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3207 214 105 1213 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3208 213 105 1214 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3209 212 105 1215 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3210 1216 100 215 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3211 1217 100 214 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3212 1218 100 213 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3213 1219 100 212 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3214 0 1217 1216 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3215 1217 1216 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3216 0 1219 1218 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3217 1219 1218 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3218 1 1217 1216 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3219 1217 1216 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3220 1 1219 1218 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3221 1219 1218 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3222 1 1221 1220 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3223 1 1220 1221 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3224 1 1223 1222 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3225 1 1222 1223 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3226 0 1221 1220 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3227 1221 1220 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3228 0 1223 1222 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3229 1223 1222 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3230 224 100 1220 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3231 225 100 1221 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3232 226 100 1222 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3233 227 100 1223 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m3234 1224 105 224 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3235 1225 105 225 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3236 1226 105 226 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3237 1227 105 227 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m3238 0 1225 1224 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3239 1225 1224 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3240 0 1227 1226 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3241 1227 1226 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3242 1 1225 1224 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3243 1225 1224 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3244 1 1227 1226 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3245 1227 1226 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3246 1 1229 1228 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3247 1 1228 1229 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3248 1 1231 1230 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3249 1 1230 1231 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3250 0 1229 1228 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3251 1229 1228 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3252 0 1231 1230 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3253 1231 1230 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3254 223 105 1228 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3255 222 105 1229 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3256 221 105 1230 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3257 220 105 1231 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3258 1232 100 223 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3259 1233 100 222 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3260 1234 100 221 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3261 1235 100 220 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3262 0 1233 1232 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3263 1233 1232 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3264 0 1235 1234 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3265 1235 1234 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3266 1 1233 1232 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3267 1233 1232 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3268 1 1235 1234 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3269 1235 1234 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3270 1 1237 1236 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3271 1 1236 1237 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3272 1 1239 1238 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3273 1 1238 1239 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3274 0 1237 1236 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3275 1237 1236 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3276 0 1239 1238 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3277 1239 1238 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3278 232 100 1236 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3279 233 100 1237 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3280 234 100 1238 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3281 235 100 1239 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m3282 1240 105 232 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3283 1241 105 233 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3284 1242 105 234 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3285 1243 105 235 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m3286 0 1241 1240 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3287 1241 1240 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3288 0 1243 1242 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3289 1243 1242 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3290 1 1241 1240 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3291 1241 1240 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3292 1 1243 1242 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3293 1243 1242 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3294 1 1245 1244 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3295 1 1244 1245 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3296 1 1247 1246 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3297 1 1246 1247 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3298 0 1245 1244 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3299 1245 1244 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3300 0 1247 1246 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3301 1247 1246 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3302 231 105 1244 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3303 230 105 1245 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3304 229 105 1246 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3305 228 105 1247 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3306 1248 100 231 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3307 1249 100 230 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3308 1250 100 229 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3309 1251 100 228 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3310 0 1249 1248 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3311 1249 1248 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3312 0 1251 1250 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3313 1251 1250 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3314 1 1249 1248 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3315 1249 1248 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3316 1 1251 1250 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3317 1251 1250 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3318 1 1253 1252 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3319 1 1252 1253 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3320 1 1255 1254 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3321 1 1254 1255 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3322 0 1253 1252 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3323 1253 1252 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3324 0 1255 1254 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3325 1255 1254 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3326 240 100 1252 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3327 241 100 1253 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3328 242 100 1254 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3329 243 100 1255 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m3330 1256 105 240 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3331 1257 105 241 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3332 1258 105 242 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3333 1259 105 243 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m3334 0 1257 1256 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3335 1257 1256 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3336 0 1259 1258 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3337 1259 1258 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3338 1 1257 1256 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3339 1257 1256 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3340 1 1259 1258 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3341 1259 1258 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3342 1 1261 1260 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3343 1 1260 1261 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3344 1 1263 1262 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3345 1 1262 1263 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3346 0 1261 1260 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3347 1261 1260 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3348 0 1263 1262 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3349 1263 1262 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3350 239 105 1260 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3351 238 105 1261 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3352 237 105 1262 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3353 236 105 1263 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3354 1264 100 239 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3355 1265 100 238 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3356 1266 100 237 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3357 1267 100 236 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3358 0 1265 1264 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3359 1265 1264 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3360 0 1267 1266 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3361 1267 1266 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3362 1 1265 1264 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3363 1265 1264 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3364 1 1267 1266 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3365 1267 1266 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3366 1 1269 1268 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3367 1 1268 1269 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3368 1 1271 1270 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3369 1 1270 1271 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3370 0 1269 1268 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3371 1269 1268 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3372 0 1271 1270 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3373 1271 1270 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3374 184 90 1268 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3375 185 90 1269 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3376 186 90 1270 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3377 187 90 1271 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m3378 1272 94 184 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3379 1273 94 185 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3380 1274 94 186 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3381 1275 94 187 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m3382 0 1273 1272 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3383 1273 1272 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3384 0 1275 1274 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3385 1275 1274 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3386 1 1273 1272 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3387 1273 1272 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3388 1 1275 1274 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3389 1275 1274 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3390 1 1277 1276 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3391 1 1276 1277 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3392 1 1279 1278 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3393 1 1278 1279 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3394 0 1277 1276 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3395 1277 1276 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3396 0 1279 1278 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3397 1279 1278 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3398 183 94 1276 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3399 182 94 1277 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3400 181 94 1278 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3401 180 94 1279 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3402 1280 90 183 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3403 1281 90 182 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3404 1282 90 181 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3405 1283 90 180 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3406 0 1281 1280 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3407 1281 1280 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3408 0 1283 1282 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3409 1283 1282 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3410 1 1281 1280 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3411 1281 1280 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3412 1 1283 1282 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3413 1283 1282 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3414 1 1285 1284 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3415 1 1284 1285 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3416 1 1287 1286 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3417 1 1286 1287 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3418 0 1285 1284 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3419 1285 1284 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3420 0 1287 1286 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3421 1287 1286 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3422 192 90 1284 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3423 193 90 1285 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3424 194 90 1286 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3425 195 90 1287 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m3426 1288 94 192 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3427 1289 94 193 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3428 1290 94 194 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3429 1291 94 195 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m3430 0 1289 1288 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3431 1289 1288 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3432 0 1291 1290 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3433 1291 1290 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3434 1 1289 1288 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3435 1289 1288 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3436 1 1291 1290 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3437 1291 1290 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3438 1 1293 1292 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3439 1 1292 1293 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3440 1 1295 1294 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3441 1 1294 1295 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3442 0 1293 1292 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3443 1293 1292 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3444 0 1295 1294 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3445 1295 1294 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3446 191 94 1292 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3447 190 94 1293 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3448 189 94 1294 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3449 188 94 1295 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3450 1296 90 191 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3451 1297 90 190 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3452 1298 90 189 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3453 1299 90 188 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3454 0 1297 1296 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3455 1297 1296 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3456 0 1299 1298 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3457 1299 1298 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3458 1 1297 1296 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3459 1297 1296 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3460 1 1299 1298 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3461 1299 1298 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3462 1 1301 1300 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3463 1 1300 1301 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3464 1 1303 1302 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3465 1 1302 1303 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3466 0 1301 1300 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3467 1301 1300 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3468 0 1303 1302 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3469 1303 1302 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3470 200 90 1300 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3471 201 90 1301 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3472 202 90 1302 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3473 203 90 1303 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m3474 1304 94 200 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3475 1305 94 201 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3476 1306 94 202 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3477 1307 94 203 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m3478 0 1305 1304 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3479 1305 1304 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3480 0 1307 1306 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3481 1307 1306 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3482 1 1305 1304 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3483 1305 1304 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3484 1 1307 1306 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3485 1307 1306 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3486 1 1309 1308 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3487 1 1308 1309 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3488 1 1311 1310 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3489 1 1310 1311 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3490 0 1309 1308 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3491 1309 1308 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3492 0 1311 1310 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3493 1311 1310 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3494 199 94 1308 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3495 198 94 1309 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3496 197 94 1310 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3497 196 94 1311 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3498 1312 90 199 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3499 1313 90 198 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3500 1314 90 197 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3501 1315 90 196 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3502 0 1313 1312 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3503 1313 1312 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3504 0 1315 1314 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3505 1315 1314 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3506 1 1313 1312 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3507 1313 1312 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3508 1 1315 1314 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3509 1315 1314 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3510 1 1317 1316 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3511 1 1316 1317 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3512 1 1319 1318 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3513 1 1318 1319 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3514 0 1317 1316 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3515 1317 1316 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3516 0 1319 1318 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3517 1319 1318 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3518 208 90 1316 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3519 209 90 1317 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3520 210 90 1318 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3521 211 90 1319 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m3522 1320 94 208 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3523 1321 94 209 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3524 1322 94 210 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3525 1323 94 211 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m3526 0 1321 1320 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3527 1321 1320 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3528 0 1323 1322 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3529 1323 1322 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3530 1 1321 1320 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3531 1321 1320 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3532 1 1323 1322 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3533 1323 1322 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3534 1 1325 1324 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3535 1 1324 1325 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3536 1 1327 1326 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3537 1 1326 1327 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3538 0 1325 1324 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3539 1325 1324 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3540 0 1327 1326 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3541 1327 1326 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3542 207 94 1324 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3543 206 94 1325 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3544 205 94 1326 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3545 204 94 1327 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3546 1328 90 207 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3547 1329 90 206 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3548 1330 90 205 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3549 1331 90 204 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3550 0 1329 1328 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3551 1329 1328 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3552 0 1331 1330 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3553 1331 1330 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3554 1 1329 1328 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3555 1329 1328 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3556 1 1331 1330 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3557 1331 1330 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3558 1 1333 1332 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3559 1 1332 1333 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3560 1 1335 1334 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3561 1 1334 1335 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3562 0 1333 1332 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3563 1333 1332 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3564 0 1335 1334 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3565 1335 1334 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3566 216 90 1332 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3567 217 90 1333 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3568 218 90 1334 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3569 219 90 1335 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m3570 1336 94 216 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3571 1337 94 217 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3572 1338 94 218 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3573 1339 94 219 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m3574 0 1337 1336 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3575 1337 1336 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3576 0 1339 1338 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3577 1339 1338 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3578 1 1337 1336 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3579 1337 1336 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3580 1 1339 1338 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3581 1339 1338 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3582 1 1341 1340 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3583 1 1340 1341 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3584 1 1343 1342 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3585 1 1342 1343 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3586 0 1341 1340 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3587 1341 1340 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3588 0 1343 1342 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3589 1343 1342 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3590 215 94 1340 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3591 214 94 1341 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3592 213 94 1342 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3593 212 94 1343 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3594 1344 90 215 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3595 1345 90 214 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3596 1346 90 213 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3597 1347 90 212 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3598 0 1345 1344 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3599 1345 1344 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3600 0 1347 1346 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3601 1347 1346 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3602 1 1345 1344 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3603 1345 1344 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3604 1 1347 1346 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3605 1347 1346 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3606 1 1349 1348 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3607 1 1348 1349 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3608 1 1351 1350 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3609 1 1350 1351 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3610 0 1349 1348 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3611 1349 1348 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3612 0 1351 1350 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3613 1351 1350 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3614 224 90 1348 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3615 225 90 1349 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3616 226 90 1350 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3617 227 90 1351 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m3618 1352 94 224 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3619 1353 94 225 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3620 1354 94 226 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3621 1355 94 227 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m3622 0 1353 1352 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3623 1353 1352 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3624 0 1355 1354 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3625 1355 1354 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3626 1 1353 1352 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3627 1353 1352 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3628 1 1355 1354 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3629 1355 1354 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3630 1 1357 1356 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3631 1 1356 1357 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3632 1 1359 1358 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3633 1 1358 1359 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3634 0 1357 1356 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3635 1357 1356 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3636 0 1359 1358 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3637 1359 1358 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3638 223 94 1356 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3639 222 94 1357 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3640 221 94 1358 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3641 220 94 1359 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3642 1360 90 223 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3643 1361 90 222 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3644 1362 90 221 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3645 1363 90 220 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3646 0 1361 1360 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3647 1361 1360 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3648 0 1363 1362 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3649 1363 1362 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3650 1 1361 1360 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3651 1361 1360 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3652 1 1363 1362 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3653 1363 1362 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3654 1 1365 1364 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3655 1 1364 1365 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3656 1 1367 1366 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3657 1 1366 1367 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3658 0 1365 1364 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3659 1365 1364 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3660 0 1367 1366 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3661 1367 1366 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3662 232 90 1364 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3663 233 90 1365 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3664 234 90 1366 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3665 235 90 1367 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m3666 1368 94 232 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3667 1369 94 233 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3668 1370 94 234 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3669 1371 94 235 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m3670 0 1369 1368 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3671 1369 1368 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3672 0 1371 1370 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3673 1371 1370 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3674 1 1369 1368 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3675 1369 1368 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3676 1 1371 1370 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3677 1371 1370 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3678 1 1373 1372 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3679 1 1372 1373 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3680 1 1375 1374 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3681 1 1374 1375 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3682 0 1373 1372 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3683 1373 1372 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3684 0 1375 1374 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3685 1375 1374 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3686 231 94 1372 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3687 230 94 1373 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3688 229 94 1374 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3689 228 94 1375 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3690 1376 90 231 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3691 1377 90 230 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3692 1378 90 229 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3693 1379 90 228 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3694 0 1377 1376 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3695 1377 1376 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3696 0 1379 1378 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3697 1379 1378 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3698 1 1377 1376 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3699 1377 1376 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3700 1 1379 1378 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3701 1379 1378 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3702 1 1381 1380 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3703 1 1380 1381 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3704 1 1383 1382 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3705 1 1382 1383 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3706 0 1381 1380 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3707 1381 1380 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3708 0 1383 1382 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3709 1383 1382 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3710 240 90 1380 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3711 241 90 1381 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3712 242 90 1382 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3713 243 90 1383 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m3714 1384 94 240 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3715 1385 94 241 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3716 1386 94 242 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3717 1387 94 243 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m3718 0 1385 1384 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3719 1385 1384 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3720 0 1387 1386 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3721 1387 1386 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3722 1 1385 1384 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3723 1385 1384 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3724 1 1387 1386 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3725 1387 1386 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3726 1 1389 1388 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3727 1 1388 1389 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3728 1 1391 1390 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3729 1 1390 1391 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3730 0 1389 1388 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3731 1389 1388 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3732 0 1391 1390 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3733 1391 1390 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3734 239 94 1388 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3735 238 94 1389 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3736 237 94 1390 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3737 236 94 1391 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3738 1392 90 239 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3739 1393 90 238 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3740 1394 90 237 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3741 1395 90 236 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3742 0 1393 1392 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3743 1393 1392 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3744 0 1395 1394 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3745 1395 1394 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3746 1 1393 1392 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3747 1393 1392 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3748 1 1395 1394 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3749 1395 1394 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3750 1 1397 1396 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3751 1 1396 1397 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3752 1 1399 1398 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3753 1 1398 1399 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3754 0 1397 1396 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3755 1397 1396 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3756 0 1399 1398 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3757 1399 1398 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3758 184 79 1396 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3759 185 79 1397 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3760 186 79 1398 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3761 187 79 1399 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m3762 1400 84 184 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3763 1401 84 185 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3764 1402 84 186 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3765 1403 84 187 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m3766 0 1401 1400 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3767 1401 1400 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3768 0 1403 1402 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3769 1403 1402 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3770 1 1401 1400 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3771 1401 1400 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3772 1 1403 1402 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3773 1403 1402 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3774 1 1405 1404 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3775 1 1404 1405 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3776 1 1407 1406 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3777 1 1406 1407 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3778 0 1405 1404 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3779 1405 1404 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3780 0 1407 1406 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3781 1407 1406 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3782 183 84 1404 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3783 182 84 1405 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3784 181 84 1406 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3785 180 84 1407 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3786 1408 79 183 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3787 1409 79 182 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3788 1410 79 181 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3789 1411 79 180 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3790 0 1409 1408 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3791 1409 1408 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3792 0 1411 1410 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3793 1411 1410 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3794 1 1409 1408 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3795 1409 1408 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3796 1 1411 1410 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3797 1411 1410 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3798 1 1413 1412 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3799 1 1412 1413 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3800 1 1415 1414 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3801 1 1414 1415 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3802 0 1413 1412 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3803 1413 1412 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3804 0 1415 1414 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3805 1415 1414 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3806 192 79 1412 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3807 193 79 1413 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3808 194 79 1414 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3809 195 79 1415 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m3810 1416 84 192 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3811 1417 84 193 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3812 1418 84 194 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3813 1419 84 195 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m3814 0 1417 1416 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3815 1417 1416 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3816 0 1419 1418 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3817 1419 1418 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3818 1 1417 1416 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3819 1417 1416 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3820 1 1419 1418 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3821 1419 1418 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3822 1 1421 1420 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3823 1 1420 1421 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3824 1 1423 1422 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3825 1 1422 1423 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3826 0 1421 1420 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3827 1421 1420 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3828 0 1423 1422 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3829 1423 1422 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3830 191 84 1420 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3831 190 84 1421 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3832 189 84 1422 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3833 188 84 1423 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3834 1424 79 191 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3835 1425 79 190 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3836 1426 79 189 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3837 1427 79 188 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3838 0 1425 1424 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3839 1425 1424 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3840 0 1427 1426 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3841 1427 1426 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3842 1 1425 1424 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3843 1425 1424 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3844 1 1427 1426 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3845 1427 1426 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3846 1 1429 1428 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3847 1 1428 1429 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3848 1 1431 1430 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3849 1 1430 1431 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3850 0 1429 1428 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3851 1429 1428 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3852 0 1431 1430 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3853 1431 1430 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3854 200 79 1428 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3855 201 79 1429 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3856 202 79 1430 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3857 203 79 1431 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m3858 1432 84 200 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3859 1433 84 201 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3860 1434 84 202 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3861 1435 84 203 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m3862 0 1433 1432 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3863 1433 1432 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3864 0 1435 1434 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3865 1435 1434 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3866 1 1433 1432 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3867 1433 1432 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3868 1 1435 1434 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3869 1435 1434 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3870 1 1437 1436 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3871 1 1436 1437 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3872 1 1439 1438 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3873 1 1438 1439 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3874 0 1437 1436 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3875 1437 1436 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3876 0 1439 1438 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3877 1439 1438 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3878 199 84 1436 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3879 198 84 1437 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3880 197 84 1438 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3881 196 84 1439 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3882 1440 79 199 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3883 1441 79 198 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3884 1442 79 197 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3885 1443 79 196 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3886 0 1441 1440 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3887 1441 1440 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3888 0 1443 1442 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3889 1443 1442 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3890 1 1441 1440 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3891 1441 1440 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3892 1 1443 1442 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3893 1443 1442 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3894 1 1445 1444 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3895 1 1444 1445 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3896 1 1447 1446 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3897 1 1446 1447 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3898 0 1445 1444 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3899 1445 1444 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3900 0 1447 1446 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3901 1447 1446 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3902 208 79 1444 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3903 209 79 1445 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3904 210 79 1446 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3905 211 79 1447 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m3906 1448 84 208 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3907 1449 84 209 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3908 1450 84 210 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3909 1451 84 211 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m3910 0 1449 1448 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3911 1449 1448 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3912 0 1451 1450 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3913 1451 1450 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3914 1 1449 1448 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3915 1449 1448 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3916 1 1451 1450 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3917 1451 1450 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3918 1 1453 1452 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3919 1 1452 1453 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3920 1 1455 1454 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3921 1 1454 1455 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3922 0 1453 1452 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3923 1453 1452 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3924 0 1455 1454 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3925 1455 1454 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3926 207 84 1452 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3927 206 84 1453 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3928 205 84 1454 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3929 204 84 1455 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3930 1456 79 207 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3931 1457 79 206 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3932 1458 79 205 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3933 1459 79 204 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3934 0 1457 1456 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3935 1457 1456 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3936 0 1459 1458 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3937 1459 1458 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3938 1 1457 1456 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3939 1457 1456 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3940 1 1459 1458 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3941 1459 1458 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3942 1 1461 1460 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3943 1 1460 1461 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3944 1 1463 1462 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3945 1 1462 1463 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3946 0 1461 1460 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3947 1461 1460 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3948 0 1463 1462 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3949 1463 1462 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3950 216 79 1460 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3951 217 79 1461 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3952 218 79 1462 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3953 219 79 1463 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m3954 1464 84 216 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3955 1465 84 217 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3956 1466 84 218 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3957 1467 84 219 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m3958 0 1465 1464 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3959 1465 1464 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3960 0 1467 1466 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3961 1467 1466 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3962 1 1465 1464 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3963 1465 1464 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3964 1 1467 1466 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3965 1467 1466 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3966 1 1469 1468 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3967 1 1468 1469 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3968 1 1471 1470 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3969 1 1470 1471 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3970 0 1469 1468 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3971 1469 1468 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3972 0 1471 1470 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3973 1471 1470 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3974 215 84 1468 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3975 214 84 1469 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m3976 213 84 1470 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3977 212 84 1471 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m3978 1472 79 215 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m3979 1473 79 214 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m3980 1474 79 213 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3981 1475 79 212 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m3982 0 1473 1472 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3983 1473 1472 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3984 0 1475 1474 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3985 1475 1474 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3986 1 1473 1472 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3987 1473 1472 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3988 1 1475 1474 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3989 1475 1474 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m3990 1 1477 1476 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3991 1 1476 1477 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3992 1 1479 1478 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3993 1 1478 1479 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m3994 0 1477 1476 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m3995 1477 1476 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m3996 0 1479 1478 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m3997 1479 1478 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m3998 224 79 1476 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m3999 225 79 1477 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4000 226 79 1478 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4001 227 79 1479 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m4002 1480 84 224 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4003 1481 84 225 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4004 1482 84 226 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4005 1483 84 227 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m4006 0 1481 1480 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4007 1481 1480 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4008 0 1483 1482 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4009 1483 1482 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4010 1 1481 1480 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4011 1481 1480 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4012 1 1483 1482 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4013 1483 1482 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4014 1 1485 1484 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4015 1 1484 1485 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4016 1 1487 1486 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4017 1 1486 1487 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4018 0 1485 1484 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4019 1485 1484 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4020 0 1487 1486 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4021 1487 1486 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4022 223 84 1484 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4023 222 84 1485 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4024 221 84 1486 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4025 220 84 1487 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4026 1488 79 223 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4027 1489 79 222 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4028 1490 79 221 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4029 1491 79 220 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4030 0 1489 1488 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4031 1489 1488 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4032 0 1491 1490 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4033 1491 1490 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4034 1 1489 1488 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4035 1489 1488 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4036 1 1491 1490 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4037 1491 1490 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4038 1 1493 1492 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4039 1 1492 1493 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4040 1 1495 1494 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4041 1 1494 1495 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4042 0 1493 1492 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4043 1493 1492 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4044 0 1495 1494 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4045 1495 1494 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4046 232 79 1492 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4047 233 79 1493 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4048 234 79 1494 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4049 235 79 1495 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m4050 1496 84 232 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4051 1497 84 233 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4052 1498 84 234 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4053 1499 84 235 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m4054 0 1497 1496 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4055 1497 1496 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4056 0 1499 1498 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4057 1499 1498 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4058 1 1497 1496 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4059 1497 1496 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4060 1 1499 1498 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4061 1499 1498 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4062 1 1501 1500 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4063 1 1500 1501 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4064 1 1503 1502 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4065 1 1502 1503 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4066 0 1501 1500 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4067 1501 1500 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4068 0 1503 1502 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4069 1503 1502 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4070 231 84 1500 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4071 230 84 1501 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4072 229 84 1502 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4073 228 84 1503 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4074 1504 79 231 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4075 1505 79 230 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4076 1506 79 229 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4077 1507 79 228 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4078 0 1505 1504 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4079 1505 1504 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4080 0 1507 1506 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4081 1507 1506 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4082 1 1505 1504 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4083 1505 1504 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4084 1 1507 1506 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4085 1507 1506 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4086 1 1509 1508 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4087 1 1508 1509 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4088 1 1511 1510 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4089 1 1510 1511 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4090 0 1509 1508 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4091 1509 1508 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4092 0 1511 1510 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4093 1511 1510 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4094 240 79 1508 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4095 241 79 1509 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4096 242 79 1510 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4097 243 79 1511 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m4098 1512 84 240 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4099 1513 84 241 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4100 1514 84 242 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4101 1515 84 243 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m4102 0 1513 1512 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4103 1513 1512 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4104 0 1515 1514 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4105 1515 1514 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4106 1 1513 1512 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4107 1513 1512 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4108 1 1515 1514 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4109 1515 1514 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4110 1 1517 1516 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4111 1 1516 1517 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4112 1 1519 1518 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4113 1 1518 1519 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4114 0 1517 1516 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4115 1517 1516 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4116 0 1519 1518 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4117 1519 1518 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4118 239 84 1516 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4119 238 84 1517 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4120 237 84 1518 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4121 236 84 1519 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4122 1520 79 239 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4123 1521 79 238 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4124 1522 79 237 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4125 1523 79 236 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4126 0 1521 1520 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4127 1521 1520 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4128 0 1523 1522 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4129 1523 1522 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4130 1 1521 1520 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4131 1521 1520 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4132 1 1523 1522 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4133 1523 1522 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4134 1 1525 1524 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4135 1 1524 1525 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4136 1 1527 1526 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4137 1 1526 1527 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4138 0 1525 1524 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4139 1525 1524 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4140 0 1527 1526 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4141 1527 1526 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4142 184 69 1524 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4143 185 69 1525 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4144 186 69 1526 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4145 187 69 1527 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m4146 1528 73 184 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4147 1529 73 185 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4148 1530 73 186 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4149 1531 73 187 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m4150 0 1529 1528 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4151 1529 1528 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4152 0 1531 1530 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4153 1531 1530 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4154 1 1529 1528 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4155 1529 1528 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4156 1 1531 1530 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4157 1531 1530 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4158 1 1533 1532 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4159 1 1532 1533 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4160 1 1535 1534 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4161 1 1534 1535 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4162 0 1533 1532 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4163 1533 1532 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4164 0 1535 1534 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4165 1535 1534 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4166 183 73 1532 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4167 182 73 1533 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4168 181 73 1534 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4169 180 73 1535 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4170 1536 69 183 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4171 1537 69 182 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4172 1538 69 181 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4173 1539 69 180 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4174 0 1537 1536 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4175 1537 1536 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4176 0 1539 1538 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4177 1539 1538 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4178 1 1537 1536 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4179 1537 1536 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4180 1 1539 1538 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4181 1539 1538 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4182 1 1541 1540 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4183 1 1540 1541 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4184 1 1543 1542 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4185 1 1542 1543 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4186 0 1541 1540 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4187 1541 1540 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4188 0 1543 1542 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4189 1543 1542 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4190 192 69 1540 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4191 193 69 1541 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4192 194 69 1542 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4193 195 69 1543 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m4194 1544 73 192 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4195 1545 73 193 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4196 1546 73 194 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4197 1547 73 195 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m4198 0 1545 1544 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4199 1545 1544 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4200 0 1547 1546 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4201 1547 1546 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4202 1 1545 1544 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4203 1545 1544 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4204 1 1547 1546 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4205 1547 1546 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4206 1 1549 1548 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4207 1 1548 1549 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4208 1 1551 1550 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4209 1 1550 1551 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4210 0 1549 1548 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4211 1549 1548 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4212 0 1551 1550 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4213 1551 1550 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4214 191 73 1548 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4215 190 73 1549 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4216 189 73 1550 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4217 188 73 1551 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4218 1552 69 191 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4219 1553 69 190 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4220 1554 69 189 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4221 1555 69 188 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4222 0 1553 1552 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4223 1553 1552 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4224 0 1555 1554 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4225 1555 1554 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4226 1 1553 1552 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4227 1553 1552 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4228 1 1555 1554 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4229 1555 1554 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4230 1 1557 1556 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4231 1 1556 1557 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4232 1 1559 1558 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4233 1 1558 1559 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4234 0 1557 1556 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4235 1557 1556 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4236 0 1559 1558 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4237 1559 1558 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4238 200 69 1556 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4239 201 69 1557 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4240 202 69 1558 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4241 203 69 1559 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m4242 1560 73 200 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4243 1561 73 201 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4244 1562 73 202 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4245 1563 73 203 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m4246 0 1561 1560 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4247 1561 1560 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4248 0 1563 1562 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4249 1563 1562 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4250 1 1561 1560 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4251 1561 1560 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4252 1 1563 1562 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4253 1563 1562 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4254 1 1565 1564 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4255 1 1564 1565 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4256 1 1567 1566 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4257 1 1566 1567 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4258 0 1565 1564 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4259 1565 1564 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4260 0 1567 1566 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4261 1567 1566 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4262 199 73 1564 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4263 198 73 1565 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4264 197 73 1566 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4265 196 73 1567 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4266 1568 69 199 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4267 1569 69 198 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4268 1570 69 197 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4269 1571 69 196 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4270 0 1569 1568 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4271 1569 1568 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4272 0 1571 1570 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4273 1571 1570 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4274 1 1569 1568 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4275 1569 1568 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4276 1 1571 1570 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4277 1571 1570 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4278 1 1573 1572 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4279 1 1572 1573 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4280 1 1575 1574 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4281 1 1574 1575 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4282 0 1573 1572 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4283 1573 1572 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4284 0 1575 1574 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4285 1575 1574 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4286 208 69 1572 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4287 209 69 1573 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4288 210 69 1574 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4289 211 69 1575 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m4290 1576 73 208 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4291 1577 73 209 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4292 1578 73 210 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4293 1579 73 211 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m4294 0 1577 1576 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4295 1577 1576 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4296 0 1579 1578 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4297 1579 1578 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4298 1 1577 1576 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4299 1577 1576 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4300 1 1579 1578 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4301 1579 1578 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4302 1 1581 1580 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4303 1 1580 1581 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4304 1 1583 1582 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4305 1 1582 1583 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4306 0 1581 1580 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4307 1581 1580 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4308 0 1583 1582 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4309 1583 1582 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4310 207 73 1580 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4311 206 73 1581 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4312 205 73 1582 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4313 204 73 1583 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4314 1584 69 207 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4315 1585 69 206 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4316 1586 69 205 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4317 1587 69 204 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4318 0 1585 1584 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4319 1585 1584 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4320 0 1587 1586 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4321 1587 1586 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4322 1 1585 1584 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4323 1585 1584 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4324 1 1587 1586 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4325 1587 1586 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4326 1 1589 1588 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4327 1 1588 1589 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4328 1 1591 1590 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4329 1 1590 1591 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4330 0 1589 1588 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4331 1589 1588 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4332 0 1591 1590 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4333 1591 1590 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4334 216 69 1588 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4335 217 69 1589 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4336 218 69 1590 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4337 219 69 1591 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m4338 1592 73 216 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4339 1593 73 217 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4340 1594 73 218 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4341 1595 73 219 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m4342 0 1593 1592 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4343 1593 1592 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4344 0 1595 1594 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4345 1595 1594 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4346 1 1593 1592 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4347 1593 1592 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4348 1 1595 1594 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4349 1595 1594 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4350 1 1597 1596 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4351 1 1596 1597 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4352 1 1599 1598 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4353 1 1598 1599 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4354 0 1597 1596 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4355 1597 1596 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4356 0 1599 1598 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4357 1599 1598 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4358 215 73 1596 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4359 214 73 1597 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4360 213 73 1598 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4361 212 73 1599 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4362 1600 69 215 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4363 1601 69 214 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4364 1602 69 213 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4365 1603 69 212 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4366 0 1601 1600 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4367 1601 1600 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4368 0 1603 1602 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4369 1603 1602 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4370 1 1601 1600 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4371 1601 1600 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4372 1 1603 1602 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4373 1603 1602 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4374 1 1605 1604 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4375 1 1604 1605 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4376 1 1607 1606 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4377 1 1606 1607 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4378 0 1605 1604 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4379 1605 1604 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4380 0 1607 1606 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4381 1607 1606 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4382 224 69 1604 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4383 225 69 1605 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4384 226 69 1606 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4385 227 69 1607 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m4386 1608 73 224 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4387 1609 73 225 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4388 1610 73 226 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4389 1611 73 227 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m4390 0 1609 1608 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4391 1609 1608 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4392 0 1611 1610 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4393 1611 1610 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4394 1 1609 1608 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4395 1609 1608 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4396 1 1611 1610 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4397 1611 1610 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4398 1 1613 1612 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4399 1 1612 1613 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4400 1 1615 1614 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4401 1 1614 1615 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4402 0 1613 1612 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4403 1613 1612 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4404 0 1615 1614 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4405 1615 1614 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4406 223 73 1612 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4407 222 73 1613 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4408 221 73 1614 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4409 220 73 1615 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4410 1616 69 223 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4411 1617 69 222 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4412 1618 69 221 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4413 1619 69 220 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4414 0 1617 1616 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4415 1617 1616 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4416 0 1619 1618 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4417 1619 1618 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4418 1 1617 1616 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4419 1617 1616 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4420 1 1619 1618 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4421 1619 1618 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4422 1 1621 1620 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4423 1 1620 1621 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4424 1 1623 1622 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4425 1 1622 1623 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4426 0 1621 1620 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4427 1621 1620 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4428 0 1623 1622 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4429 1623 1622 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4430 232 69 1620 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4431 233 69 1621 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4432 234 69 1622 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4433 235 69 1623 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m4434 1624 73 232 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4435 1625 73 233 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4436 1626 73 234 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4437 1627 73 235 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m4438 0 1625 1624 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4439 1625 1624 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4440 0 1627 1626 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4441 1627 1626 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4442 1 1625 1624 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4443 1625 1624 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4444 1 1627 1626 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4445 1627 1626 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4446 1 1629 1628 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4447 1 1628 1629 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4448 1 1631 1630 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4449 1 1630 1631 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4450 0 1629 1628 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4451 1629 1628 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4452 0 1631 1630 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4453 1631 1630 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4454 231 73 1628 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4455 230 73 1629 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4456 229 73 1630 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4457 228 73 1631 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4458 1632 69 231 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4459 1633 69 230 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4460 1634 69 229 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4461 1635 69 228 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4462 0 1633 1632 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4463 1633 1632 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4464 0 1635 1634 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4465 1635 1634 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4466 1 1633 1632 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4467 1633 1632 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4468 1 1635 1634 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4469 1635 1634 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4470 1 1637 1636 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4471 1 1636 1637 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4472 1 1639 1638 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4473 1 1638 1639 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4474 0 1637 1636 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4475 1637 1636 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4476 0 1639 1638 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4477 1639 1638 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4478 240 69 1636 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4479 241 69 1637 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4480 242 69 1638 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4481 243 69 1639 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m4482 1640 73 240 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4483 1641 73 241 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4484 1642 73 242 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4485 1643 73 243 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m4486 0 1641 1640 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4487 1641 1640 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4488 0 1643 1642 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4489 1643 1642 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4490 1 1641 1640 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4491 1641 1640 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4492 1 1643 1642 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4493 1643 1642 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4494 1 1645 1644 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4495 1 1644 1645 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4496 1 1647 1646 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4497 1 1646 1647 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4498 0 1645 1644 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4499 1645 1644 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4500 0 1647 1646 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4501 1647 1646 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4502 239 73 1644 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4503 238 73 1645 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4504 237 73 1646 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4505 236 73 1647 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4506 1648 69 239 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4507 1649 69 238 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4508 1650 69 237 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4509 1651 69 236 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4510 0 1649 1648 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4511 1649 1648 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4512 0 1651 1650 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4513 1651 1650 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4514 1 1649 1648 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4515 1649 1648 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4516 1 1651 1650 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4517 1651 1650 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4518 1 1653 1652 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4519 1 1652 1653 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4520 1 1655 1654 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4521 1 1654 1655 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4522 0 1653 1652 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4523 1653 1652 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4524 0 1655 1654 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4525 1655 1654 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4526 184 58 1652 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4527 185 58 1653 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4528 186 58 1654 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4529 187 58 1655 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m4530 1656 63 184 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4531 1657 63 185 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4532 1658 63 186 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4533 1659 63 187 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m4534 0 1657 1656 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4535 1657 1656 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4536 0 1659 1658 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4537 1659 1658 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4538 1 1657 1656 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4539 1657 1656 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4540 1 1659 1658 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4541 1659 1658 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4542 1 1661 1660 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4543 1 1660 1661 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4544 1 1663 1662 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4545 1 1662 1663 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4546 0 1661 1660 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4547 1661 1660 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4548 0 1663 1662 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4549 1663 1662 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4550 183 63 1660 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4551 182 63 1661 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4552 181 63 1662 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4553 180 63 1663 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4554 1664 58 183 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4555 1665 58 182 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4556 1666 58 181 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4557 1667 58 180 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4558 0 1665 1664 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4559 1665 1664 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4560 0 1667 1666 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4561 1667 1666 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4562 1 1665 1664 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4563 1665 1664 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4564 1 1667 1666 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4565 1667 1666 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4566 1 1669 1668 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4567 1 1668 1669 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4568 1 1671 1670 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4569 1 1670 1671 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4570 0 1669 1668 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4571 1669 1668 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4572 0 1671 1670 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4573 1671 1670 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4574 192 58 1668 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4575 193 58 1669 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4576 194 58 1670 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4577 195 58 1671 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m4578 1672 63 192 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4579 1673 63 193 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4580 1674 63 194 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4581 1675 63 195 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m4582 0 1673 1672 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4583 1673 1672 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4584 0 1675 1674 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4585 1675 1674 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4586 1 1673 1672 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4587 1673 1672 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4588 1 1675 1674 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4589 1675 1674 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4590 1 1677 1676 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4591 1 1676 1677 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4592 1 1679 1678 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4593 1 1678 1679 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4594 0 1677 1676 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4595 1677 1676 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4596 0 1679 1678 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4597 1679 1678 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4598 191 63 1676 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4599 190 63 1677 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4600 189 63 1678 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4601 188 63 1679 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4602 1680 58 191 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4603 1681 58 190 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4604 1682 58 189 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4605 1683 58 188 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4606 0 1681 1680 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4607 1681 1680 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4608 0 1683 1682 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4609 1683 1682 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4610 1 1681 1680 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4611 1681 1680 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4612 1 1683 1682 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4613 1683 1682 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4614 1 1685 1684 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4615 1 1684 1685 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4616 1 1687 1686 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4617 1 1686 1687 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4618 0 1685 1684 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4619 1685 1684 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4620 0 1687 1686 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4621 1687 1686 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4622 200 58 1684 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4623 201 58 1685 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4624 202 58 1686 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4625 203 58 1687 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m4626 1688 63 200 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4627 1689 63 201 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4628 1690 63 202 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4629 1691 63 203 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m4630 0 1689 1688 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4631 1689 1688 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4632 0 1691 1690 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4633 1691 1690 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4634 1 1689 1688 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4635 1689 1688 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4636 1 1691 1690 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4637 1691 1690 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4638 1 1693 1692 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4639 1 1692 1693 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4640 1 1695 1694 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4641 1 1694 1695 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4642 0 1693 1692 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4643 1693 1692 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4644 0 1695 1694 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4645 1695 1694 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4646 199 63 1692 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4647 198 63 1693 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4648 197 63 1694 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4649 196 63 1695 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4650 1696 58 199 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4651 1697 58 198 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4652 1698 58 197 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4653 1699 58 196 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4654 0 1697 1696 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4655 1697 1696 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4656 0 1699 1698 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4657 1699 1698 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4658 1 1697 1696 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4659 1697 1696 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4660 1 1699 1698 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4661 1699 1698 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4662 1 1701 1700 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4663 1 1700 1701 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4664 1 1703 1702 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4665 1 1702 1703 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4666 0 1701 1700 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4667 1701 1700 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4668 0 1703 1702 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4669 1703 1702 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4670 208 58 1700 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4671 209 58 1701 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4672 210 58 1702 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4673 211 58 1703 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m4674 1704 63 208 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4675 1705 63 209 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4676 1706 63 210 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4677 1707 63 211 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m4678 0 1705 1704 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4679 1705 1704 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4680 0 1707 1706 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4681 1707 1706 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4682 1 1705 1704 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4683 1705 1704 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4684 1 1707 1706 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4685 1707 1706 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4686 1 1709 1708 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4687 1 1708 1709 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4688 1 1711 1710 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4689 1 1710 1711 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4690 0 1709 1708 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4691 1709 1708 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4692 0 1711 1710 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4693 1711 1710 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4694 207 63 1708 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4695 206 63 1709 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4696 205 63 1710 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4697 204 63 1711 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4698 1712 58 207 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4699 1713 58 206 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4700 1714 58 205 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4701 1715 58 204 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4702 0 1713 1712 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4703 1713 1712 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4704 0 1715 1714 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4705 1715 1714 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4706 1 1713 1712 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4707 1713 1712 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4708 1 1715 1714 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4709 1715 1714 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4710 1 1717 1716 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4711 1 1716 1717 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4712 1 1719 1718 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4713 1 1718 1719 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4714 0 1717 1716 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4715 1717 1716 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4716 0 1719 1718 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4717 1719 1718 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4718 216 58 1716 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4719 217 58 1717 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4720 218 58 1718 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4721 219 58 1719 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m4722 1720 63 216 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4723 1721 63 217 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4724 1722 63 218 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4725 1723 63 219 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m4726 0 1721 1720 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4727 1721 1720 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4728 0 1723 1722 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4729 1723 1722 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4730 1 1721 1720 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4731 1721 1720 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4732 1 1723 1722 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4733 1723 1722 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4734 1 1725 1724 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4735 1 1724 1725 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4736 1 1727 1726 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4737 1 1726 1727 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4738 0 1725 1724 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4739 1725 1724 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4740 0 1727 1726 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4741 1727 1726 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4742 215 63 1724 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4743 214 63 1725 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4744 213 63 1726 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4745 212 63 1727 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4746 1728 58 215 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4747 1729 58 214 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4748 1730 58 213 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4749 1731 58 212 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4750 0 1729 1728 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4751 1729 1728 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4752 0 1731 1730 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4753 1731 1730 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4754 1 1729 1728 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4755 1729 1728 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4756 1 1731 1730 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4757 1731 1730 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4758 1 1733 1732 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4759 1 1732 1733 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4760 1 1735 1734 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4761 1 1734 1735 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4762 0 1733 1732 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4763 1733 1732 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4764 0 1735 1734 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4765 1735 1734 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4766 224 58 1732 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4767 225 58 1733 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4768 226 58 1734 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4769 227 58 1735 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m4770 1736 63 224 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4771 1737 63 225 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4772 1738 63 226 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4773 1739 63 227 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m4774 0 1737 1736 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4775 1737 1736 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4776 0 1739 1738 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4777 1739 1738 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4778 1 1737 1736 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4779 1737 1736 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4780 1 1739 1738 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4781 1739 1738 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4782 1 1741 1740 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4783 1 1740 1741 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4784 1 1743 1742 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4785 1 1742 1743 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4786 0 1741 1740 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4787 1741 1740 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4788 0 1743 1742 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4789 1743 1742 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4790 223 63 1740 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4791 222 63 1741 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4792 221 63 1742 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4793 220 63 1743 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4794 1744 58 223 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4795 1745 58 222 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4796 1746 58 221 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4797 1747 58 220 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4798 0 1745 1744 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4799 1745 1744 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4800 0 1747 1746 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4801 1747 1746 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4802 1 1745 1744 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4803 1745 1744 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4804 1 1747 1746 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4805 1747 1746 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4806 1 1749 1748 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4807 1 1748 1749 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4808 1 1751 1750 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4809 1 1750 1751 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4810 0 1749 1748 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4811 1749 1748 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4812 0 1751 1750 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4813 1751 1750 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4814 232 58 1748 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4815 233 58 1749 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4816 234 58 1750 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4817 235 58 1751 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m4818 1752 63 232 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4819 1753 63 233 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4820 1754 63 234 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4821 1755 63 235 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m4822 0 1753 1752 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4823 1753 1752 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4824 0 1755 1754 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4825 1755 1754 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4826 1 1753 1752 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4827 1753 1752 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4828 1 1755 1754 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4829 1755 1754 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4830 1 1757 1756 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4831 1 1756 1757 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4832 1 1759 1758 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4833 1 1758 1759 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4834 0 1757 1756 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4835 1757 1756 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4836 0 1759 1758 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4837 1759 1758 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4838 231 63 1756 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4839 230 63 1757 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4840 229 63 1758 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4841 228 63 1759 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4842 1760 58 231 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4843 1761 58 230 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4844 1762 58 229 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4845 1763 58 228 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4846 0 1761 1760 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4847 1761 1760 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4848 0 1763 1762 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4849 1763 1762 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4850 1 1761 1760 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4851 1761 1760 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4852 1 1763 1762 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4853 1763 1762 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4854 1 1765 1764 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4855 1 1764 1765 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4856 1 1767 1766 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4857 1 1766 1767 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4858 0 1765 1764 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4859 1765 1764 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4860 0 1767 1766 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4861 1767 1766 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4862 240 58 1764 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4863 241 58 1765 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4864 242 58 1766 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4865 243 58 1767 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m4866 1768 63 240 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4867 1769 63 241 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4868 1770 63 242 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4869 1771 63 243 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m4870 0 1769 1768 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4871 1769 1768 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4872 0 1771 1770 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4873 1771 1770 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4874 1 1769 1768 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4875 1769 1768 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4876 1 1771 1770 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4877 1771 1770 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4878 1 1773 1772 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4879 1 1772 1773 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4880 1 1775 1774 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4881 1 1774 1775 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4882 0 1773 1772 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4883 1773 1772 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4884 0 1775 1774 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4885 1775 1774 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4886 239 63 1772 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4887 238 63 1773 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4888 237 63 1774 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4889 236 63 1775 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4890 1776 58 239 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4891 1777 58 238 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4892 1778 58 237 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4893 1779 58 236 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4894 0 1777 1776 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4895 1777 1776 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4896 0 1779 1778 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4897 1779 1778 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4898 1 1777 1776 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4899 1777 1776 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4900 1 1779 1778 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4901 1779 1778 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4902 1 1781 1780 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4903 1 1780 1781 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4904 1 1783 1782 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4905 1 1782 1783 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4906 0 1781 1780 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4907 1781 1780 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4908 0 1783 1782 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4909 1783 1782 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4910 184 48 1780 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4911 185 48 1781 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4912 186 48 1782 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4913 187 48 1783 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m4914 1784 52 184 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4915 1785 52 185 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4916 1786 52 186 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4917 1787 52 187 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m4918 0 1785 1784 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4919 1785 1784 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4920 0 1787 1786 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4921 1787 1786 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4922 1 1785 1784 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4923 1785 1784 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4924 1 1787 1786 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4925 1787 1786 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4926 1 1789 1788 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4927 1 1788 1789 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4928 1 1791 1790 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4929 1 1790 1791 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4930 0 1789 1788 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4931 1789 1788 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4932 0 1791 1790 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4933 1791 1790 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4934 183 52 1788 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4935 182 52 1789 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4936 181 52 1790 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4937 180 52 1791 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4938 1792 48 183 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4939 1793 48 182 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4940 1794 48 181 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4941 1795 48 180 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4942 0 1793 1792 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4943 1793 1792 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4944 0 1795 1794 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4945 1795 1794 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4946 1 1793 1792 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4947 1793 1792 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4948 1 1795 1794 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4949 1795 1794 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4950 1 1797 1796 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4951 1 1796 1797 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4952 1 1799 1798 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4953 1 1798 1799 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4954 0 1797 1796 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4955 1797 1796 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4956 0 1799 1798 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4957 1799 1798 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4958 192 48 1796 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4959 193 48 1797 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4960 194 48 1798 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4961 195 48 1799 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m4962 1800 52 192 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4963 1801 52 193 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4964 1802 52 194 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4965 1803 52 195 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m4966 0 1801 1800 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4967 1801 1800 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4968 0 1803 1802 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4969 1803 1802 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4970 1 1801 1800 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4971 1801 1800 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4972 1 1803 1802 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4973 1803 1802 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4974 1 1805 1804 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4975 1 1804 1805 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4976 1 1807 1806 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4977 1 1806 1807 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4978 0 1805 1804 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4979 1805 1804 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4980 0 1807 1806 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4981 1807 1806 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4982 191 52 1804 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m4983 190 52 1805 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m4984 189 52 1806 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4985 188 52 1807 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m4986 1808 48 191 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m4987 1809 48 190 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m4988 1810 48 189 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4989 1811 48 188 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m4990 0 1809 1808 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m4991 1809 1808 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m4992 0 1811 1810 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m4993 1811 1810 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m4994 1 1809 1808 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4995 1809 1808 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4996 1 1811 1810 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4997 1811 1810 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m4998 1 1813 1812 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m4999 1 1812 1813 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5000 1 1815 1814 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5001 1 1814 1815 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5002 0 1813 1812 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5003 1813 1812 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5004 0 1815 1814 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5005 1815 1814 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5006 200 48 1812 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5007 201 48 1813 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5008 202 48 1814 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5009 203 48 1815 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m5010 1816 52 200 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5011 1817 52 201 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5012 1818 52 202 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5013 1819 52 203 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m5014 0 1817 1816 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5015 1817 1816 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5016 0 1819 1818 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5017 1819 1818 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5018 1 1817 1816 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5019 1817 1816 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5020 1 1819 1818 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5021 1819 1818 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5022 1 1821 1820 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5023 1 1820 1821 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5024 1 1823 1822 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5025 1 1822 1823 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5026 0 1821 1820 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5027 1821 1820 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5028 0 1823 1822 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5029 1823 1822 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5030 199 52 1820 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5031 198 52 1821 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5032 197 52 1822 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5033 196 52 1823 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5034 1824 48 199 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5035 1825 48 198 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5036 1826 48 197 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5037 1827 48 196 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5038 0 1825 1824 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5039 1825 1824 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5040 0 1827 1826 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5041 1827 1826 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5042 1 1825 1824 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5043 1825 1824 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5044 1 1827 1826 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5045 1827 1826 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5046 1 1829 1828 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5047 1 1828 1829 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5048 1 1831 1830 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5049 1 1830 1831 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5050 0 1829 1828 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5051 1829 1828 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5052 0 1831 1830 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5053 1831 1830 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5054 208 48 1828 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5055 209 48 1829 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5056 210 48 1830 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5057 211 48 1831 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m5058 1832 52 208 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5059 1833 52 209 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5060 1834 52 210 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5061 1835 52 211 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m5062 0 1833 1832 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5063 1833 1832 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5064 0 1835 1834 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5065 1835 1834 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5066 1 1833 1832 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5067 1833 1832 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5068 1 1835 1834 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5069 1835 1834 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5070 1 1837 1836 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5071 1 1836 1837 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5072 1 1839 1838 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5073 1 1838 1839 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5074 0 1837 1836 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5075 1837 1836 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5076 0 1839 1838 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5077 1839 1838 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5078 207 52 1836 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5079 206 52 1837 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5080 205 52 1838 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5081 204 52 1839 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5082 1840 48 207 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5083 1841 48 206 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5084 1842 48 205 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5085 1843 48 204 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5086 0 1841 1840 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5087 1841 1840 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5088 0 1843 1842 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5089 1843 1842 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5090 1 1841 1840 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5091 1841 1840 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5092 1 1843 1842 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5093 1843 1842 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5094 1 1845 1844 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5095 1 1844 1845 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5096 1 1847 1846 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5097 1 1846 1847 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5098 0 1845 1844 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5099 1845 1844 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5100 0 1847 1846 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5101 1847 1846 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5102 216 48 1844 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5103 217 48 1845 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5104 218 48 1846 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5105 219 48 1847 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m5106 1848 52 216 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5107 1849 52 217 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5108 1850 52 218 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5109 1851 52 219 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m5110 0 1849 1848 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5111 1849 1848 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5112 0 1851 1850 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5113 1851 1850 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5114 1 1849 1848 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5115 1849 1848 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5116 1 1851 1850 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5117 1851 1850 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5118 1 1853 1852 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5119 1 1852 1853 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5120 1 1855 1854 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5121 1 1854 1855 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5122 0 1853 1852 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5123 1853 1852 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5124 0 1855 1854 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5125 1855 1854 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5126 215 52 1852 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5127 214 52 1853 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5128 213 52 1854 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5129 212 52 1855 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5130 1856 48 215 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5131 1857 48 214 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5132 1858 48 213 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5133 1859 48 212 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5134 0 1857 1856 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5135 1857 1856 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5136 0 1859 1858 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5137 1859 1858 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5138 1 1857 1856 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5139 1857 1856 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5140 1 1859 1858 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5141 1859 1858 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5142 1 1861 1860 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5143 1 1860 1861 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5144 1 1863 1862 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5145 1 1862 1863 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5146 0 1861 1860 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5147 1861 1860 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5148 0 1863 1862 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5149 1863 1862 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5150 224 48 1860 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5151 225 48 1861 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5152 226 48 1862 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5153 227 48 1863 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m5154 1864 52 224 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5155 1865 52 225 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5156 1866 52 226 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5157 1867 52 227 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m5158 0 1865 1864 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5159 1865 1864 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5160 0 1867 1866 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5161 1867 1866 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5162 1 1865 1864 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5163 1865 1864 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5164 1 1867 1866 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5165 1867 1866 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5166 1 1869 1868 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5167 1 1868 1869 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5168 1 1871 1870 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5169 1 1870 1871 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5170 0 1869 1868 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5171 1869 1868 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5172 0 1871 1870 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5173 1871 1870 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5174 223 52 1868 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5175 222 52 1869 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5176 221 52 1870 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5177 220 52 1871 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5178 1872 48 223 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5179 1873 48 222 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5180 1874 48 221 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5181 1875 48 220 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5182 0 1873 1872 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5183 1873 1872 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5184 0 1875 1874 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5185 1875 1874 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5186 1 1873 1872 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5187 1873 1872 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5188 1 1875 1874 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5189 1875 1874 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5190 1 1877 1876 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5191 1 1876 1877 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5192 1 1879 1878 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5193 1 1878 1879 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5194 0 1877 1876 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5195 1877 1876 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5196 0 1879 1878 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5197 1879 1878 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5198 232 48 1876 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5199 233 48 1877 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5200 234 48 1878 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5201 235 48 1879 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m5202 1880 52 232 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5203 1881 52 233 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5204 1882 52 234 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5205 1883 52 235 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m5206 0 1881 1880 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5207 1881 1880 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5208 0 1883 1882 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5209 1883 1882 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5210 1 1881 1880 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5211 1881 1880 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5212 1 1883 1882 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5213 1883 1882 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5214 1 1885 1884 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5215 1 1884 1885 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5216 1 1887 1886 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5217 1 1886 1887 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5218 0 1885 1884 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5219 1885 1884 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5220 0 1887 1886 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5221 1887 1886 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5222 231 52 1884 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5223 230 52 1885 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5224 229 52 1886 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5225 228 52 1887 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5226 1888 48 231 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5227 1889 48 230 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5228 1890 48 229 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5229 1891 48 228 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5230 0 1889 1888 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5231 1889 1888 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5232 0 1891 1890 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5233 1891 1890 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5234 1 1889 1888 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5235 1889 1888 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5236 1 1891 1890 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5237 1891 1890 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5238 1 1893 1892 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5239 1 1892 1893 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5240 1 1895 1894 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5241 1 1894 1895 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5242 0 1893 1892 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5243 1893 1892 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5244 0 1895 1894 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5245 1895 1894 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5246 240 48 1892 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5247 241 48 1893 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5248 242 48 1894 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5249 243 48 1895 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m5250 1896 52 240 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5251 1897 52 241 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5252 1898 52 242 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5253 1899 52 243 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m5254 0 1897 1896 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5255 1897 1896 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5256 0 1899 1898 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5257 1899 1898 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5258 1 1897 1896 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5259 1897 1896 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5260 1 1899 1898 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5261 1899 1898 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5262 1 1901 1900 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5263 1 1900 1901 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5264 1 1903 1902 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5265 1 1902 1903 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5266 0 1901 1900 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5267 1901 1900 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5268 0 1903 1902 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5269 1903 1902 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5270 239 52 1900 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5271 238 52 1901 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5272 237 52 1902 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5273 236 52 1903 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5274 1904 48 239 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5275 1905 48 238 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5276 1906 48 237 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5277 1907 48 236 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5278 0 1905 1904 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5279 1905 1904 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5280 0 1907 1906 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5281 1907 1906 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5282 1 1905 1904 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5283 1905 1904 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5284 1 1907 1906 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5285 1907 1906 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5286 1 1909 1908 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5287 1 1908 1909 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5288 1 1911 1910 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5289 1 1910 1911 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5290 0 1909 1908 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5291 1909 1908 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5292 0 1911 1910 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5293 1911 1910 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5294 184 37 1908 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5295 185 37 1909 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5296 186 37 1910 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5297 187 37 1911 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m5298 1912 42 184 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5299 1913 42 185 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5300 1914 42 186 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5301 1915 42 187 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m5302 0 1913 1912 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5303 1913 1912 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5304 0 1915 1914 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5305 1915 1914 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5306 1 1913 1912 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5307 1913 1912 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5308 1 1915 1914 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5309 1915 1914 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5310 1 1917 1916 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5311 1 1916 1917 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5312 1 1919 1918 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5313 1 1918 1919 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5314 0 1917 1916 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5315 1917 1916 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5316 0 1919 1918 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5317 1919 1918 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5318 183 42 1916 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5319 182 42 1917 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5320 181 42 1918 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5321 180 42 1919 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5322 1920 37 183 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5323 1921 37 182 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5324 1922 37 181 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5325 1923 37 180 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5326 0 1921 1920 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5327 1921 1920 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5328 0 1923 1922 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5329 1923 1922 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5330 1 1921 1920 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5331 1921 1920 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5332 1 1923 1922 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5333 1923 1922 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5334 1 1925 1924 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5335 1 1924 1925 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5336 1 1927 1926 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5337 1 1926 1927 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5338 0 1925 1924 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5339 1925 1924 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5340 0 1927 1926 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5341 1927 1926 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5342 192 37 1924 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5343 193 37 1925 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5344 194 37 1926 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5345 195 37 1927 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m5346 1928 42 192 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5347 1929 42 193 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5348 1930 42 194 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5349 1931 42 195 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m5350 0 1929 1928 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5351 1929 1928 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5352 0 1931 1930 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5353 1931 1930 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5354 1 1929 1928 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5355 1929 1928 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5356 1 1931 1930 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5357 1931 1930 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5358 1 1933 1932 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5359 1 1932 1933 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5360 1 1935 1934 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5361 1 1934 1935 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5362 0 1933 1932 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5363 1933 1932 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5364 0 1935 1934 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5365 1935 1934 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5366 191 42 1932 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5367 190 42 1933 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5368 189 42 1934 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5369 188 42 1935 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5370 1936 37 191 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5371 1937 37 190 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5372 1938 37 189 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5373 1939 37 188 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5374 0 1937 1936 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5375 1937 1936 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5376 0 1939 1938 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5377 1939 1938 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5378 1 1937 1936 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5379 1937 1936 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5380 1 1939 1938 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5381 1939 1938 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5382 1 1941 1940 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5383 1 1940 1941 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5384 1 1943 1942 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5385 1 1942 1943 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5386 0 1941 1940 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5387 1941 1940 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5388 0 1943 1942 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5389 1943 1942 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5390 200 37 1940 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5391 201 37 1941 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5392 202 37 1942 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5393 203 37 1943 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m5394 1944 42 200 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5395 1945 42 201 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5396 1946 42 202 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5397 1947 42 203 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m5398 0 1945 1944 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5399 1945 1944 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5400 0 1947 1946 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5401 1947 1946 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5402 1 1945 1944 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5403 1945 1944 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5404 1 1947 1946 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5405 1947 1946 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5406 1 1949 1948 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5407 1 1948 1949 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5408 1 1951 1950 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5409 1 1950 1951 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5410 0 1949 1948 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5411 1949 1948 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5412 0 1951 1950 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5413 1951 1950 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5414 199 42 1948 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5415 198 42 1949 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5416 197 42 1950 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5417 196 42 1951 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5418 1952 37 199 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5419 1953 37 198 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5420 1954 37 197 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5421 1955 37 196 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5422 0 1953 1952 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5423 1953 1952 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5424 0 1955 1954 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5425 1955 1954 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5426 1 1953 1952 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5427 1953 1952 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5428 1 1955 1954 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5429 1955 1954 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5430 1 1957 1956 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5431 1 1956 1957 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5432 1 1959 1958 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5433 1 1958 1959 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5434 0 1957 1956 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5435 1957 1956 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5436 0 1959 1958 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5437 1959 1958 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5438 208 37 1956 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5439 209 37 1957 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5440 210 37 1958 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5441 211 37 1959 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m5442 1960 42 208 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5443 1961 42 209 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5444 1962 42 210 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5445 1963 42 211 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m5446 0 1961 1960 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5447 1961 1960 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5448 0 1963 1962 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5449 1963 1962 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5450 1 1961 1960 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5451 1961 1960 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5452 1 1963 1962 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5453 1963 1962 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5454 1 1965 1964 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5455 1 1964 1965 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5456 1 1967 1966 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5457 1 1966 1967 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5458 0 1965 1964 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5459 1965 1964 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5460 0 1967 1966 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5461 1967 1966 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5462 207 42 1964 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5463 206 42 1965 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5464 205 42 1966 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5465 204 42 1967 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5466 1968 37 207 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5467 1969 37 206 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5468 1970 37 205 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5469 1971 37 204 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5470 0 1969 1968 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5471 1969 1968 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5472 0 1971 1970 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5473 1971 1970 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5474 1 1969 1968 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5475 1969 1968 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5476 1 1971 1970 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5477 1971 1970 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5478 1 1973 1972 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5479 1 1972 1973 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5480 1 1975 1974 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5481 1 1974 1975 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5482 0 1973 1972 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5483 1973 1972 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5484 0 1975 1974 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5485 1975 1974 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5486 216 37 1972 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5487 217 37 1973 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5488 218 37 1974 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5489 219 37 1975 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m5490 1976 42 216 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5491 1977 42 217 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5492 1978 42 218 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5493 1979 42 219 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m5494 0 1977 1976 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5495 1977 1976 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5496 0 1979 1978 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5497 1979 1978 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5498 1 1977 1976 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5499 1977 1976 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5500 1 1979 1978 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5501 1979 1978 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5502 1 1981 1980 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5503 1 1980 1981 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5504 1 1983 1982 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5505 1 1982 1983 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5506 0 1981 1980 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5507 1981 1980 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5508 0 1983 1982 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5509 1983 1982 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5510 215 42 1980 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5511 214 42 1981 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5512 213 42 1982 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5513 212 42 1983 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5514 1984 37 215 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5515 1985 37 214 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5516 1986 37 213 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5517 1987 37 212 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5518 0 1985 1984 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5519 1985 1984 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5520 0 1987 1986 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5521 1987 1986 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5522 1 1985 1984 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5523 1985 1984 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5524 1 1987 1986 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5525 1987 1986 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5526 1 1989 1988 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5527 1 1988 1989 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5528 1 1991 1990 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5529 1 1990 1991 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5530 0 1989 1988 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5531 1989 1988 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5532 0 1991 1990 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5533 1991 1990 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5534 224 37 1988 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5535 225 37 1989 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5536 226 37 1990 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5537 227 37 1991 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m5538 1992 42 224 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5539 1993 42 225 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5540 1994 42 226 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5541 1995 42 227 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m5542 0 1993 1992 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5543 1993 1992 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5544 0 1995 1994 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5545 1995 1994 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5546 1 1993 1992 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5547 1993 1992 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5548 1 1995 1994 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5549 1995 1994 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5550 1 1997 1996 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5551 1 1996 1997 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5552 1 1999 1998 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5553 1 1998 1999 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5554 0 1997 1996 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5555 1997 1996 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5556 0 1999 1998 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5557 1999 1998 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5558 223 42 1996 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5559 222 42 1997 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5560 221 42 1998 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5561 220 42 1999 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5562 2000 37 223 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5563 2001 37 222 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5564 2002 37 221 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5565 2003 37 220 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5566 0 2001 2000 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5567 2001 2000 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5568 0 2003 2002 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5569 2003 2002 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5570 1 2001 2000 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5571 2001 2000 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5572 1 2003 2002 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5573 2003 2002 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5574 1 2005 2004 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5575 1 2004 2005 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5576 1 2007 2006 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5577 1 2006 2007 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5578 0 2005 2004 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5579 2005 2004 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5580 0 2007 2006 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5581 2007 2006 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5582 232 37 2004 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5583 233 37 2005 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5584 234 37 2006 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5585 235 37 2007 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m5586 2008 42 232 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5587 2009 42 233 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5588 2010 42 234 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5589 2011 42 235 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m5590 0 2009 2008 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5591 2009 2008 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5592 0 2011 2010 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5593 2011 2010 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5594 1 2009 2008 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5595 2009 2008 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5596 1 2011 2010 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5597 2011 2010 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5598 1 2013 2012 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5599 1 2012 2013 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5600 1 2015 2014 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5601 1 2014 2015 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5602 0 2013 2012 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5603 2013 2012 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5604 0 2015 2014 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5605 2015 2014 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5606 231 42 2012 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5607 230 42 2013 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5608 229 42 2014 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5609 228 42 2015 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5610 2016 37 231 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5611 2017 37 230 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5612 2018 37 229 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5613 2019 37 228 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5614 0 2017 2016 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5615 2017 2016 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5616 0 2019 2018 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5617 2019 2018 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5618 1 2017 2016 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5619 2017 2016 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5620 1 2019 2018 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5621 2019 2018 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5622 1 2021 2020 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5623 1 2020 2021 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5624 1 2023 2022 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5625 1 2022 2023 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5626 0 2021 2020 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5627 2021 2020 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5628 0 2023 2022 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5629 2023 2022 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5630 240 37 2020 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5631 241 37 2021 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5632 242 37 2022 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5633 243 37 2023 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m5634 2024 42 240 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5635 2025 42 241 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5636 2026 42 242 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5637 2027 42 243 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m5638 0 2025 2024 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5639 2025 2024 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5640 0 2027 2026 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5641 2027 2026 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5642 1 2025 2024 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5643 2025 2024 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5644 1 2027 2026 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5645 2027 2026 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5646 1 2029 2028 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5647 1 2028 2029 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5648 1 2031 2030 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5649 1 2030 2031 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5650 0 2029 2028 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5651 2029 2028 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5652 0 2031 2030 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5653 2031 2030 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5654 239 42 2028 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5655 238 42 2029 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5656 237 42 2030 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5657 236 42 2031 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5658 2032 37 239 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5659 2033 37 238 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5660 2034 37 237 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5661 2035 37 236 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5662 0 2033 2032 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5663 2033 2032 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5664 0 2035 2034 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5665 2035 2034 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5666 1 2033 2032 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5667 2033 2032 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5668 1 2035 2034 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5669 2035 2034 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5670 1 2037 2036 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5671 1 2036 2037 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5672 1 2039 2038 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5673 1 2038 2039 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5674 0 2037 2036 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5675 2037 2036 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5676 0 2039 2038 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5677 2039 2038 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5678 184 27 2036 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5679 185 27 2037 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5680 186 27 2038 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5681 187 27 2039 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m5682 2040 31 184 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5683 2041 31 185 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5684 2042 31 186 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5685 2043 31 187 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m5686 0 2041 2040 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5687 2041 2040 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5688 0 2043 2042 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5689 2043 2042 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5690 1 2041 2040 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5691 2041 2040 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5692 1 2043 2042 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5693 2043 2042 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5694 1 2045 2044 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5695 1 2044 2045 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5696 1 2047 2046 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5697 1 2046 2047 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5698 0 2045 2044 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5699 2045 2044 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5700 0 2047 2046 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5701 2047 2046 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5702 183 31 2044 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5703 182 31 2045 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5704 181 31 2046 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5705 180 31 2047 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5706 2048 27 183 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5707 2049 27 182 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5708 2050 27 181 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5709 2051 27 180 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5710 0 2049 2048 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5711 2049 2048 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5712 0 2051 2050 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5713 2051 2050 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5714 1 2049 2048 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5715 2049 2048 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5716 1 2051 2050 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5717 2051 2050 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5718 1 2053 2052 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5719 1 2052 2053 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5720 1 2055 2054 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5721 1 2054 2055 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5722 0 2053 2052 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5723 2053 2052 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5724 0 2055 2054 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5725 2055 2054 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5726 192 27 2052 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5727 193 27 2053 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5728 194 27 2054 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5729 195 27 2055 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m5730 2056 31 192 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5731 2057 31 193 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5732 2058 31 194 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5733 2059 31 195 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m5734 0 2057 2056 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5735 2057 2056 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5736 0 2059 2058 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5737 2059 2058 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5738 1 2057 2056 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5739 2057 2056 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5740 1 2059 2058 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5741 2059 2058 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5742 1 2061 2060 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5743 1 2060 2061 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5744 1 2063 2062 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5745 1 2062 2063 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5746 0 2061 2060 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5747 2061 2060 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5748 0 2063 2062 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5749 2063 2062 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5750 191 31 2060 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5751 190 31 2061 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5752 189 31 2062 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5753 188 31 2063 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5754 2064 27 191 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5755 2065 27 190 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5756 2066 27 189 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5757 2067 27 188 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5758 0 2065 2064 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5759 2065 2064 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5760 0 2067 2066 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5761 2067 2066 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5762 1 2065 2064 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5763 2065 2064 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5764 1 2067 2066 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5765 2067 2066 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5766 1 2069 2068 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5767 1 2068 2069 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5768 1 2071 2070 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5769 1 2070 2071 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5770 0 2069 2068 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5771 2069 2068 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5772 0 2071 2070 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5773 2071 2070 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5774 200 27 2068 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5775 201 27 2069 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5776 202 27 2070 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5777 203 27 2071 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m5778 2072 31 200 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5779 2073 31 201 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5780 2074 31 202 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5781 2075 31 203 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m5782 0 2073 2072 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5783 2073 2072 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5784 0 2075 2074 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5785 2075 2074 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5786 1 2073 2072 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5787 2073 2072 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5788 1 2075 2074 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5789 2075 2074 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5790 1 2077 2076 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5791 1 2076 2077 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5792 1 2079 2078 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5793 1 2078 2079 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5794 0 2077 2076 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5795 2077 2076 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5796 0 2079 2078 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5797 2079 2078 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5798 199 31 2076 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5799 198 31 2077 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5800 197 31 2078 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5801 196 31 2079 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5802 2080 27 199 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5803 2081 27 198 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5804 2082 27 197 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5805 2083 27 196 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5806 0 2081 2080 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5807 2081 2080 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5808 0 2083 2082 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5809 2083 2082 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5810 1 2081 2080 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5811 2081 2080 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5812 1 2083 2082 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5813 2083 2082 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5814 1 2085 2084 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5815 1 2084 2085 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5816 1 2087 2086 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5817 1 2086 2087 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5818 0 2085 2084 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5819 2085 2084 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5820 0 2087 2086 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5821 2087 2086 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5822 208 27 2084 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5823 209 27 2085 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5824 210 27 2086 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5825 211 27 2087 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m5826 2088 31 208 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5827 2089 31 209 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5828 2090 31 210 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5829 2091 31 211 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m5830 0 2089 2088 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5831 2089 2088 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5832 0 2091 2090 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5833 2091 2090 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5834 1 2089 2088 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5835 2089 2088 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5836 1 2091 2090 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5837 2091 2090 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5838 1 2093 2092 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5839 1 2092 2093 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5840 1 2095 2094 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5841 1 2094 2095 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5842 0 2093 2092 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5843 2093 2092 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5844 0 2095 2094 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5845 2095 2094 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5846 207 31 2092 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5847 206 31 2093 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5848 205 31 2094 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5849 204 31 2095 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5850 2096 27 207 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5851 2097 27 206 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5852 2098 27 205 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5853 2099 27 204 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5854 0 2097 2096 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5855 2097 2096 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5856 0 2099 2098 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5857 2099 2098 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5858 1 2097 2096 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5859 2097 2096 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5860 1 2099 2098 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5861 2099 2098 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5862 1 2101 2100 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5863 1 2100 2101 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5864 1 2103 2102 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5865 1 2102 2103 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5866 0 2101 2100 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5867 2101 2100 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5868 0 2103 2102 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5869 2103 2102 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5870 216 27 2100 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5871 217 27 2101 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5872 218 27 2102 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5873 219 27 2103 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m5874 2104 31 216 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5875 2105 31 217 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5876 2106 31 218 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5877 2107 31 219 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m5878 0 2105 2104 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5879 2105 2104 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5880 0 2107 2106 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5881 2107 2106 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5882 1 2105 2104 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5883 2105 2104 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5884 1 2107 2106 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5885 2107 2106 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5886 1 2109 2108 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5887 1 2108 2109 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5888 1 2111 2110 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5889 1 2110 2111 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5890 0 2109 2108 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5891 2109 2108 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5892 0 2111 2110 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5893 2111 2110 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5894 215 31 2108 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5895 214 31 2109 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5896 213 31 2110 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5897 212 31 2111 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5898 2112 27 215 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5899 2113 27 214 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5900 2114 27 213 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5901 2115 27 212 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5902 0 2113 2112 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5903 2113 2112 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5904 0 2115 2114 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5905 2115 2114 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5906 1 2113 2112 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5907 2113 2112 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5908 1 2115 2114 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5909 2115 2114 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5910 1 2117 2116 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5911 1 2116 2117 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5912 1 2119 2118 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5913 1 2118 2119 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5914 0 2117 2116 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5915 2117 2116 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5916 0 2119 2118 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5917 2119 2118 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5918 224 27 2116 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5919 225 27 2117 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5920 226 27 2118 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5921 227 27 2119 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m5922 2120 31 224 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5923 2121 31 225 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5924 2122 31 226 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5925 2123 31 227 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m5926 0 2121 2120 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5927 2121 2120 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5928 0 2123 2122 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5929 2123 2122 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5930 1 2121 2120 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5931 2121 2120 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5932 1 2123 2122 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5933 2123 2122 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5934 1 2125 2124 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5935 1 2124 2125 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5936 1 2127 2126 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5937 1 2126 2127 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5938 0 2125 2124 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5939 2125 2124 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5940 0 2127 2126 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5941 2127 2126 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5942 223 31 2124 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5943 222 31 2125 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5944 221 31 2126 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5945 220 31 2127 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5946 2128 27 223 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5947 2129 27 222 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5948 2130 27 221 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5949 2131 27 220 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5950 0 2129 2128 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5951 2129 2128 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5952 0 2131 2130 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5953 2131 2130 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5954 1 2129 2128 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5955 2129 2128 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5956 1 2131 2130 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5957 2131 2130 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5958 1 2133 2132 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5959 1 2132 2133 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5960 1 2135 2134 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5961 1 2134 2135 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5962 0 2133 2132 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5963 2133 2132 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5964 0 2135 2134 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5965 2135 2134 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5966 232 27 2132 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5967 233 27 2133 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5968 234 27 2134 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5969 235 27 2135 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m5970 2136 31 232 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5971 2137 31 233 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5972 2138 31 234 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5973 2139 31 235 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m5974 0 2137 2136 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5975 2137 2136 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5976 0 2139 2138 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5977 2139 2138 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5978 1 2137 2136 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5979 2137 2136 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5980 1 2139 2138 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5981 2139 2138 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m5982 1 2141 2140 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5983 1 2140 2141 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5984 1 2143 2142 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5985 1 2142 2143 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m5986 0 2141 2140 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5987 2141 2140 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m5988 0 2143 2142 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m5989 2143 2142 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m5990 231 31 2140 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m5991 230 31 2141 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m5992 229 31 2142 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5993 228 31 2143 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m5994 2144 27 231 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m5995 2145 27 230 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m5996 2146 27 229 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5997 2147 27 228 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m5998 0 2145 2144 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m5999 2145 2144 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6000 0 2147 2146 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6001 2147 2146 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6002 1 2145 2144 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6003 2145 2144 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6004 1 2147 2146 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6005 2147 2146 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6006 1 2149 2148 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6007 1 2148 2149 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6008 1 2151 2150 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6009 1 2150 2151 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6010 0 2149 2148 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6011 2149 2148 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6012 0 2151 2150 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6013 2151 2150 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6014 240 27 2148 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m6015 241 27 2149 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m6016 242 27 2150 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m6017 243 27 2151 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m6018 2152 31 240 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m6019 2153 31 241 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m6020 2154 31 242 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m6021 2155 31 243 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m6022 0 2153 2152 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6023 2153 2152 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6024 0 2155 2154 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6025 2155 2154 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6026 1 2153 2152 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6027 2153 2152 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6028 1 2155 2154 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6029 2155 2154 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6030 1 2157 2156 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6031 1 2156 2157 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6032 1 2159 2158 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6033 1 2158 2159 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6034 0 2157 2156 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6035 2157 2156 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6036 0 2159 2158 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6037 2159 2158 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6038 239 31 2156 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m6039 238 31 2157 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m6040 237 31 2158 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m6041 236 31 2159 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m6042 2160 27 239 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m6043 2161 27 238 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m6044 2162 27 237 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m6045 2163 27 236 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m6046 0 2161 2160 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6047 2161 2160 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6048 0 2163 2162 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6049 2163 2162 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6050 1 2161 2160 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6051 2161 2160 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6052 1 2163 2162 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6053 2163 2162 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6054 1 2165 2164 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6055 1 2164 2165 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6056 1 2167 2166 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6057 1 2166 2167 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6058 0 2165 2164 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6059 2165 2164 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6060 0 2167 2166 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6061 2167 2166 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6062 184 14 2164 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m6063 185 14 2165 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m6064 186 14 2166 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m6065 187 14 2167 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m6066 2168 20 184 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m6067 2169 20 185 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m6068 2170 20 186 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m6069 2171 20 187 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m6070 0 2169 2168 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6071 2169 2168 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6072 0 2171 2170 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6073 2171 2170 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6074 1 2169 2168 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6075 2169 2168 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6076 1 2171 2170 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6077 2171 2170 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6078 1 2173 2172 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6079 1 2172 2173 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6080 1 2175 2174 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6081 1 2174 2175 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6082 0 2173 2172 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6083 2173 2172 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6084 0 2175 2174 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6085 2175 2174 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6086 183 20 2172 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m6087 182 20 2173 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m6088 181 20 2174 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m6089 180 20 2175 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m6090 2176 14 183 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m6091 2177 14 182 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m6092 2178 14 181 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m6093 2179 14 180 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m6094 0 2177 2176 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6095 2177 2176 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6096 0 2179 2178 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6097 2179 2178 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6098 1 2177 2176 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6099 2177 2176 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6100 1 2179 2178 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6101 2179 2178 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6102 1 2181 2180 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6103 1 2180 2181 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6104 1 2183 2182 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6105 1 2182 2183 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6106 0 2181 2180 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6107 2181 2180 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6108 0 2183 2182 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6109 2183 2182 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6110 192 14 2180 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m6111 193 14 2181 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m6112 194 14 2182 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m6113 195 14 2183 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m6114 2184 20 192 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m6115 2185 20 193 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m6116 2186 20 194 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m6117 2187 20 195 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m6118 0 2185 2184 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6119 2185 2184 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6120 0 2187 2186 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6121 2187 2186 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6122 1 2185 2184 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6123 2185 2184 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6124 1 2187 2186 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6125 2187 2186 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6126 1 2189 2188 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6127 1 2188 2189 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6128 1 2191 2190 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6129 1 2190 2191 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6130 0 2189 2188 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6131 2189 2188 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6132 0 2191 2190 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6133 2191 2190 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6134 191 20 2188 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m6135 190 20 2189 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m6136 189 20 2190 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m6137 188 20 2191 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m6138 2192 14 191 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m6139 2193 14 190 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m6140 2194 14 189 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m6141 2195 14 188 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m6142 0 2193 2192 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6143 2193 2192 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6144 0 2195 2194 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6145 2195 2194 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6146 1 2193 2192 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6147 2193 2192 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6148 1 2195 2194 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6149 2195 2194 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6150 1 2197 2196 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6151 1 2196 2197 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6152 1 2199 2198 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6153 1 2198 2199 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6154 0 2197 2196 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6155 2197 2196 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6156 0 2199 2198 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6157 2199 2198 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6158 200 14 2196 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m6159 201 14 2197 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m6160 202 14 2198 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m6161 203 14 2199 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m6162 2200 20 200 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m6163 2201 20 201 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m6164 2202 20 202 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m6165 2203 20 203 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m6166 0 2201 2200 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6167 2201 2200 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6168 0 2203 2202 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6169 2203 2202 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6170 1 2201 2200 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6171 2201 2200 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6172 1 2203 2202 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6173 2203 2202 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6174 1 2205 2204 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6175 1 2204 2205 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6176 1 2207 2206 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6177 1 2206 2207 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6178 0 2205 2204 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6179 2205 2204 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6180 0 2207 2206 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6181 2207 2206 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6182 199 20 2204 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m6183 198 20 2205 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m6184 197 20 2206 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m6185 196 20 2207 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m6186 2208 14 199 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m6187 2209 14 198 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m6188 2210 14 197 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m6189 2211 14 196 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m6190 0 2209 2208 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6191 2209 2208 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6192 0 2211 2210 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6193 2211 2210 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6194 1 2209 2208 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6195 2209 2208 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6196 1 2211 2210 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6197 2211 2210 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6198 1 2213 2212 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6199 1 2212 2213 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6200 1 2215 2214 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6201 1 2214 2215 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6202 0 2213 2212 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6203 2213 2212 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6204 0 2215 2214 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6205 2215 2214 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6206 208 14 2212 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m6207 209 14 2213 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m6208 210 14 2214 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m6209 211 14 2215 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m6210 2216 20 208 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m6211 2217 20 209 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m6212 2218 20 210 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m6213 2219 20 211 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m6214 0 2217 2216 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6215 2217 2216 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6216 0 2219 2218 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6217 2219 2218 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6218 1 2217 2216 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6219 2217 2216 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6220 1 2219 2218 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6221 2219 2218 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6222 1 2221 2220 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6223 1 2220 2221 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6224 1 2223 2222 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6225 1 2222 2223 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6226 0 2221 2220 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6227 2221 2220 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6228 0 2223 2222 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6229 2223 2222 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6230 207 20 2220 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m6231 206 20 2221 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m6232 205 20 2222 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m6233 204 20 2223 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m6234 2224 14 207 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m6235 2225 14 206 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m6236 2226 14 205 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m6237 2227 14 204 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m6238 0 2225 2224 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6239 2225 2224 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6240 0 2227 2226 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6241 2227 2226 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6242 1 2225 2224 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6243 2225 2224 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6244 1 2227 2226 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6245 2227 2226 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6246 1 2229 2228 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6247 1 2228 2229 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6248 1 2231 2230 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6249 1 2230 2231 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6250 0 2229 2228 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6251 2229 2228 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6252 0 2231 2230 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6253 2231 2230 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6254 216 14 2228 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m6255 217 14 2229 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m6256 218 14 2230 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m6257 219 14 2231 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m6258 2232 20 216 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m6259 2233 20 217 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m6260 2234 20 218 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m6261 2235 20 219 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m6262 0 2233 2232 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6263 2233 2232 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6264 0 2235 2234 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6265 2235 2234 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6266 1 2233 2232 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6267 2233 2232 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6268 1 2235 2234 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6269 2235 2234 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6270 1 2237 2236 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6271 1 2236 2237 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6272 1 2239 2238 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6273 1 2238 2239 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6274 0 2237 2236 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6275 2237 2236 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6276 0 2239 2238 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6277 2239 2238 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6278 215 20 2236 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m6279 214 20 2237 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m6280 213 20 2238 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m6281 212 20 2239 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m6282 2240 14 215 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m6283 2241 14 214 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m6284 2242 14 213 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m6285 2243 14 212 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m6286 0 2241 2240 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6287 2241 2240 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6288 0 2243 2242 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6289 2243 2242 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6290 1 2241 2240 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6291 2241 2240 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6292 1 2243 2242 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6293 2243 2242 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6294 1 2245 2244 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6295 1 2244 2245 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6296 1 2247 2246 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6297 1 2246 2247 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6298 0 2245 2244 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6299 2245 2244 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6300 0 2247 2246 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6301 2247 2246 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6302 224 14 2244 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m6303 225 14 2245 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m6304 226 14 2246 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m6305 227 14 2247 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m6306 2248 20 224 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m6307 2249 20 225 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m6308 2250 20 226 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m6309 2251 20 227 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m6310 0 2249 2248 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6311 2249 2248 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6312 0 2251 2250 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6313 2251 2250 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6314 1 2249 2248 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6315 2249 2248 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6316 1 2251 2250 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6317 2251 2250 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6318 1 2253 2252 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6319 1 2252 2253 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6320 1 2255 2254 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6321 1 2254 2255 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6322 0 2253 2252 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6323 2253 2252 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6324 0 2255 2254 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6325 2255 2254 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6326 223 20 2252 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m6327 222 20 2253 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m6328 221 20 2254 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m6329 220 20 2255 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m6330 2256 14 223 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m6331 2257 14 222 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m6332 2258 14 221 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m6333 2259 14 220 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m6334 0 2257 2256 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6335 2257 2256 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6336 0 2259 2258 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6337 2259 2258 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6338 1 2257 2256 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6339 2257 2256 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6340 1 2259 2258 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6341 2259 2258 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6342 1 2261 2260 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6343 1 2260 2261 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6344 1 2263 2262 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6345 1 2262 2263 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6346 0 2261 2260 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6347 2261 2260 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6348 0 2263 2262 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6349 2263 2262 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6350 232 14 2260 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m6351 233 14 2261 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m6352 234 14 2262 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m6353 235 14 2263 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m6354 2264 20 232 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m6355 2265 20 233 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m6356 2266 20 234 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m6357 2267 20 235 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m6358 0 2265 2264 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6359 2265 2264 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6360 0 2267 2266 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6361 2267 2266 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6362 1 2265 2264 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6363 2265 2264 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6364 1 2267 2266 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6365 2267 2266 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6366 1 2269 2268 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6367 1 2268 2269 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6368 1 2271 2270 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6369 1 2270 2271 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6370 0 2269 2268 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6371 2269 2268 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6372 0 2271 2270 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6373 2271 2270 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6374 231 20 2268 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m6375 230 20 2269 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m6376 229 20 2270 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m6377 228 20 2271 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m6378 2272 14 231 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m6379 2273 14 230 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m6380 2274 14 229 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m6381 2275 14 228 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m6382 0 2273 2272 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6383 2273 2272 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6384 0 2275 2274 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6385 2275 2274 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6386 1 2273 2272 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6387 2273 2272 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6388 1 2275 2274 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6389 2275 2274 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6390 1 2277 2276 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6391 1 2276 2277 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6392 1 2279 2278 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6393 1 2278 2279 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6394 0 2277 2276 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6395 2277 2276 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6396 0 2279 2278 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6397 2279 2278 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6398 240 14 2276 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m6399 241 14 2277 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m6400 242 14 2278 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m6401 243 14 2279 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.83e-12 ad=4.39e-12 ps=5.13e-06 pd=3.88e-06
+ nrs=1.89 nrd=1.71
m6402 2280 20 240 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m6403 2281 20 241 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m6404 2282 20 242 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m6405 2283 20 243 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.83e-12 ps=3.88e-06 pd=5.13e-06
+ nrs=1.71 nrd=1.89
m6406 0 2281 2280 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6407 2281 2280 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6408 0 2283 2282 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6409 2283 2282 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6410 1 2281 2280 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6411 2281 2280 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6412 1 2283 2282 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6413 2283 2282 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6414 1 2285 2284 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6415 1 2284 2285 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6416 1 2287 2286 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6417 1 2286 2287 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6418 0 2285 2284 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6419 2285 2284 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6420 0 2287 2286 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6421 2287 2286 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6422 239 20 2284 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.49e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.75
m6423 238 20 2285 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.63e-12 ps=5.11e-06 pd=4.12e-06
+ nrs=1.87 nrd=1.81
m6424 237 20 2286 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m6425 236 20 2287 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.79e-12 ad=4.39e-12 ps=5.11e-06 pd=3.88e-06
+ nrs=1.87 nrd=1.71
m6426 2288 14 239 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.49e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.75 nrd=1.87
m6427 2289 14 238 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.63e-12 ad=4.79e-12 ps=4.12e-06 pd=5.11e-06
+ nrs=1.81 nrd=1.87
m6428 2290 14 237 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m6429 2291 14 236 0 nenh l=1.1e-06 w=1.6e-06
+ as=4.39e-12 ad=4.79e-12 ps=3.88e-06 pd=5.11e-06
+ nrs=1.71 nrd=1.87
m6430 0 2289 2288 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=1.009e-11 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.78
m6431 2289 2288 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=1.043e-11 ad=9.82e-12 ps=9.28e-06 pd=5.86e-06
+ nrs=0.8 nrd=0.76
m6432 0 2291 2290 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.82e-12 ad=9.87e-12 ps=5.86e-06 pd=8.72e-06
+ nrs=0.76 nrd=0.76
m6433 2291 2290 0 0 nenh l=1.1e-06 w=3.6e-06
+ as=9.87e-12 ad=9.82e-12 ps=8.72e-06 pd=5.86e-06
+ nrs=0.76 nrd=0.76
m6434 1 2289 2288 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6435 2289 2288 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6436 1 2291 2290 1 penh l=2.1e-06 w=3.4e-06
+ as=8.23e-12 ad=8.54e-12 ps=5.87e-06 pd=8.3e-06
+ nrs=0.71 nrd=0.74
m6437 2291 2290 1 1 penh l=2.1e-06 w=3.4e-06
+ as=8.54e-12 ad=8.23e-12 ps=8.3e-06 pd=5.87e-06
+ nrs=0.74 nrd=0.71
m6438 2292 2294 2293 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.148e-11 ps=1.7e-06 pd=1.17e-05
+ nrs=0.15 nrd=0.37
m6439 2295 2296 2292 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6440 2297 2298 2295 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6441 0 2299 2297 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6442 2300 2293 0 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.64e-12 ps=8.9e-06 pd=4.56e-06
+ nrs=1.09 nrd=0.97
m6443 0 2302 2301 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.64e-12 ad=8.54e-12 ps=4.56e-06 pd=8.9e-06
+ nrs=0.97 nrd=1.09
m6444 2303 2305 2304 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.148e-11 ps=1.7e-06 pd=1.17e-05
+ nrs=0.15 nrd=0.37
m6445 2306 2296 2303 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6446 2307 2298 2306 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6447 0 2299 2307 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6448 2308 2304 0 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.64e-12 ps=8.9e-06 pd=4.56e-06
+ nrs=1.09 nrd=0.97
m6449 2309 2299 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6450 2310 2298 2309 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6451 2311 2296 2310 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6452 2302 2312 2311 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=4.76e-12 ps=1.17e-05 pd=1.7e-06
+ nrs=0.37 nrd=0.15
m6453 0 2314 2313 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.64e-12 ad=8.54e-12 ps=4.56e-06 pd=8.9e-06
+ nrs=0.97 nrd=1.09
m6454 2315 2299 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6455 2316 2298 2315 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6456 2317 2296 2316 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6457 2314 2318 2317 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=4.76e-12 ps=1.17e-05 pd=1.7e-06
+ nrs=0.37 nrd=0.15
m6458 1 2299 2304 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6459 2308 2304 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6460 1 2299 2293 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6461 2300 2293 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6462 1 2302 2301 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6463 2319 2308 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6464 180 2320 2319 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6465 2302 2299 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6466 1 2314 2313 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6467 2314 2299 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6468 2321 2322 181 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.678e-11 ps=1.7e-06 pd=1.787e-05
+ nrs=0.15 nrd=0.54
m6469 0 2308 2321 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6470 2323 2300 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6471 182 2320 2323 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6472 2324 2322 183 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.678e-11 ps=1.7e-06 pd=1.787e-05
+ nrs=0.15 nrd=0.54
m6473 0 2300 2324 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6474 2325 2301 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6475 184 2322 2325 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6476 2326 2320 185 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.678e-11 ps=1.7e-06 pd=1.787e-05
+ nrs=0.15 nrd=0.54
m6477 0 2301 2326 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6478 2327 2313 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6479 186 2322 2327 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6480 2328 2320 187 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.689e-11 ps=1.7e-06 pd=1.795e-05
+ nrs=0.15 nrd=0.54
m6481 0 2313 2328 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6482 2329 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6483 2330 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6484 2331 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6485 2332 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6486 2329 180 2333 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6487 2334 181 2329 0 nenh l=1.1e-06 w=2.8e-06
+ as=9.66e-12 ad=7.51e-12 ps=9.7e-06 pd=3.2e-06
+ nrs=1.23 nrd=0.96
m6488 2330 182 2335 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6489 2336 183 2330 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.51e-12 ps=8.9e-06 pd=3.2e-06
+ nrs=1.09 nrd=0.96
m6490 2331 184 2337 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6491 2338 185 2331 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.51e-12 ps=8.9e-06 pd=3.2e-06
+ nrs=1.09 nrd=0.96
m6492 2332 186 2339 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6493 2340 187 2332 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.51e-12 ps=8.9e-06 pd=3.2e-06
+ nrs=1.09 nrd=0.96
m6494 1 2334 2333 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6495 2334 2334 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6496 1 2336 2335 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6497 2336 2336 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6498 1 2337 2337 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6499 2338 2337 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6500 1 2339 2339 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6501 2340 2339 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6502 2341 2343 2342 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.148e-11 ps=1.7e-06 pd=1.17e-05
+ nrs=0.15 nrd=0.37
m6503 2344 2296 2341 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6504 2345 2298 2344 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6505 0 2299 2345 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6506 2346 2342 0 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.64e-12 ps=8.9e-06 pd=4.56e-06
+ nrs=1.09 nrd=0.97
m6507 0 2348 2347 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.64e-12 ad=8.54e-12 ps=4.56e-06 pd=8.9e-06
+ nrs=0.97 nrd=1.09
m6508 2349 2351 2350 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.148e-11 ps=1.7e-06 pd=1.17e-05
+ nrs=0.15 nrd=0.37
m6509 2352 2296 2349 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6510 2353 2298 2352 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6511 0 2299 2353 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6512 2354 2350 0 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.64e-12 ps=8.9e-06 pd=4.56e-06
+ nrs=1.09 nrd=0.97
m6513 2355 2299 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6514 2356 2298 2355 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6515 2357 2296 2356 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6516 2348 2358 2357 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=4.76e-12 ps=1.17e-05 pd=1.7e-06
+ nrs=0.37 nrd=0.15
m6517 0 2360 2359 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.64e-12 ad=8.54e-12 ps=4.56e-06 pd=8.9e-06
+ nrs=0.97 nrd=1.09
m6518 2361 2299 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6519 2362 2298 2361 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6520 2363 2296 2362 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6521 2360 2364 2363 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=4.76e-12 ps=1.17e-05 pd=1.7e-06
+ nrs=0.37 nrd=0.15
m6522 1 2299 2350 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6523 2354 2350 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6524 1 2299 2342 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6525 2346 2342 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6526 1 2348 2347 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6527 2365 2354 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6528 188 2320 2365 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6529 2348 2299 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6530 1 2360 2359 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6531 2360 2299 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6532 2366 2322 189 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.678e-11 ps=1.7e-06 pd=1.787e-05
+ nrs=0.15 nrd=0.54
m6533 0 2354 2366 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6534 2367 2346 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6535 190 2320 2367 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6536 2368 2322 191 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.678e-11 ps=1.7e-06 pd=1.787e-05
+ nrs=0.15 nrd=0.54
m6537 0 2346 2368 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6538 2369 2347 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6539 192 2322 2369 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6540 2370 2320 193 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.678e-11 ps=1.7e-06 pd=1.787e-05
+ nrs=0.15 nrd=0.54
m6541 0 2347 2370 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6542 2371 2359 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6543 194 2322 2371 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6544 2372 2320 195 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.689e-11 ps=1.7e-06 pd=1.795e-05
+ nrs=0.15 nrd=0.54
m6545 0 2359 2372 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6546 2373 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6547 2374 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6548 2375 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6549 2376 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6550 2373 188 2377 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6551 2378 189 2373 0 nenh l=1.1e-06 w=2.8e-06
+ as=9.66e-12 ad=7.51e-12 ps=9.7e-06 pd=3.2e-06
+ nrs=1.23 nrd=0.96
m6552 2374 190 2379 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6553 2380 191 2374 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.51e-12 ps=8.9e-06 pd=3.2e-06
+ nrs=1.09 nrd=0.96
m6554 2375 192 2381 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6555 2382 193 2375 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.51e-12 ps=8.9e-06 pd=3.2e-06
+ nrs=1.09 nrd=0.96
m6556 2376 194 2383 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6557 2384 195 2376 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.51e-12 ps=8.9e-06 pd=3.2e-06
+ nrs=1.09 nrd=0.96
m6558 1 2378 2377 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6559 2378 2378 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6560 1 2380 2379 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6561 2380 2380 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6562 1 2381 2381 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6563 2382 2381 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6564 1 2383 2383 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6565 2384 2383 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6566 2385 2294 2386 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.148e-11 ps=1.7e-06 pd=1.17e-05
+ nrs=0.15 nrd=0.37
m6567 2387 2296 2385 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6568 2388 2389 2387 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6569 0 2299 2388 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6570 2390 2386 0 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.64e-12 ps=8.9e-06 pd=4.56e-06
+ nrs=1.09 nrd=0.97
m6571 0 2392 2391 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.64e-12 ad=8.54e-12 ps=4.56e-06 pd=8.9e-06
+ nrs=0.97 nrd=1.09
m6572 2393 2305 2394 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.148e-11 ps=1.7e-06 pd=1.17e-05
+ nrs=0.15 nrd=0.37
m6573 2395 2296 2393 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6574 2396 2389 2395 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6575 0 2299 2396 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6576 2397 2394 0 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.64e-12 ps=8.9e-06 pd=4.56e-06
+ nrs=1.09 nrd=0.97
m6577 2398 2299 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6578 2399 2389 2398 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6579 2400 2296 2399 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6580 2392 2312 2400 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=4.76e-12 ps=1.17e-05 pd=1.7e-06
+ nrs=0.37 nrd=0.15
m6581 0 2402 2401 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.64e-12 ad=8.54e-12 ps=4.56e-06 pd=8.9e-06
+ nrs=0.97 nrd=1.09
m6582 2403 2299 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6583 2404 2389 2403 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6584 2405 2296 2404 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6585 2402 2318 2405 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=4.76e-12 ps=1.17e-05 pd=1.7e-06
+ nrs=0.37 nrd=0.15
m6586 1 2299 2394 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6587 2397 2394 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6588 1 2299 2386 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6589 2390 2386 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6590 1 2392 2391 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6591 2406 2397 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6592 196 2407 2406 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6593 2392 2299 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6594 1 2402 2401 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6595 2402 2299 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6596 2408 2409 197 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.678e-11 ps=1.7e-06 pd=1.787e-05
+ nrs=0.15 nrd=0.54
m6597 0 2397 2408 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6598 2410 2390 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6599 198 2407 2410 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6600 2411 2409 199 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.678e-11 ps=1.7e-06 pd=1.787e-05
+ nrs=0.15 nrd=0.54
m6601 0 2390 2411 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6602 2412 2391 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6603 200 2409 2412 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6604 2413 2407 201 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.678e-11 ps=1.7e-06 pd=1.787e-05
+ nrs=0.15 nrd=0.54
m6605 0 2391 2413 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6606 2414 2401 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6607 202 2409 2414 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6608 2415 2407 203 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.689e-11 ps=1.7e-06 pd=1.795e-05
+ nrs=0.15 nrd=0.54
m6609 0 2401 2415 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6610 2416 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6611 2417 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6612 2418 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6613 2419 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6614 2416 196 2420 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6615 2421 197 2416 0 nenh l=1.1e-06 w=2.8e-06
+ as=9.66e-12 ad=7.51e-12 ps=9.7e-06 pd=3.2e-06
+ nrs=1.23 nrd=0.96
m6616 2417 198 2422 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6617 2423 199 2417 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.51e-12 ps=8.9e-06 pd=3.2e-06
+ nrs=1.09 nrd=0.96
m6618 2418 200 2424 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6619 2425 201 2418 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.51e-12 ps=8.9e-06 pd=3.2e-06
+ nrs=1.09 nrd=0.96
m6620 2419 202 2426 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6621 2427 203 2419 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.51e-12 ps=8.9e-06 pd=3.2e-06
+ nrs=1.09 nrd=0.96
m6622 1 2421 2420 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6623 2421 2421 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6624 1 2423 2422 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6625 2423 2423 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6626 1 2424 2424 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6627 2425 2424 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6628 1 2426 2426 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6629 2427 2426 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6630 2428 2343 2429 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.148e-11 ps=1.7e-06 pd=1.17e-05
+ nrs=0.15 nrd=0.37
m6631 2430 2296 2428 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6632 2431 2389 2430 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6633 0 2299 2431 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6634 2432 2429 0 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.64e-12 ps=8.9e-06 pd=4.56e-06
+ nrs=1.09 nrd=0.97
m6635 0 2434 2433 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.64e-12 ad=8.54e-12 ps=4.56e-06 pd=8.9e-06
+ nrs=0.97 nrd=1.09
m6636 2435 2351 2436 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.148e-11 ps=1.7e-06 pd=1.17e-05
+ nrs=0.15 nrd=0.37
m6637 2437 2296 2435 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6638 2438 2389 2437 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6639 0 2299 2438 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6640 2439 2436 0 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.64e-12 ps=8.9e-06 pd=4.56e-06
+ nrs=1.09 nrd=0.97
m6641 2440 2299 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6642 2441 2389 2440 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6643 2442 2296 2441 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6644 2434 2358 2442 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=4.76e-12 ps=1.17e-05 pd=1.7e-06
+ nrs=0.37 nrd=0.15
m6645 0 2444 2443 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.64e-12 ad=8.54e-12 ps=4.56e-06 pd=8.9e-06
+ nrs=0.97 nrd=1.09
m6646 2445 2299 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6647 2446 2389 2445 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6648 2447 2296 2446 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6649 2444 2364 2447 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=4.76e-12 ps=1.17e-05 pd=1.7e-06
+ nrs=0.37 nrd=0.15
m6650 1 2299 2436 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6651 2439 2436 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6652 1 2299 2429 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6653 2432 2429 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6654 1 2434 2433 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6655 2448 2439 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6656 204 2407 2448 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6657 2434 2299 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6658 1 2444 2443 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6659 2444 2299 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6660 2449 2409 205 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.678e-11 ps=1.7e-06 pd=1.787e-05
+ nrs=0.15 nrd=0.54
m6661 0 2439 2449 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6662 2450 2432 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6663 206 2407 2450 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6664 2451 2409 207 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.678e-11 ps=1.7e-06 pd=1.787e-05
+ nrs=0.15 nrd=0.54
m6665 0 2432 2451 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6666 2452 2433 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6667 208 2409 2452 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6668 2453 2407 209 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.678e-11 ps=1.7e-06 pd=1.787e-05
+ nrs=0.15 nrd=0.54
m6669 0 2433 2453 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6670 2454 2443 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6671 210 2409 2454 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6672 2455 2407 211 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.689e-11 ps=1.7e-06 pd=1.795e-05
+ nrs=0.15 nrd=0.54
m6673 0 2443 2455 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6674 2456 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6675 2457 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6676 2458 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6677 2459 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6678 2456 204 2460 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6679 2461 205 2456 0 nenh l=1.1e-06 w=2.8e-06
+ as=9.66e-12 ad=7.51e-12 ps=9.7e-06 pd=3.2e-06
+ nrs=1.23 nrd=0.96
m6680 2457 206 2462 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6681 2463 207 2457 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.51e-12 ps=8.9e-06 pd=3.2e-06
+ nrs=1.09 nrd=0.96
m6682 2458 208 2464 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6683 2465 209 2458 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.51e-12 ps=8.9e-06 pd=3.2e-06
+ nrs=1.09 nrd=0.96
m6684 2459 210 2466 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6685 2467 211 2459 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.51e-12 ps=8.9e-06 pd=3.2e-06
+ nrs=1.09 nrd=0.96
m6686 1 2461 2460 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6687 2461 2461 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6688 1 2463 2462 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6689 2463 2463 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6690 1 2464 2464 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6691 2465 2464 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6692 1 2466 2466 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6693 2467 2466 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6694 2468 2294 2469 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.148e-11 ps=1.7e-06 pd=1.17e-05
+ nrs=0.15 nrd=0.37
m6695 2470 2471 2468 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6696 2472 2298 2470 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6697 0 2299 2472 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6698 2473 2469 0 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.64e-12 ps=8.9e-06 pd=4.56e-06
+ nrs=1.09 nrd=0.97
m6699 0 2475 2474 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.64e-12 ad=8.54e-12 ps=4.56e-06 pd=8.9e-06
+ nrs=0.97 nrd=1.09
m6700 2476 2305 2477 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.148e-11 ps=1.7e-06 pd=1.17e-05
+ nrs=0.15 nrd=0.37
m6701 2478 2471 2476 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6702 2479 2298 2478 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6703 0 2299 2479 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6704 2480 2477 0 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.64e-12 ps=8.9e-06 pd=4.56e-06
+ nrs=1.09 nrd=0.97
m6705 2481 2299 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6706 2482 2298 2481 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6707 2483 2471 2482 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6708 2475 2312 2483 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=4.76e-12 ps=1.17e-05 pd=1.7e-06
+ nrs=0.37 nrd=0.15
m6709 0 2485 2484 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.64e-12 ad=8.54e-12 ps=4.56e-06 pd=8.9e-06
+ nrs=0.97 nrd=1.09
m6710 2486 2299 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6711 2487 2298 2486 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6712 2488 2471 2487 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6713 2485 2318 2488 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=4.76e-12 ps=1.17e-05 pd=1.7e-06
+ nrs=0.37 nrd=0.15
m6714 1 2299 2477 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6715 2480 2477 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6716 1 2299 2469 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6717 2473 2469 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6718 1 2475 2474 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6719 2489 2480 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6720 212 2490 2489 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6721 2475 2299 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6722 1 2485 2484 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6723 2485 2299 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6724 2491 2492 213 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.678e-11 ps=1.7e-06 pd=1.787e-05
+ nrs=0.15 nrd=0.54
m6725 0 2480 2491 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6726 2493 2473 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6727 214 2490 2493 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6728 2494 2492 215 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.678e-11 ps=1.7e-06 pd=1.787e-05
+ nrs=0.15 nrd=0.54
m6729 0 2473 2494 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6730 2495 2474 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6731 216 2492 2495 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6732 2496 2490 217 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.678e-11 ps=1.7e-06 pd=1.787e-05
+ nrs=0.15 nrd=0.54
m6733 0 2474 2496 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6734 2497 2484 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6735 218 2492 2497 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6736 2498 2490 219 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.689e-11 ps=1.7e-06 pd=1.795e-05
+ nrs=0.15 nrd=0.54
m6737 0 2484 2498 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6738 2499 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6739 2500 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6740 2501 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6741 2502 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6742 2499 212 2503 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6743 2504 213 2499 0 nenh l=1.1e-06 w=2.8e-06
+ as=9.66e-12 ad=7.51e-12 ps=9.7e-06 pd=3.2e-06
+ nrs=1.23 nrd=0.96
m6744 2500 214 2505 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6745 2506 215 2500 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.51e-12 ps=8.9e-06 pd=3.2e-06
+ nrs=1.09 nrd=0.96
m6746 2501 216 2507 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6747 2508 217 2501 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.51e-12 ps=8.9e-06 pd=3.2e-06
+ nrs=1.09 nrd=0.96
m6748 2502 218 2509 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6749 2510 219 2502 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.51e-12 ps=8.9e-06 pd=3.2e-06
+ nrs=1.09 nrd=0.96
m6750 1 2504 2503 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6751 2504 2504 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6752 1 2506 2505 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6753 2506 2506 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6754 1 2507 2507 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6755 2508 2507 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6756 1 2509 2509 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6757 2510 2509 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6758 2511 2343 2512 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.148e-11 ps=1.7e-06 pd=1.17e-05
+ nrs=0.15 nrd=0.37
m6759 2513 2471 2511 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6760 2514 2298 2513 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6761 0 2299 2514 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6762 2515 2512 0 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.64e-12 ps=8.9e-06 pd=4.56e-06
+ nrs=1.09 nrd=0.97
m6763 0 2517 2516 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.64e-12 ad=8.54e-12 ps=4.56e-06 pd=8.9e-06
+ nrs=0.97 nrd=1.09
m6764 2518 2351 2519 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.148e-11 ps=1.7e-06 pd=1.17e-05
+ nrs=0.15 nrd=0.37
m6765 2520 2471 2518 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6766 2521 2298 2520 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6767 0 2299 2521 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6768 2522 2519 0 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.64e-12 ps=8.9e-06 pd=4.56e-06
+ nrs=1.09 nrd=0.97
m6769 2523 2299 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6770 2524 2298 2523 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6771 2525 2471 2524 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6772 2517 2358 2525 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=4.76e-12 ps=1.17e-05 pd=1.7e-06
+ nrs=0.37 nrd=0.15
m6773 0 2527 2526 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.64e-12 ad=8.54e-12 ps=4.56e-06 pd=8.9e-06
+ nrs=0.97 nrd=1.09
m6774 2528 2299 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6775 2529 2298 2528 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6776 2530 2471 2529 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6777 2527 2364 2530 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=4.76e-12 ps=1.17e-05 pd=1.7e-06
+ nrs=0.37 nrd=0.15
m6778 1 2299 2519 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6779 2522 2519 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6780 1 2299 2512 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6781 2515 2512 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6782 1 2517 2516 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6783 2531 2522 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6784 220 2490 2531 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6785 2517 2299 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6786 1 2527 2526 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6787 2527 2299 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6788 2532 2492 221 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.678e-11 ps=1.7e-06 pd=1.787e-05
+ nrs=0.15 nrd=0.54
m6789 0 2522 2532 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6790 2533 2515 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6791 222 2490 2533 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6792 2534 2492 223 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.678e-11 ps=1.7e-06 pd=1.787e-05
+ nrs=0.15 nrd=0.54
m6793 0 2515 2534 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6794 2535 2516 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6795 224 2492 2535 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6796 2536 2490 225 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.678e-11 ps=1.7e-06 pd=1.787e-05
+ nrs=0.15 nrd=0.54
m6797 0 2516 2536 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6798 2537 2526 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6799 226 2492 2537 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6800 2538 2490 227 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.689e-11 ps=1.7e-06 pd=1.795e-05
+ nrs=0.15 nrd=0.54
m6801 0 2526 2538 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6802 2539 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6803 2540 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6804 2541 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6805 2542 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6806 2539 220 2543 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6807 2544 221 2539 0 nenh l=1.1e-06 w=2.8e-06
+ as=9.66e-12 ad=7.51e-12 ps=9.7e-06 pd=3.2e-06
+ nrs=1.23 nrd=0.96
m6808 2540 222 2545 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6809 2546 223 2540 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.51e-12 ps=8.9e-06 pd=3.2e-06
+ nrs=1.09 nrd=0.96
m6810 2541 224 2547 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6811 2548 225 2541 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.51e-12 ps=8.9e-06 pd=3.2e-06
+ nrs=1.09 nrd=0.96
m6812 2542 226 2549 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6813 2550 227 2542 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.51e-12 ps=8.9e-06 pd=3.2e-06
+ nrs=1.09 nrd=0.96
m6814 1 2544 2543 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6815 2544 2544 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6816 1 2546 2545 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6817 2546 2546 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6818 1 2547 2547 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6819 2548 2547 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6820 1 2549 2549 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6821 2550 2549 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6822 2551 2294 2552 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.148e-11 ps=1.7e-06 pd=1.17e-05
+ nrs=0.15 nrd=0.37
m6823 2553 2471 2551 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6824 2554 2389 2553 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6825 0 2299 2554 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6826 2555 2552 0 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.64e-12 ps=8.9e-06 pd=4.56e-06
+ nrs=1.09 nrd=0.97
m6827 0 2557 2556 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.64e-12 ad=8.54e-12 ps=4.56e-06 pd=8.9e-06
+ nrs=0.97 nrd=1.09
m6828 2558 2305 2559 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.148e-11 ps=1.7e-06 pd=1.17e-05
+ nrs=0.15 nrd=0.37
m6829 2560 2471 2558 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6830 2561 2389 2560 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6831 0 2299 2561 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6832 2562 2559 0 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.64e-12 ps=8.9e-06 pd=4.56e-06
+ nrs=1.09 nrd=0.97
m6833 2563 2299 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6834 2564 2389 2563 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6835 2565 2471 2564 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6836 2557 2312 2565 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=4.76e-12 ps=1.17e-05 pd=1.7e-06
+ nrs=0.37 nrd=0.15
m6837 0 2567 2566 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.64e-12 ad=8.54e-12 ps=4.56e-06 pd=8.9e-06
+ nrs=0.97 nrd=1.09
m6838 2568 2299 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6839 2569 2389 2568 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6840 2570 2471 2569 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6841 2567 2318 2570 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=4.76e-12 ps=1.17e-05 pd=1.7e-06
+ nrs=0.37 nrd=0.15
m6842 1 2299 2559 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6843 2562 2559 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6844 1 2299 2552 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6845 2555 2552 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6846 1 2557 2556 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6847 2571 2562 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6848 228 2572 2571 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6849 2557 2299 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6850 1 2567 2566 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6851 2567 2299 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6852 2573 2574 229 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.678e-11 ps=1.7e-06 pd=1.787e-05
+ nrs=0.15 nrd=0.54
m6853 0 2562 2573 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6854 2575 2555 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6855 230 2572 2575 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6856 2576 2574 231 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.678e-11 ps=1.7e-06 pd=1.787e-05
+ nrs=0.15 nrd=0.54
m6857 0 2555 2576 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6858 2577 2556 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6859 232 2574 2577 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6860 2578 2572 233 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.678e-11 ps=1.7e-06 pd=1.787e-05
+ nrs=0.15 nrd=0.54
m6861 0 2556 2578 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6862 2579 2566 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6863 234 2574 2579 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6864 2580 2572 235 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.689e-11 ps=1.7e-06 pd=1.795e-05
+ nrs=0.15 nrd=0.54
m6865 0 2566 2580 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6866 2581 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6867 2582 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6868 2583 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6869 2584 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6870 2581 228 2585 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6871 2586 229 2581 0 nenh l=1.1e-06 w=2.8e-06
+ as=9.66e-12 ad=7.51e-12 ps=9.7e-06 pd=3.2e-06
+ nrs=1.23 nrd=0.96
m6872 2582 230 2587 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6873 2588 231 2582 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.51e-12 ps=8.9e-06 pd=3.2e-06
+ nrs=1.09 nrd=0.96
m6874 2583 232 2589 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6875 2590 233 2583 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.51e-12 ps=8.9e-06 pd=3.2e-06
+ nrs=1.09 nrd=0.96
m6876 2584 234 2591 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6877 2592 235 2584 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.51e-12 ps=8.9e-06 pd=3.2e-06
+ nrs=1.09 nrd=0.96
m6878 1 2586 2585 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6879 2586 2586 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6880 1 2588 2587 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6881 2588 2588 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6882 1 2589 2589 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6883 2590 2589 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6884 1 2591 2591 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6885 2592 2591 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6886 2593 2343 2594 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.148e-11 ps=1.7e-06 pd=1.17e-05
+ nrs=0.15 nrd=0.37
m6887 2595 2471 2593 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6888 2596 2389 2595 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6889 0 2299 2596 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6890 2597 2594 0 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.64e-12 ps=8.9e-06 pd=4.56e-06
+ nrs=1.09 nrd=0.97
m6891 0 2599 2598 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.64e-12 ad=8.54e-12 ps=4.56e-06 pd=8.9e-06
+ nrs=0.97 nrd=1.09
m6892 2600 2351 2601 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.148e-11 ps=1.7e-06 pd=1.17e-05
+ nrs=0.15 nrd=0.37
m6893 2602 2471 2600 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6894 2603 2389 2602 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6895 0 2299 2603 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6896 2604 2601 0 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.64e-12 ps=8.9e-06 pd=4.56e-06
+ nrs=1.09 nrd=0.97
m6897 2605 2299 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6898 2606 2389 2605 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6899 2607 2471 2606 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6900 2599 2358 2607 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=4.76e-12 ps=1.17e-05 pd=1.7e-06
+ nrs=0.37 nrd=0.15
m6901 0 2609 2608 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.64e-12 ad=8.54e-12 ps=4.56e-06 pd=8.9e-06
+ nrs=0.97 nrd=1.09
m6902 2610 2299 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6903 2611 2389 2610 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6904 2612 2471 2611 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=4.76e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.15
m6905 2609 2364 2612 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=4.76e-12 ps=1.17e-05 pd=1.7e-06
+ nrs=0.37 nrd=0.15
m6906 1 2299 2601 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6907 2604 2601 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6908 1 2299 2594 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6909 2597 2594 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6910 1 2599 2598 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6911 2613 2604 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6912 236 2572 2613 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6913 2599 2299 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6914 1 2609 2608 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.148e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.37
m6915 2609 2299 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6916 2614 2574 237 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.678e-11 ps=1.7e-06 pd=1.787e-05
+ nrs=0.15 nrd=0.54
m6917 0 2604 2614 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6918 2615 2597 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6919 238 2572 2615 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6920 2616 2574 239 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.678e-11 ps=1.7e-06 pd=1.787e-05
+ nrs=0.15 nrd=0.54
m6921 0 2597 2616 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6922 2617 2598 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6923 240 2574 2617 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6924 2618 2572 241 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.678e-11 ps=1.7e-06 pd=1.787e-05
+ nrs=0.15 nrd=0.54
m6925 0 2598 2618 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6926 2619 2608 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6927 242 2574 2619 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.678e-11 ad=4.76e-12 ps=1.787e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m6928 2620 2572 243 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.689e-11 ps=1.7e-06 pd=1.795e-05
+ nrs=0.15 nrd=0.54
m6929 0 2608 2620 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6930 2621 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6931 2622 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6932 2623 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6933 2624 8 0 0 nenh l=1.1e-06 w=4.8e-06
+ as=1.287e-11 ad=1.309e-11 ps=5.49e-06 pd=7.82e-06
+ nrs=0.56 nrd=0.57
m6934 2621 236 2625 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6935 2626 237 2621 0 nenh l=1.1e-06 w=2.8e-06
+ as=9.66e-12 ad=7.51e-12 ps=9.7e-06 pd=3.2e-06
+ nrs=1.23 nrd=0.96
m6936 2622 238 2627 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6937 2628 239 2622 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.51e-12 ps=8.9e-06 pd=3.2e-06
+ nrs=1.09 nrd=0.96
m6938 2623 240 2629 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6939 2630 241 2623 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.51e-12 ps=8.9e-06 pd=3.2e-06
+ nrs=1.09 nrd=0.96
m6940 2624 242 2631 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.51e-12 ad=8.54e-12 ps=3.2e-06 pd=8.9e-06
+ nrs=0.96 nrd=1.09
m6941 2632 243 2624 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.51e-12 ps=8.9e-06 pd=3.2e-06
+ nrs=1.09 nrd=0.96
m6942 1 2626 2625 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6943 2626 2626 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6944 1 2628 2627 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6945 2628 2628 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6946 1 2629 2629 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6947 2630 2629 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6948 1 2631 2631 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.296e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.18
m6949 2632 2631 1 1 penh l=1.1e-06 w=1.12e-05
+ as=2.296e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.18 nrd=0.22
m6950 2633 2625 2634 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=1.914e-11 ps=1.7e-06 pd=7.78e-06
+ nrs=0.08 nrd=0.15
m6951 1 2635 2633 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=9.52e-12 ps=1.934e-05 pd=1.7e-06
+ nrs=0.22 nrd=0.08
m6952 2636 2637 1 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=2.711e-11 ps=1.7e-06 pd=1.934e-05
+ nrs=0.08 nrd=0.22
m6953 2634 2627 2636 1 penh l=1.1e-06 w=1.12e-05
+ as=1.914e-11 ad=9.52e-12 ps=7.78e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.08
m6954 2638 2630 2634 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=1.914e-11 ps=1.7e-06 pd=7.78e-06
+ nrs=0.08 nrd=0.15
m6955 1 2639 2638 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=9.52e-12 ps=1.934e-05 pd=1.7e-06
+ nrs=0.22 nrd=0.08
m6956 2640 2641 1 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=2.711e-11 ps=1.7e-06 pd=1.934e-05
+ nrs=0.08 nrd=0.22
m6957 2634 2632 2640 1 penh l=1.1e-06 w=1.12e-05
+ as=1.914e-11 ad=9.52e-12 ps=7.78e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.08
m6958 2642 2585 2634 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=1.914e-11 ps=1.7e-06 pd=7.78e-06
+ nrs=0.08 nrd=0.15
m6959 1 2643 2642 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=9.52e-12 ps=1.934e-05 pd=1.7e-06
+ nrs=0.22 nrd=0.08
m6960 2644 2645 1 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=2.711e-11 ps=1.7e-06 pd=1.934e-05
+ nrs=0.08 nrd=0.22
m6961 2634 2587 2644 1 penh l=1.1e-06 w=1.12e-05
+ as=1.914e-11 ad=9.52e-12 ps=7.78e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.08
m6962 2646 2590 2634 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=1.914e-11 ps=1.7e-06 pd=7.78e-06
+ nrs=0.08 nrd=0.15
m6963 1 2647 2646 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=9.52e-12 ps=1.934e-05 pd=1.7e-06
+ nrs=0.22 nrd=0.08
m6964 2648 2649 1 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=2.711e-11 ps=1.7e-06 pd=1.934e-05
+ nrs=0.08 nrd=0.22
m6965 2634 2592 2648 1 penh l=1.1e-06 w=1.12e-05
+ as=1.914e-11 ad=9.52e-12 ps=7.78e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.08
m6966 2650 2651 1 1 penh l=1.1e-06 w=5.6e-06
+ as=5.88e-12 ad=1.355e-11 ps=2.1e-06 pd=9.67e-06
+ nrs=0.19 nrd=0.43
m6967 2574 2652 2650 1 penh l=1.1e-06 w=5.6e-06
+ as=9.24e-12 ad=5.88e-12 ps=3.3e-06 pd=2.1e-06
+ nrs=0.29 nrd=0.19
m6968 2653 2654 2574 1 penh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=9.24e-12 ps=1.7e-06 pd=3.3e-06
+ nrs=0.15 nrd=0.29
m6969 1 2655 2653 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=4.76e-12 ps=9.67e-06 pd=1.7e-06
+ nrs=0.43 nrd=0.15
m6970 2572 2574 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m6971 2656 2625 2634 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.061e-11 ps=1.7e-06 pd=6.1e-06
+ nrs=0.15 nrd=0.34
m6972 0 2351 2656 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6973 2657 2343 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6974 2634 2627 2657 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.061e-11 ad=4.76e-12 ps=6.1e-06 pd=1.7e-06
+ nrs=0.34 nrd=0.15
m6975 2658 2630 2634 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.061e-11 ps=1.7e-06 pd=6.1e-06
+ nrs=0.15 nrd=0.34
m6976 0 2358 2658 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6977 2659 2364 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6978 2634 2632 2659 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.061e-11 ad=4.76e-12 ps=6.1e-06 pd=1.7e-06
+ nrs=0.34 nrd=0.15
m6979 2660 2585 2634 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.061e-11 ps=1.7e-06 pd=6.1e-06
+ nrs=0.15 nrd=0.34
m6980 0 2305 2660 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6981 2661 2294 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6982 2634 2587 2661 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.061e-11 ad=4.76e-12 ps=6.1e-06 pd=1.7e-06
+ nrs=0.34 nrd=0.15
m6983 2662 2590 2634 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.061e-11 ps=1.7e-06 pd=6.1e-06
+ nrs=0.15 nrd=0.34
m6984 0 2312 2662 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m6985 2663 2318 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m6986 2634 2592 2663 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.061e-11 ad=4.76e-12 ps=6.1e-06 pd=1.7e-06
+ nrs=0.34 nrd=0.15
m6987 2664 2543 2665 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=1.914e-11 ps=1.7e-06 pd=7.78e-06
+ nrs=0.08 nrd=0.15
m6988 1 2635 2664 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=9.52e-12 ps=1.934e-05 pd=1.7e-06
+ nrs=0.22 nrd=0.08
m6989 2666 2637 1 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=2.711e-11 ps=1.7e-06 pd=1.934e-05
+ nrs=0.08 nrd=0.22
m6990 2665 2545 2666 1 penh l=1.1e-06 w=1.12e-05
+ as=1.914e-11 ad=9.52e-12 ps=7.78e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.08
m6991 2667 2548 2665 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=1.914e-11 ps=1.7e-06 pd=7.78e-06
+ nrs=0.08 nrd=0.15
m6992 1 2639 2667 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=9.52e-12 ps=1.934e-05 pd=1.7e-06
+ nrs=0.22 nrd=0.08
m6993 2668 2641 1 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=2.711e-11 ps=1.7e-06 pd=1.934e-05
+ nrs=0.08 nrd=0.22
m6994 2665 2550 2668 1 penh l=1.1e-06 w=1.12e-05
+ as=1.914e-11 ad=9.52e-12 ps=7.78e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.08
m6995 2669 2503 2665 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=1.914e-11 ps=1.7e-06 pd=7.78e-06
+ nrs=0.08 nrd=0.15
m6996 1 2643 2669 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=9.52e-12 ps=1.934e-05 pd=1.7e-06
+ nrs=0.22 nrd=0.08
m6997 2670 2645 1 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=2.711e-11 ps=1.7e-06 pd=1.934e-05
+ nrs=0.08 nrd=0.22
m6998 2665 2505 2670 1 penh l=1.1e-06 w=1.12e-05
+ as=1.914e-11 ad=9.52e-12 ps=7.78e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.08
m6999 2671 2508 2665 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=1.914e-11 ps=1.7e-06 pd=7.78e-06
+ nrs=0.08 nrd=0.15
m7000 1 2647 2671 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=9.52e-12 ps=1.934e-05 pd=1.7e-06
+ nrs=0.22 nrd=0.08
m7001 2672 2649 1 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=2.711e-11 ps=1.7e-06 pd=1.934e-05
+ nrs=0.08 nrd=0.22
m7002 2665 2510 2672 1 penh l=1.1e-06 w=1.12e-05
+ as=1.914e-11 ad=9.52e-12 ps=7.78e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.08
m7003 2673 2651 1 1 penh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.355e-11 ps=1.7e-06 pd=9.67e-06
+ nrs=0.15 nrd=0.43
m7004 2492 2652 2673 1 penh l=1.1e-06 w=5.6e-06
+ as=9.24e-12 ad=4.76e-12 ps=3.3e-06 pd=1.7e-06
+ nrs=0.29 nrd=0.15
m7005 2674 2675 2492 1 penh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=9.24e-12 ps=1.7e-06 pd=3.3e-06
+ nrs=0.15 nrd=0.29
m7006 1 2655 2674 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=4.76e-12 ps=9.67e-06 pd=1.7e-06
+ nrs=0.43 nrd=0.15
m7007 2490 2492 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m7008 2676 2655 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m7009 2574 2652 2676 0 nenh l=1.1e-06 w=5.6e-06
+ as=9.24e-12 ad=4.76e-12 ps=3.3e-06 pd=1.7e-06
+ nrs=0.29 nrd=0.15
m7010 2677 2654 2574 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=9.24e-12 ps=1.7e-06 pd=3.3e-06
+ nrs=0.15 nrd=0.29
m7011 0 2651 2677 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m7012 2572 2574 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.527e-11 ps=1.17e-05 pd=9.12e-06
+ nrs=0.37 nrd=0.49
m7013 2678 2543 2665 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.061e-11 ps=1.7e-06 pd=6.1e-06
+ nrs=0.15 nrd=0.34
m7014 0 2351 2678 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m7015 2679 2343 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m7016 2665 2545 2679 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.061e-11 ad=4.76e-12 ps=6.1e-06 pd=1.7e-06
+ nrs=0.34 nrd=0.15
m7017 2680 2548 2665 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.061e-11 ps=1.7e-06 pd=6.1e-06
+ nrs=0.15 nrd=0.34
m7018 0 2358 2680 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m7019 2681 2364 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m7020 2665 2550 2681 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.061e-11 ad=4.76e-12 ps=6.1e-06 pd=1.7e-06
+ nrs=0.34 nrd=0.15
m7021 2682 2503 2665 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.061e-11 ps=1.7e-06 pd=6.1e-06
+ nrs=0.15 nrd=0.34
m7022 0 2305 2682 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m7023 2683 2294 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m7024 2665 2505 2683 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.061e-11 ad=4.76e-12 ps=6.1e-06 pd=1.7e-06
+ nrs=0.34 nrd=0.15
m7025 2684 2508 2665 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.061e-11 ps=1.7e-06 pd=6.1e-06
+ nrs=0.15 nrd=0.34
m7026 0 2312 2684 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m7027 2685 2318 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m7028 2665 2510 2685 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.061e-11 ad=4.76e-12 ps=6.1e-06 pd=1.7e-06
+ nrs=0.34 nrd=0.15
m7029 2686 2460 2687 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=1.914e-11 ps=1.7e-06 pd=7.78e-06
+ nrs=0.08 nrd=0.15
m7030 1 2635 2686 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=9.52e-12 ps=1.934e-05 pd=1.7e-06
+ nrs=0.22 nrd=0.08
m7031 2688 2637 1 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=2.711e-11 ps=1.7e-06 pd=1.934e-05
+ nrs=0.08 nrd=0.22
m7032 2687 2462 2688 1 penh l=1.1e-06 w=1.12e-05
+ as=1.914e-11 ad=9.52e-12 ps=7.78e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.08
m7033 2689 2465 2687 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=1.914e-11 ps=1.7e-06 pd=7.78e-06
+ nrs=0.08 nrd=0.15
m7034 1 2639 2689 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=9.52e-12 ps=1.934e-05 pd=1.7e-06
+ nrs=0.22 nrd=0.08
m7035 2690 2641 1 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=2.711e-11 ps=1.7e-06 pd=1.934e-05
+ nrs=0.08 nrd=0.22
m7036 2687 2467 2690 1 penh l=1.1e-06 w=1.12e-05
+ as=1.914e-11 ad=9.52e-12 ps=7.78e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.08
m7037 2691 2420 2687 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=1.914e-11 ps=1.7e-06 pd=7.78e-06
+ nrs=0.08 nrd=0.15
m7038 1 2643 2691 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=9.52e-12 ps=1.934e-05 pd=1.7e-06
+ nrs=0.22 nrd=0.08
m7039 2692 2645 1 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=2.711e-11 ps=1.7e-06 pd=1.934e-05
+ nrs=0.08 nrd=0.22
m7040 2687 2422 2692 1 penh l=1.1e-06 w=1.12e-05
+ as=1.914e-11 ad=9.52e-12 ps=7.78e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.08
m7041 2693 2425 2687 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=1.914e-11 ps=1.7e-06 pd=7.78e-06
+ nrs=0.08 nrd=0.15
m7042 1 2647 2693 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=9.52e-12 ps=1.934e-05 pd=1.7e-06
+ nrs=0.22 nrd=0.08
m7043 2694 2649 1 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=2.711e-11 ps=1.7e-06 pd=1.934e-05
+ nrs=0.08 nrd=0.22
m7044 2687 2427 2694 1 penh l=1.1e-06 w=1.12e-05
+ as=1.914e-11 ad=9.52e-12 ps=7.78e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.08
m7045 2695 2651 1 1 penh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.355e-11 ps=1.7e-06 pd=9.67e-06
+ nrs=0.15 nrd=0.43
m7046 2409 2652 2695 1 penh l=1.1e-06 w=5.6e-06
+ as=9.24e-12 ad=4.76e-12 ps=3.3e-06 pd=1.7e-06
+ nrs=0.29 nrd=0.15
m7047 2696 2697 2409 1 penh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=9.24e-12 ps=1.7e-06 pd=3.3e-06
+ nrs=0.15 nrd=0.29
m7048 1 2655 2696 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=4.76e-12 ps=9.67e-06 pd=1.7e-06
+ nrs=0.43 nrd=0.15
m7049 2407 2409 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m7050 2698 2655 0 0 nenh l=1.1e-06 w=7.2e-06
+ as=7.66e-12 ad=1.964e-11 ps=5.68e-06 pd=1.172e-05
+ nrs=0.15 nrd=0.38
m7051 2492 2652 2698 0 nenh l=1.1e-06 w=5.6e-06
+ as=9.24e-12 ad=5.96e-12 ps=3.3e-06 pd=4.42e-06
+ nrs=0.29 nrd=0.19
m7052 2699 2675 2492 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=9.24e-12 ps=1.7e-06 pd=3.3e-06
+ nrs=0.15 nrd=0.29
m7053 0 2651 2699 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m7054 2490 2492 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.527e-11 ps=1.17e-05 pd=9.12e-06
+ nrs=0.37 nrd=0.49
m7055 2700 2460 2687 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.061e-11 ps=1.7e-06 pd=6.1e-06
+ nrs=0.15 nrd=0.34
m7056 0 2351 2700 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m7057 2701 2343 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m7058 2687 2462 2701 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.061e-11 ad=4.76e-12 ps=6.1e-06 pd=1.7e-06
+ nrs=0.34 nrd=0.15
m7059 2702 2465 2687 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.061e-11 ps=1.7e-06 pd=6.1e-06
+ nrs=0.15 nrd=0.34
m7060 0 2358 2702 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m7061 2703 2364 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m7062 2687 2467 2703 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.061e-11 ad=4.76e-12 ps=6.1e-06 pd=1.7e-06
+ nrs=0.34 nrd=0.15
m7063 2704 2420 2687 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.061e-11 ps=1.7e-06 pd=6.1e-06
+ nrs=0.15 nrd=0.34
m7064 0 2305 2704 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m7065 2705 2294 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m7066 2687 2422 2705 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.061e-11 ad=4.76e-12 ps=6.1e-06 pd=1.7e-06
+ nrs=0.34 nrd=0.15
m7067 2706 2425 2687 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.061e-11 ps=1.7e-06 pd=6.1e-06
+ nrs=0.15 nrd=0.34
m7068 0 2312 2706 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m7069 2707 2318 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m7070 2687 2427 2707 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.061e-11 ad=4.76e-12 ps=6.1e-06 pd=1.7e-06
+ nrs=0.34 nrd=0.15
m7071 2708 2377 2709 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=1.914e-11 ps=1.7e-06 pd=7.78e-06
+ nrs=0.08 nrd=0.15
m7072 1 2635 2708 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=9.52e-12 ps=1.934e-05 pd=1.7e-06
+ nrs=0.22 nrd=0.08
m7073 2710 2637 1 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=2.711e-11 ps=1.7e-06 pd=1.934e-05
+ nrs=0.08 nrd=0.22
m7074 2709 2379 2710 1 penh l=1.1e-06 w=1.12e-05
+ as=1.914e-11 ad=9.52e-12 ps=7.78e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.08
m7075 2711 2382 2709 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=1.914e-11 ps=1.7e-06 pd=7.78e-06
+ nrs=0.08 nrd=0.15
m7076 1 2639 2711 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=9.52e-12 ps=1.934e-05 pd=1.7e-06
+ nrs=0.22 nrd=0.08
m7077 2712 2641 1 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=2.711e-11 ps=1.7e-06 pd=1.934e-05
+ nrs=0.08 nrd=0.22
m7078 2709 2384 2712 1 penh l=1.1e-06 w=1.12e-05
+ as=1.914e-11 ad=9.52e-12 ps=7.78e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.08
m7079 2713 2333 2709 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=1.914e-11 ps=1.7e-06 pd=7.78e-06
+ nrs=0.08 nrd=0.15
m7080 1 2643 2713 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=9.52e-12 ps=1.934e-05 pd=1.7e-06
+ nrs=0.22 nrd=0.08
m7081 2714 2645 1 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=2.711e-11 ps=1.7e-06 pd=1.934e-05
+ nrs=0.08 nrd=0.22
m7082 2709 2335 2714 1 penh l=1.1e-06 w=1.12e-05
+ as=1.914e-11 ad=9.52e-12 ps=7.78e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.08
m7083 2715 2338 2709 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=1.914e-11 ps=1.7e-06 pd=7.78e-06
+ nrs=0.08 nrd=0.15
m7084 1 2647 2715 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=9.52e-12 ps=1.934e-05 pd=1.7e-06
+ nrs=0.22 nrd=0.08
m7085 2716 2649 1 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=2.711e-11 ps=1.7e-06 pd=1.934e-05
+ nrs=0.08 nrd=0.22
m7086 2709 2340 2716 1 penh l=1.1e-06 w=1.12e-05
+ as=1.914e-11 ad=9.52e-12 ps=7.78e-06 pd=1.7e-06
+ nrs=0.15 nrd=0.08
m7087 2717 2651 1 1 penh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.355e-11 ps=1.7e-06 pd=9.67e-06
+ nrs=0.15 nrd=0.43
m7088 2322 2652 2717 1 penh l=1.1e-06 w=5.6e-06
+ as=9.24e-12 ad=4.76e-12 ps=3.3e-06 pd=1.7e-06
+ nrs=0.29 nrd=0.15
m7089 2718 2719 2322 1 penh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=9.24e-12 ps=1.7e-06 pd=3.3e-06
+ nrs=0.15 nrd=0.29
m7090 1 2655 2718 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=4.76e-12 ps=9.67e-06 pd=1.7e-06
+ nrs=0.43 nrd=0.15
m7091 2320 2322 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.37 nrd=0.43
m7092 2720 2655 0 0 nenh l=1.1e-06 w=7.2e-06
+ as=7.66e-12 ad=1.964e-11 ps=5.68e-06 pd=1.172e-05
+ nrs=0.15 nrd=0.38
m7093 2409 2652 2720 0 nenh l=1.1e-06 w=5.6e-06
+ as=9.24e-12 ad=5.96e-12 ps=3.3e-06 pd=4.42e-06
+ nrs=0.29 nrd=0.19
m7094 2721 2697 2409 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=9.24e-12 ps=1.7e-06 pd=3.3e-06
+ nrs=0.15 nrd=0.29
m7095 0 2651 2721 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m7096 2407 2409 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.527e-11 ps=1.17e-05 pd=9.12e-06
+ nrs=0.37 nrd=0.49
m7097 2722 2377 2709 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.061e-11 ps=1.7e-06 pd=6.1e-06
+ nrs=0.15 nrd=0.34
m7098 0 2351 2722 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m7099 2723 2343 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m7100 2709 2379 2723 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.061e-11 ad=4.76e-12 ps=6.1e-06 pd=1.7e-06
+ nrs=0.34 nrd=0.15
m7101 2724 2382 2709 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.061e-11 ps=1.7e-06 pd=6.1e-06
+ nrs=0.15 nrd=0.34
m7102 0 2358 2724 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m7103 2725 2364 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m7104 2709 2384 2725 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.061e-11 ad=4.76e-12 ps=6.1e-06 pd=1.7e-06
+ nrs=0.34 nrd=0.15
m7105 2726 2333 2709 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.061e-11 ps=1.7e-06 pd=6.1e-06
+ nrs=0.15 nrd=0.34
m7106 0 2305 2726 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m7107 2727 2294 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m7108 2709 2335 2727 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.061e-11 ad=4.76e-12 ps=6.1e-06 pd=1.7e-06
+ nrs=0.34 nrd=0.15
m7109 2728 2338 2709 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.061e-11 ps=1.7e-06 pd=6.1e-06
+ nrs=0.15 nrd=0.34
m7110 0 2312 2728 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m7111 2729 2318 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m7112 2709 2340 2729 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.061e-11 ad=4.76e-12 ps=6.1e-06 pd=1.7e-06
+ nrs=0.34 nrd=0.15
m7113 1 2651 2655 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=1.736e-11 ps=1.934e-05 pd=1.73e-05
+ nrs=0.22 nrd=0.14
m7114 2651 1 1 1 penh l=1.1e-06 w=1.12e-05
+ as=1.736e-11 ad=2.711e-11 ps=1.73e-05 pd=1.934e-05
+ nrs=0.14 nrd=0.22
m7115 2730 2655 0 0 nenh l=1.1e-06 w=7.2e-06
+ as=8.74e-12 ad=1.964e-11 ps=5.68e-06 pd=1.172e-05
+ nrs=0.17 nrd=0.38
m7116 2322 2652 2730 0 nenh l=1.1e-06 w=5.6e-06
+ as=9.24e-12 ad=6.8e-12 ps=3.3e-06 pd=4.42e-06
+ nrs=0.29 nrd=0.22
m7117 2731 2719 2322 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=9.24e-12 ps=1.7e-06 pd=3.3e-06
+ nrs=0.15 nrd=0.29
m7118 0 2651 2731 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m7119 2320 2322 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.148e-11 ad=1.527e-11 ps=1.17e-05 pd=9.12e-06
+ nrs=0.37 nrd=0.49
m7120 0 2651 2655 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=1.148e-11 ps=9.12e-06 pd=1.17e-05
+ nrs=0.49 nrd=0.37
m7121 2651 1 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.527e-11 ps=1.17e-05 pd=9.12e-06
+ nrs=0.54 nrd=0.49
m7122 0 2351 2635 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=1.708e-11 ps=9.12e-06 pd=1.17e-05
+ nrs=0.49 nrd=0.54
m7123 1 2351 2635 1 penh l=1.1e-06 w=8.4e-06
+ as=2.033e-11 ad=2.306e-11 ps=1.45e-05 pd=1.45e-05
+ nrs=0.29 nrd=0.33
m7124 2649 2318 1 1 penh l=1.1e-06 w=8.4e-06
+ as=2.562e-11 ad=2.033e-11 ps=1.45e-05 pd=1.45e-05
+ nrs=0.36 nrd=0.29
m7125 0 2732 2351 0 nenh l=1.1e-06 w=1.16e-05
+ as=3.164e-11 ad=1.442e-11 ps=1.889e-05 pd=6.81e-06
+ nrs=0.24 nrd=0.11
m7126 2351 2733 0 0 nenh l=1.1e-06 w=1e-05
+ as=1.243e-11 ad=2.727e-11 ps=5.87e-06 pd=1.628e-05
+ nrs=0.12 nrd=0.27
m7127 0 2734 2351 0 nenh l=1.1e-06 w=1.16e-05
+ as=3.164e-11 ad=1.442e-11 ps=1.889e-05 pd=6.81e-06
+ nrs=0.24 nrd=0.11
m7128 2364 2734 0 0 nenh l=1.1e-06 w=1.16e-05
+ as=1.442e-11 ad=3.164e-11 ps=6.81e-06 pd=1.889e-05
+ nrs=0.11 nrd=0.24
m7129 0 2735 2364 0 nenh l=1.1e-06 w=1e-05
+ as=2.727e-11 ad=1.243e-11 ps=1.628e-05 pd=5.87e-06
+ nrs=0.27 nrd=0.12
m7130 2364 2732 0 0 nenh l=1.1e-06 w=1.16e-05
+ as=1.442e-11 ad=3.164e-11 ps=6.81e-06 pd=1.889e-05
+ nrs=0.11 nrd=0.24
m7131 0 2364 2641 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=1.708e-11 ps=9.12e-06 pd=1.17e-05
+ nrs=0.49 nrd=0.54
m7132 2637 2343 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.527e-11 ps=1.17e-05 pd=9.12e-06
+ nrs=0.54 nrd=0.49
m7133 2736 2732 2351 1 penh l=1.1e-06 w=1.08e-05
+ as=9.18e-12 ad=2.814e-11 ps=1.7e-06 pd=1.69e-05
+ nrs=0.08 nrd=0.24
m7134 2737 2733 2736 1 penh l=1.1e-06 w=1.08e-05
+ as=9.18e-12 ad=9.18e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.08 nrd=0.08
m7135 1 2734 2737 1 penh l=1.1e-06 w=1.08e-05
+ as=2.614e-11 ad=9.18e-12 ps=1.865e-05 pd=1.7e-06
+ nrs=0.22 nrd=0.08
m7136 2738 2734 1 1 penh l=1.1e-06 w=1.08e-05
+ as=9.18e-12 ad=2.614e-11 ps=1.7e-06 pd=1.865e-05
+ nrs=0.08 nrd=0.22
m7137 2739 2735 2738 1 penh l=1.1e-06 w=1.08e-05
+ as=9.18e-12 ad=9.18e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.08 nrd=0.08
m7138 2364 2732 2739 1 penh l=1.1e-06 w=1.08e-05
+ as=2.814e-11 ad=9.18e-12 ps=1.69e-05 pd=1.7e-06
+ nrs=0.24 nrd=0.08
m7139 0 2732 2343 0 nenh l=1.1e-06 w=1.16e-05
+ as=3.164e-11 ad=1.442e-11 ps=1.889e-05 pd=6.81e-06
+ nrs=0.24 nrd=0.11
m7140 2343 2733 0 0 nenh l=1.1e-06 w=1e-05
+ as=1.243e-11 ad=2.727e-11 ps=5.87e-06 pd=1.628e-05
+ nrs=0.12 nrd=0.27
m7141 0 2740 2343 0 nenh l=1.1e-06 w=1.16e-05
+ as=3.164e-11 ad=1.442e-11 ps=1.889e-05 pd=6.81e-06
+ nrs=0.24 nrd=0.11
m7142 2358 2740 0 0 nenh l=1.1e-06 w=1.16e-05
+ as=1.442e-11 ad=3.164e-11 ps=6.81e-06 pd=1.889e-05
+ nrs=0.11 nrd=0.24
m7143 0 2735 2358 0 nenh l=1.1e-06 w=1e-05
+ as=2.727e-11 ad=1.243e-11 ps=1.628e-05 pd=5.87e-06
+ nrs=0.27 nrd=0.12
m7144 2358 2732 0 0 nenh l=1.1e-06 w=1.16e-05
+ as=1.442e-11 ad=3.164e-11 ps=6.81e-06 pd=1.889e-05
+ nrs=0.11 nrd=0.24
m7145 2639 2358 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.692e-11 ad=1.527e-11 ps=1.17e-05 pd=9.12e-06
+ nrs=0.54 nrd=0.49
m7146 1 2364 2641 1 penh l=1.1e-06 w=7.2e-06
+ as=1.743e-11 ad=2.196e-11 ps=1.243e-05 pd=1.33e-05
+ nrs=0.34 nrd=0.42
m7147 2637 2343 1 1 penh l=1.1e-06 w=7.2e-06
+ as=2.196e-11 ad=1.743e-11 ps=1.33e-05 pd=1.243e-05
+ nrs=0.42 nrd=0.34
m7148 2741 2732 2343 1 penh l=1.1e-06 w=1.08e-05
+ as=9.18e-12 ad=2.814e-11 ps=1.7e-06 pd=1.69e-05
+ nrs=0.08 nrd=0.24
m7149 2742 2733 2741 1 penh l=1.1e-06 w=1.08e-05
+ as=9.18e-12 ad=9.18e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.08 nrd=0.08
m7150 1 2740 2742 1 penh l=1.1e-06 w=1.08e-05
+ as=2.614e-11 ad=9.18e-12 ps=1.865e-05 pd=1.7e-06
+ nrs=0.22 nrd=0.08
m7151 2743 2740 1 1 penh l=1.1e-06 w=1.08e-05
+ as=9.18e-12 ad=2.614e-11 ps=1.7e-06 pd=1.865e-05
+ nrs=0.08 nrd=0.22
m7152 2744 2735 2743 1 penh l=1.1e-06 w=1.08e-05
+ as=9.18e-12 ad=9.18e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.08 nrd=0.08
m7153 2358 2732 2744 1 penh l=1.1e-06 w=1.08e-05
+ as=3.006e-11 ad=9.18e-12 ps=1.69e-05 pd=1.7e-06
+ nrs=0.26 nrd=0.08
m7154 2639 2358 1 1 penh l=1.1e-06 w=9.6e-06
+ as=2.928e-11 ad=2.324e-11 ps=1.57e-05 pd=1.657e-05
+ nrs=0.32 nrd=0.25
m7155 2745 2746 2318 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=2.904e-11 ps=1.7e-06 pd=1.73e-05
+ nrs=0.08 nrd=0.23
m7156 2747 2733 2745 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=9.52e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.08 nrd=0.08
m7157 1 2734 2747 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=9.52e-12 ps=1.934e-05 pd=1.7e-06
+ nrs=0.22 nrd=0.08
m7158 2748 2734 1 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=2.711e-11 ps=1.7e-06 pd=1.934e-05
+ nrs=0.08 nrd=0.22
m7159 2749 2735 2748 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=9.52e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.08 nrd=0.08
m7160 2305 2746 2749 1 penh l=1.1e-06 w=1.12e-05
+ as=2.904e-11 ad=9.52e-12 ps=1.73e-05 pd=1.7e-06
+ nrs=0.23 nrd=0.08
m7161 1 2305 2643 1 penh l=1.1e-06 w=1e-05
+ as=2.42e-11 ad=2.186e-11 ps=1.726e-05 pd=1.61e-05
+ nrs=0.24 nrd=0.22
m7162 2647 2312 1 1 penh l=1.1e-06 w=1e-05
+ as=3.05e-11 ad=2.42e-11 ps=1.61e-05 pd=1.726e-05
+ nrs=0.31 nrd=0.24
m7163 2649 2318 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.527e-11 ps=1.17e-05 pd=9.12e-06
+ nrs=0.54 nrd=0.49
m7164 0 2746 2318 0 nenh l=1.1e-06 w=8.8e-06
+ as=2.4e-11 ad=1.482e-11 ps=1.433e-05 pd=6.94e-06
+ nrs=0.31 nrd=0.19
m7165 2318 2733 0 0 nenh l=1.1e-06 w=7.2e-06
+ as=1.213e-11 ad=1.964e-11 ps=5.68e-06 pd=1.172e-05
+ nrs=0.23 nrd=0.38
m7166 0 2734 2318 0 nenh l=1.1e-06 w=7.2e-06
+ as=1.964e-11 ad=1.213e-11 ps=1.172e-05 pd=5.68e-06
+ nrs=0.38 nrd=0.23
m7167 2305 2734 0 0 nenh l=1.1e-06 w=8.8e-06
+ as=1.151e-11 ad=2.4e-11 ps=5.93e-06 pd=1.433e-05
+ nrs=0.15 nrd=0.31
m7168 0 2735 2305 0 nenh l=1.1e-06 w=7.2e-06
+ as=1.964e-11 ad=9.42e-12 ps=1.172e-05 pd=4.85e-06
+ nrs=0.38 nrd=0.18
m7169 2750 2746 2312 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=2.904e-11 ps=1.7e-06 pd=1.73e-05
+ nrs=0.08 nrd=0.23
m7170 2751 2733 2750 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=9.52e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.08 nrd=0.08
m7171 1 2740 2751 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=9.52e-12 ps=1.934e-05 pd=1.7e-06
+ nrs=0.22 nrd=0.08
m7172 2752 2740 1 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=2.711e-11 ps=1.7e-06 pd=1.934e-05
+ nrs=0.08 nrd=0.22
m7173 2753 2735 2752 1 penh l=1.1e-06 w=1.12e-05
+ as=9.52e-12 ad=9.52e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.08 nrd=0.08
m7174 2294 2746 2753 1 penh l=1.1e-06 w=1.12e-05
+ as=2.904e-11 ad=9.52e-12 ps=1.73e-05 pd=1.7e-06
+ nrs=0.23 nrd=0.08
m7175 2305 2746 0 0 nenh l=1.1e-06 w=8.8e-06
+ as=1.151e-11 ad=2.4e-11 ps=5.93e-06 pd=1.433e-05
+ nrs=0.15 nrd=0.31
m7176 0 2305 2643 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=1.708e-11 ps=9.12e-06 pd=1.17e-05
+ nrs=0.49 nrd=0.54
m7177 2647 2312 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.527e-11 ps=1.17e-05 pd=9.12e-06
+ nrs=0.54 nrd=0.49
m7178 0 2746 2312 0 nenh l=1.1e-06 w=8.8e-06
+ as=2.4e-11 ad=1.482e-11 ps=1.433e-05 pd=6.94e-06
+ nrs=0.31 nrd=0.19
m7179 2312 2733 0 0 nenh l=1.1e-06 w=7.2e-06
+ as=1.213e-11 ad=1.964e-11 ps=5.68e-06 pd=1.172e-05
+ nrs=0.23 nrd=0.38
m7180 0 2740 2312 0 nenh l=1.1e-06 w=7.2e-06
+ as=1.964e-11 ad=1.213e-11 ps=1.172e-05 pd=5.68e-06
+ nrs=0.38 nrd=0.23
m7181 2294 2740 0 0 nenh l=1.1e-06 w=8.8e-06
+ as=1.151e-11 ad=2.4e-11 ps=5.93e-06 pd=1.433e-05
+ nrs=0.15 nrd=0.31
m7182 0 2735 2294 0 nenh l=1.1e-06 w=7.2e-06
+ as=1.964e-11 ad=9.42e-12 ps=1.172e-05 pd=4.85e-06
+ nrs=0.38 nrd=0.18
m7183 2294 2746 0 0 nenh l=1.1e-06 w=8.8e-06
+ as=1.151e-11 ad=2.4e-11 ps=5.93e-06 pd=1.433e-05
+ nrs=0.15 nrd=0.31
m7184 2645 2294 1 1 penh l=1.1e-06 w=7.6e-06
+ as=2.318e-11 ad=1.84e-11 ps=1.37e-05 pd=1.312e-05
+ nrs=0.4 nrd=0.32
m7185 2645 2294 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.527e-11 ps=1.17e-05 pd=9.12e-06
+ nrs=0.54 nrd=0.49
m7186 2754 8 2755 0 nenh l=1.1e-06 w=7.2e-06
+ as=6.12e-12 ad=2.196e-11 ps=1.7e-06 pd=1.33e-05
+ nrs=0.12 nrd=0.42
m7187 2756 1 2754 0 nenh l=1.1e-06 w=7.2e-06
+ as=6.12e-12 ad=6.12e-12 ps=1.7e-06 pd=1.7e-06
+ nrs=0.12 nrd=0.12
m7188 0 2757 2756 0 nenh l=1.1e-06 w=7.2e-06
+ as=1.964e-11 ad=6.12e-12 ps=1.172e-05 pd=1.7e-06
+ nrs=0.38 nrd=0.12
m7189 2740 2734 0 0 nenh l=1.1e-06 w=7.2e-06
+ as=1.188e-11 ad=1.964e-11 ps=3.3e-06 pd=1.172e-05
+ nrs=0.23 nrd=0.38
m7190 0 2734 2740 0 nenh l=1.1e-06 w=7.2e-06
+ as=1.964e-11 ad=1.188e-11 ps=1.172e-05 pd=3.3e-06
+ nrs=0.38 nrd=0.23
m7191 2734 2758 0 0 nenh l=1.1e-06 w=7.2e-06
+ as=1.188e-11 ad=1.964e-11 ps=3.3e-06 pd=1.172e-05
+ nrs=0.23 nrd=0.38
m7192 0 2758 2734 0 nenh l=1.1e-06 w=7.2e-06
+ as=1.964e-11 ad=1.188e-11 ps=1.172e-05 pd=3.3e-06
+ nrs=0.38 nrd=0.23
m7193 2735 2733 0 0 nenh l=1.1e-06 w=7.2e-06
+ as=1.188e-11 ad=1.964e-11 ps=3.3e-06 pd=1.172e-05
+ nrs=0.23 nrd=0.38
m7194 0 2733 2735 0 nenh l=1.1e-06 w=7.2e-06
+ as=1.964e-11 ad=1.188e-11 ps=1.172e-05 pd=3.3e-06
+ nrs=0.38 nrd=0.23
m7195 2733 2759 0 0 nenh l=1.1e-06 w=7.2e-06
+ as=1.188e-11 ad=1.964e-11 ps=3.3e-06 pd=1.172e-05
+ nrs=0.23 nrd=0.38
m7196 0 2759 2733 0 nenh l=1.1e-06 w=7.2e-06
+ as=1.964e-11 ad=1.188e-11 ps=1.172e-05 pd=3.3e-06
+ nrs=0.38 nrd=0.23
m7197 2746 2732 0 0 nenh l=1.1e-06 w=7.2e-06
+ as=1.188e-11 ad=1.964e-11 ps=3.3e-06 pd=1.172e-05
+ nrs=0.23 nrd=0.38
m7198 0 2732 2746 0 nenh l=1.1e-06 w=7.2e-06
+ as=1.964e-11 ad=1.188e-11 ps=1.172e-05 pd=3.3e-06
+ nrs=0.38 nrd=0.23
m7199 2732 2760 0 0 nenh l=1.1e-06 w=7.2e-06
+ as=1.188e-11 ad=1.964e-11 ps=3.3e-06 pd=1.172e-05
+ nrs=0.23 nrd=0.38
m7200 0 2760 2732 0 nenh l=1.1e-06 w=7.2e-06
+ as=1.964e-11 ad=1.188e-11 ps=1.172e-05 pd=3.3e-06
+ nrs=0.38 nrd=0.23
m7201 1 8 2755 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.176e-11 ps=1.934e-05 pd=7.52e-06
+ nrs=0.22 nrd=0.17
m7202 2755 1 1 1 penh l=1.1e-06 w=1.2e-05
+ as=2.332e-11 ad=2.904e-11 ps=8.06e-06 pd=2.072e-05
+ nrs=0.16 nrd=0.2
m7203 1 2757 2755 1 penh l=1.1e-06 w=1.12e-05
+ as=2.711e-11 ad=2.176e-11 ps=1.934e-05 pd=7.52e-06
+ nrs=0.22 nrd=0.17
m7204 2299 2755 0 0 nenh l=1.1e-06 w=7.2e-06
+ as=2.196e-11 ad=1.964e-11 ps=1.33e-05 pd=1.172e-05
+ nrs=0.42 nrd=0.38
m7205 2740 2734 1 1 penh l=1.1e-06 w=5.6e-06
+ as=9.24e-12 ad=1.355e-11 ps=3.3e-06 pd=9.67e-06
+ nrs=0.29 nrd=0.43
m7206 1 2734 2740 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=9.24e-12 ps=9.67e-06 pd=3.3e-06
+ nrs=0.43 nrd=0.29
m7207 2734 2758 1 1 penh l=1.1e-06 w=5.6e-06
+ as=9.24e-12 ad=1.355e-11 ps=3.3e-06 pd=9.67e-06
+ nrs=0.29 nrd=0.43
m7208 1 2758 2734 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=9.24e-12 ps=9.67e-06 pd=3.3e-06
+ nrs=0.43 nrd=0.29
m7209 2735 2733 1 1 penh l=1.1e-06 w=5.6e-06
+ as=9.24e-12 ad=1.355e-11 ps=3.3e-06 pd=9.67e-06
+ nrs=0.29 nrd=0.43
m7210 1 2733 2735 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=9.24e-12 ps=9.67e-06 pd=3.3e-06
+ nrs=0.43 nrd=0.29
m7211 2733 2759 1 1 penh l=1.1e-06 w=5.6e-06
+ as=9.24e-12 ad=1.355e-11 ps=3.3e-06 pd=9.67e-06
+ nrs=0.29 nrd=0.43
m7212 1 2759 2733 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=9.24e-12 ps=9.67e-06 pd=3.3e-06
+ nrs=0.43 nrd=0.29
m7213 2746 2732 1 1 penh l=1.1e-06 w=5.6e-06
+ as=9.24e-12 ad=1.355e-11 ps=3.3e-06 pd=9.67e-06
+ nrs=0.29 nrd=0.43
m7214 1 2732 2746 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=9.24e-12 ps=9.67e-06 pd=3.3e-06
+ nrs=0.43 nrd=0.29
m7215 2732 2760 1 1 penh l=1.1e-06 w=5.6e-06
+ as=9.24e-12 ad=1.355e-11 ps=3.3e-06 pd=9.67e-06
+ nrs=0.29 nrd=0.43
m7216 1 2760 2732 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=9.24e-12 ps=9.67e-06 pd=3.3e-06
+ nrs=0.43 nrd=0.29
m7217 2299 2755 1 1 penh l=1.1e-06 w=1.04e-05
+ as=3.172e-11 ad=2.517e-11 ps=1.65e-05 pd=1.796e-05
+ nrs=0.29 nrd=0.23
m7218 2761 2762 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.036e-11 ad=1.527e-11 ps=3.7e-06 pd=9.12e-06
+ nrs=0.33 nrd=0.49
m7219 2763 2762 1 1 penh l=1.1e-06 w=1.16e-05
+ as=2.115e-11 ad=2.808e-11 ps=7.19e-06 pd=2.003e-05
+ nrs=0.16 nrd=0.21
m7220 2761 2764 2763 1 penh l=1.1e-06 w=1.24e-05
+ as=1.278e-11 ad=2.261e-11 ps=2.74e-06 pd=7.68e-06
+ nrs=0.08 nrd=0.15
m7221 2765 2764 2761 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.036e-11 ps=1.7e-06 pd=3.7e-06
+ nrs=0.15 nrd=0.33
m7222 0 0 2765 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m7223 2763 0 2761 1 penh l=1.1e-06 w=1.2e-05
+ as=2.188e-11 ad=1.236e-11 ps=7.43e-06 pd=2.66e-06
+ nrs=0.15 nrd=0.09
m7224 2766 0 2767 1 penh l=1.1e-06 w=1.2e-05
+ as=1.236e-11 ad=2.188e-11 ps=2.66e-06 pd=7.43e-06
+ nrs=0.09 nrd=0.15
m7225 2768 0 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m7226 2767 2764 2766 1 penh l=1.1e-06 w=1.24e-05
+ as=2.261e-11 ad=1.278e-11 ps=7.68e-06 pd=2.74e-06
+ nrs=0.15 nrd=0.08
m7227 2766 2764 2768 0 nenh l=1.1e-06 w=5.6e-06
+ as=9.36e-12 ad=4.76e-12 ps=3.38e-06 pd=1.7e-06
+ nrs=0.3 nrd=0.15
m7228 1 2769 2767 1 penh l=1.1e-06 w=1.16e-05
+ as=2.808e-11 ad=2.115e-11 ps=2.003e-05 pd=7.19e-06
+ nrs=0.21 nrd=0.16
m7229 0 2769 2766 0 nenh l=1.1e-06 w=6e-06
+ as=1.636e-11 ad=1.002e-11 ps=9.77e-06 pd=3.62e-06
+ nrs=0.45 nrd=0.28
m7230 2770 2771 1 1 penh l=1.1e-06 w=1.16e-05
+ as=2.13e-11 ad=2.808e-11 ps=7.4e-06 pd=2.003e-05
+ nrs=0.16 nrd=0.21
m7231 2758 2771 0 0 nenh l=1.1e-06 w=6e-06
+ as=1.002e-11 ad=1.636e-11 ps=3.62e-06 pd=9.77e-06
+ nrs=0.28 nrd=0.45
m7232 2772 0 0 0 nenh l=1.1e-06 w=6e-06
+ as=5.1e-12 ad=1.636e-11 ps=1.7e-06 pd=9.77e-06
+ nrs=0.14 nrd=0.45
m7233 2773 0 2774 1 penh l=1.1e-06 w=1.2e-05
+ as=1.276e-11 ad=1.83e-11 ps=2.66e-06 pd=7.22e-06
+ nrs=0.09 nrd=0.13
m7234 2758 2764 2770 1 penh l=1.1e-06 w=1.2e-05
+ as=1.292e-11 ad=2.204e-11 ps=2.5e-06 pd=7.65e-06
+ nrs=0.09 nrd=0.15
m7235 2773 2764 2772 0 nenh l=1.1e-06 w=6e-06
+ as=1.11e-11 ad=5.1e-12 ps=3.7e-06 pd=1.7e-06
+ nrs=0.31 nrd=0.14
m7236 2775 2764 2758 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=9.36e-12 ps=1.7e-06 pd=3.38e-06
+ nrs=0.15 nrd=0.3
m7237 2776 0 2777 1 penh l=1.1e-06 w=1.16e-05
+ as=1.399e-11 ad=1.835e-11 ps=2.65e-06 pd=7.09e-06
+ nrs=0.1 nrd=0.14
m7238 2778 0 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m7239 2779 2773 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.527e-11 ps=1.17e-05 pd=9.12e-06
+ nrs=0.54 nrd=0.49
m7240 2779 2773 1 1 penh l=1.1e-06 w=9.6e-06
+ as=2.608e-11 ad=2.324e-11 ps=1.57e-05 pd=1.657e-05
+ nrs=0.28 nrd=0.25
m7241 2780 2773 143 1 penh l=1.1e-06 w=9.2e-06
+ as=7.82e-12 ad=1.782e-11 ps=1.7e-06 pd=1.53e-05
+ nrs=0.09 nrd=0.21
m7242 0 2773 143 0 nenh l=1.1e-06 w=9.2e-06
+ as=2.509e-11 ad=1.124e-11 ps=1.498e-05 pd=5.95e-06
+ nrs=0.3 nrd=0.13
m7243 2776 2764 2778 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.036e-11 ad=4.76e-12 ps=3.7e-06 pd=1.7e-06
+ nrs=0.33 nrd=0.15
m7244 2774 2764 2773 1 penh l=1.1e-06 w=1.24e-05
+ as=1.891e-11 ad=1.318e-11 ps=7.46e-06 pd=2.74e-06
+ nrs=0.12 nrd=0.09
m7245 2777 2764 2776 1 penh l=1.1e-06 w=1.2e-05
+ as=1.898e-11 ad=1.447e-11 ps=7.33e-06 pd=2.75e-06
+ nrs=0.13 nrd=0.1
m7246 0 0 2775 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m7247 0 2781 2773 0 nenh l=1.1e-06 w=6e-06
+ as=1.636e-11 ad=1.11e-11 ps=9.77e-06 pd=3.7e-06
+ nrs=0.45 nrd=0.31
m7248 0 2779 164 0 nenh l=1.1e-06 w=9.2e-06
+ as=2.509e-11 ad=1.124e-11 ps=1.498e-05 pd=5.95e-06
+ nrs=0.3 nrd=0.13
m7249 2782 2779 164 1 penh l=1.1e-06 w=9.2e-06
+ as=7.82e-12 ad=1.782e-11 ps=1.7e-06 pd=1.53e-05
+ nrs=0.09 nrd=0.21
m7250 2783 2784 2780 1 penh l=1.1e-06 w=9.2e-06
+ as=1.091e-11 ad=7.82e-12 ps=2.3e-06 pd=1.7e-06
+ nrs=0.13 nrd=0.09
m7251 143 2784 0 0 nenh l=1.1e-06 w=7.2e-06
+ as=8.79e-12 ad=1.964e-11 ps=4.66e-06 pd=1.172e-05
+ nrs=0.17 nrd=0.38
m7252 164 2784 0 0 nenh l=1.1e-06 w=7.2e-06
+ as=8.79e-12 ad=1.964e-11 ps=4.66e-06 pd=1.172e-05
+ nrs=0.17 nrd=0.38
m7253 2785 2784 2782 1 penh l=1.1e-06 w=9.2e-06
+ as=8.85e-12 ad=7.82e-12 ps=2.3e-06 pd=1.7e-06
+ nrs=0.1 nrd=0.09
m7254 1 2781 2774 1 penh l=1.1e-06 w=1.2e-05
+ as=2.904e-11 ad=1.83e-11 ps=2.072e-05 pd=7.22e-06
+ nrs=0.2 nrd=0.13
m7255 2770 0 2758 1 penh l=1.1e-06 w=1.2e-05
+ as=2.204e-11 ad=1.292e-11 ps=7.65e-06 pd=2.5e-06
+ nrs=0.15 nrd=0.09
m7256 1 2786 2777 1 penh l=1.1e-06 w=1.16e-05
+ as=2.808e-11 ad=1.835e-11 ps=2.003e-05 pd=7.09e-06
+ nrs=0.21 nrd=0.14
m7257 0 2786 2776 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=1.036e-11 ps=9.12e-06 pd=3.7e-06
+ nrs=0.49 nrd=0.33
m7258 1 2776 2783 1 penh l=1.1e-06 w=1.08e-05
+ as=2.614e-11 ad=1.281e-11 ps=1.865e-05 pd=2.7e-06
+ nrs=0.22 nrd=0.11
m7259 0 2776 143 0 nenh l=1.1e-06 w=8.8e-06
+ as=2.4e-11 ad=1.075e-11 ps=1.433e-05 pd=5.69e-06
+ nrs=0.31 nrd=0.14
m7260 0 2776 164 0 nenh l=1.1e-06 w=8.8e-06
+ as=2.4e-11 ad=1.075e-11 ps=1.433e-05 pd=5.69e-06
+ nrs=0.31 nrd=0.14
m7261 1 2776 2785 1 penh l=1.1e-06 w=1.08e-05
+ as=2.614e-11 ad=1.039e-11 ps=1.865e-05 pd=2.7e-06
+ nrs=0.22 nrd=0.09
m7262 2787 2788 0 0 nenh l=1.1e-06 w=7.6e-06
+ as=9.77e-12 ad=2.073e-11 ps=3.24e-06 pd=1.237e-05
+ nrs=0.17 nrd=0.36
m7263 2759 0 2789 1 penh l=1.1e-06 w=1.2e-05
+ as=1.292e-11 ad=2.204e-11 ps=2.5e-06 pd=7.65e-06
+ nrs=0.09 nrd=0.15
m7264 2790 0 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.527e-11 ps=1.7e-06 pd=9.12e-06
+ nrs=0.15 nrd=0.49
m7265 2791 2764 2787 0 nenh l=1.1e-06 w=6e-06
+ as=5.1e-12 ad=7.71e-12 ps=1.7e-06 pd=2.56e-06
+ nrs=0.14 nrd=0.21
m7266 2792 2788 1 1 penh l=1.1e-06 w=1.2e-05
+ as=1.84e-11 ad=2.904e-11 ps=7.22e-06 pd=2.072e-05
+ nrs=0.13 nrd=0.2
m7267 2793 2776 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.527e-11 ps=1.17e-05 pd=9.12e-06
+ nrs=0.54 nrd=0.49
m7268 2793 2776 1 1 penh l=1.1e-06 w=9.6e-06
+ as=2.608e-11 ad=2.324e-11 ps=1.57e-05 pd=1.657e-05
+ nrs=0.28 nrd=0.25
m7269 2794 2776 1 1 penh l=1.1e-06 w=1.08e-05
+ as=1.281e-11 ad=2.614e-11 ps=2.7e-06 pd=1.865e-05
+ nrs=0.11 nrd=0.22
m7270 2787 2764 2792 1 penh l=1.1e-06 w=1.24e-05
+ as=1.318e-11 ad=1.902e-11 ps=2.74e-06 pd=7.46e-06
+ nrs=0.09 nrd=0.12
m7271 2789 2764 2759 1 penh l=1.1e-06 w=1.2e-05
+ as=2.204e-11 ad=1.292e-11 ps=7.65e-06 pd=2.5e-06
+ nrs=0.15 nrd=0.09
m7272 2759 2764 2790 0 nenh l=1.1e-06 w=5.6e-06
+ as=9.36e-12 ad=4.76e-12 ps=3.38e-06 pd=1.7e-06
+ nrs=0.3 nrd=0.15
m7273 0 0 2791 0 nenh l=1.1e-06 w=6e-06
+ as=1.636e-11 ad=5.1e-12 ps=9.77e-06 pd=1.7e-06
+ nrs=0.45 nrd=0.14
m7274 101 2776 0 0 nenh l=1.1e-06 w=8.8e-06
+ as=1.075e-11 ad=2.4e-11 ps=5.69e-06 pd=1.433e-05
+ nrs=0.14 nrd=0.31
m7275 122 2776 0 0 nenh l=1.1e-06 w=8.8e-06
+ as=1.075e-11 ad=2.4e-11 ps=5.69e-06 pd=1.433e-05
+ nrs=0.14 nrd=0.31
m7276 2795 2776 1 1 penh l=1.1e-06 w=1.08e-05
+ as=1.039e-11 ad=2.614e-11 ps=2.7e-06 pd=1.865e-05
+ nrs=0.09 nrd=0.22
m7277 2796 2787 2794 1 penh l=1.1e-06 w=9.2e-06
+ as=7.82e-12 ad=1.091e-11 ps=1.7e-06 pd=2.3e-06
+ nrs=0.09 nrd=0.13
m7278 0 2787 101 0 nenh l=1.1e-06 w=7.2e-06
+ as=1.964e-11 ad=8.79e-12 ps=1.172e-05 pd=4.66e-06
+ nrs=0.38 nrd=0.17
m7279 0 2787 122 0 nenh l=1.1e-06 w=7.2e-06
+ as=1.964e-11 ad=8.79e-12 ps=1.172e-05 pd=4.66e-06
+ nrs=0.38 nrd=0.17
m7280 2797 2787 2795 1 penh l=1.1e-06 w=9.2e-06
+ as=7.82e-12 ad=8.85e-12 ps=1.7e-06 pd=2.3e-06
+ nrs=0.09 nrd=0.1
m7281 1 2798 2789 1 penh l=1.1e-06 w=1.16e-05
+ as=2.808e-11 ad=2.13e-11 ps=2.003e-05 pd=7.4e-06
+ nrs=0.21 nrd=0.16
m7282 0 2798 2759 0 nenh l=1.1e-06 w=6e-06
+ as=1.636e-11 ad=1.002e-11 ps=9.77e-06 pd=3.62e-06
+ nrs=0.45 nrd=0.28
m7283 2799 2800 1 1 penh l=1.1e-06 w=1.16e-05
+ as=2.13e-11 ad=2.808e-11 ps=7.4e-06 pd=2.003e-05
+ nrs=0.16 nrd=0.21
m7284 2760 2800 0 0 nenh l=1.1e-06 w=6e-06
+ as=1.002e-11 ad=1.636e-11 ps=3.62e-06 pd=9.77e-06
+ nrs=0.28 nrd=0.45
m7285 2792 0 2787 1 penh l=1.1e-06 w=1.2e-05
+ as=1.84e-11 ad=1.276e-11 ps=7.22e-06 pd=2.66e-06
+ nrs=0.13 nrd=0.09
m7286 19 13 1 1 penh l=1.1e-06 w=7.2e-06
+ as=1.188e-11 ad=1.743e-11 ps=3.3e-06 pd=1.243e-05
+ nrs=0.23 nrd=0.34
m7287 19 13 0 0 nenh l=1.1e-06 w=2.8e-06
+ as=4.62e-12 ad=7.64e-12 ps=3.3e-06 pd=4.56e-06
+ nrs=0.59 nrd=0.97
m7288 2801 0 0 0 nenh l=1.1e-06 w=6e-06
+ as=5.1e-12 ad=1.636e-11 ps=1.7e-06 pd=9.77e-06
+ nrs=0.14 nrd=0.45
m7289 1 13 19 1 penh l=1.1e-06 w=7.2e-06
+ as=1.743e-11 ad=1.188e-11 ps=1.243e-05 pd=3.3e-06
+ nrs=0.34 nrd=0.23
m7290 13 0 2802 1 penh l=1.1e-06 w=1.2e-05
+ as=1.276e-11 ad=1.708e-11 ps=2.66e-06 pd=7.22e-06
+ nrs=0.09 nrd=0.12
m7291 2760 2764 2799 1 penh l=1.1e-06 w=1.2e-05
+ as=1.292e-11 ad=2.204e-11 ps=2.5e-06 pd=7.65e-06
+ nrs=0.09 nrd=0.15
m7292 13 2764 2801 0 nenh l=1.1e-06 w=6e-06
+ as=1.017e-11 ad=5.1e-12 ps=3.39e-06 pd=1.7e-06
+ nrs=0.28 nrd=0.14
m7293 2803 2764 2760 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=9.36e-12 ps=1.7e-06 pd=3.38e-06
+ nrs=0.15 nrd=0.3
m7294 0 0 2803 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=4.76e-12 ps=9.12e-06 pd=1.7e-06
+ nrs=0.49 nrd=0.15
m7295 0 13 19 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.64e-12 ad=4.62e-12 ps=4.56e-06 pd=3.3e-06
+ nrs=0.97 nrd=0.59
m7296 101 2773 2796 1 penh l=1.1e-06 w=9.2e-06
+ as=1.782e-11 ad=7.82e-12 ps=1.53e-05 pd=1.7e-06
+ nrs=0.21 nrd=0.09
m7297 101 2773 0 0 nenh l=1.1e-06 w=9.2e-06
+ as=1.124e-11 ad=2.509e-11 ps=5.95e-06 pd=1.498e-05
+ nrs=0.13 nrd=0.3
m7298 122 2779 0 0 nenh l=1.1e-06 w=9.2e-06
+ as=1.124e-11 ad=2.509e-11 ps=5.95e-06 pd=1.498e-05
+ nrs=0.13 nrd=0.3
m7299 122 2779 2797 1 penh l=1.1e-06 w=9.2e-06
+ as=1.782e-11 ad=7.82e-12 ps=1.53e-05 pd=1.7e-06
+ nrs=0.21 nrd=0.09
m7300 25 11 1 1 penh l=1.1e-06 w=7.2e-06
+ as=1.188e-11 ad=1.743e-11 ps=3.3e-06 pd=1.243e-05
+ nrs=0.23 nrd=0.34
m7301 25 11 0 0 nenh l=1.1e-06 w=2.8e-06
+ as=4.62e-12 ad=7.64e-12 ps=3.3e-06 pd=4.56e-06
+ nrs=0.59 nrd=0.97
m7302 2802 2764 13 1 penh l=1.1e-06 w=1.24e-05
+ as=1.765e-11 ad=1.318e-11 ps=7.46e-06 pd=2.74e-06
+ nrs=0.11 nrd=0.09
m7303 0 2804 13 0 nenh l=1.1e-06 w=6.4e-06
+ as=1.746e-11 ad=1.085e-11 ps=1.042e-05 pd=3.61e-06
+ nrs=0.43 nrd=0.26
m7304 1 11 25 1 penh l=1.1e-06 w=7.2e-06
+ as=1.743e-11 ad=1.188e-11 ps=1.243e-05 pd=3.3e-06
+ nrs=0.34 nrd=0.23
m7305 1 2804 2802 1 penh l=1.1e-06 w=1.2e-05
+ as=2.904e-11 ad=1.708e-11 ps=2.072e-05 pd=7.22e-06
+ nrs=0.2 nrd=0.12
m7306 2799 0 2760 1 penh l=1.1e-06 w=1.2e-05
+ as=2.204e-11 ad=1.292e-11 ps=7.65e-06 pd=2.5e-06
+ nrs=0.15 nrd=0.09
m7307 11 2805 0 0 nenh l=1.1e-06 w=6e-06
+ as=1.11e-11 ad=1.636e-11 ps=3.7e-06 pd=9.77e-06
+ nrs=0.31 nrd=0.45
m7308 2806 2805 1 1 penh l=1.1e-06 w=1.2e-05
+ as=1.74e-11 ad=2.904e-11 ps=7.22e-06 pd=2.072e-05
+ nrs=0.12 nrd=0.2
m7309 2807 2773 80 1 penh l=1.1e-06 w=9.2e-06
+ as=7.82e-12 ad=1.782e-11 ps=1.7e-06 pd=1.53e-05
+ nrs=0.09 nrd=0.21
m7310 0 2773 80 0 nenh l=1.1e-06 w=9.2e-06
+ as=2.509e-11 ad=1.124e-11 ps=1.498e-05 pd=5.95e-06
+ nrs=0.3 nrd=0.13
m7311 0 2779 59 0 nenh l=1.1e-06 w=9.2e-06
+ as=2.509e-11 ad=1.124e-11 ps=1.498e-05 pd=5.95e-06
+ nrs=0.3 nrd=0.13
m7312 2808 2779 59 1 penh l=1.1e-06 w=9.2e-06
+ as=7.82e-12 ad=1.782e-11 ps=1.7e-06 pd=1.53e-05
+ nrs=0.09 nrd=0.21
m7313 2809 2784 2807 1 penh l=1.1e-06 w=9.2e-06
+ as=1.091e-11 ad=7.82e-12 ps=2.3e-06 pd=1.7e-06
+ nrs=0.13 nrd=0.09
m7314 80 2784 0 0 nenh l=1.1e-06 w=7.2e-06
+ as=8.79e-12 ad=1.964e-11 ps=4.66e-06 pd=1.172e-05
+ nrs=0.17 nrd=0.38
m7315 59 2784 0 0 nenh l=1.1e-06 w=7.2e-06
+ as=8.79e-12 ad=1.964e-11 ps=4.66e-06 pd=1.172e-05
+ nrs=0.17 nrd=0.38
m7316 2810 2784 2808 1 penh l=1.1e-06 w=9.2e-06
+ as=8.85e-12 ad=7.82e-12 ps=2.3e-06 pd=1.7e-06
+ nrs=0.1 nrd=0.09
m7317 0 11 25 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.64e-12 ad=4.62e-12 ps=4.56e-06 pd=3.3e-06
+ nrs=0.97 nrd=0.59
m7318 0 2787 2784 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=1.708e-11 ps=9.12e-06 pd=1.17e-05
+ nrs=0.49 nrd=0.54
m7319 1 2793 2809 1 penh l=1.1e-06 w=1.08e-05
+ as=2.614e-11 ad=1.281e-11 ps=1.865e-05 pd=2.7e-06
+ nrs=0.22 nrd=0.11
m7320 0 2793 80 0 nenh l=1.1e-06 w=8.8e-06
+ as=2.4e-11 ad=1.075e-11 ps=1.433e-05 pd=5.69e-06
+ nrs=0.31 nrd=0.14
m7321 0 2793 59 0 nenh l=1.1e-06 w=8.8e-06
+ as=2.4e-11 ad=1.075e-11 ps=1.433e-05 pd=5.69e-06
+ nrs=0.31 nrd=0.14
m7322 1 2793 2810 1 penh l=1.1e-06 w=1.08e-05
+ as=2.614e-11 ad=1.039e-11 ps=1.865e-05 pd=2.7e-06
+ nrs=0.22 nrd=0.09
m7323 2811 2793 1 1 penh l=1.1e-06 w=1.08e-05
+ as=1.281e-11 ad=2.614e-11 ps=2.7e-06 pd=1.865e-05
+ nrs=0.11 nrd=0.22
m7324 38 2793 0 0 nenh l=1.1e-06 w=8.8e-06
+ as=1.075e-11 ad=2.4e-11 ps=5.69e-06 pd=1.433e-05
+ nrs=0.14 nrd=0.31
m7325 15 2793 0 0 nenh l=1.1e-06 w=8.8e-06
+ as=1.075e-11 ad=2.4e-11 ps=5.69e-06 pd=1.433e-05
+ nrs=0.14 nrd=0.31
m7326 2812 2793 1 1 penh l=1.1e-06 w=1.08e-05
+ as=1.039e-11 ad=2.614e-11 ps=2.7e-06 pd=1.865e-05
+ nrs=0.09 nrd=0.22
m7327 1 2787 2784 1 penh l=1.1e-06 w=9.2e-06
+ as=2.227e-11 ad=2.87e-11 ps=1.588e-05 pd=1.69e-05
+ nrs=0.26 nrd=0.34
m7328 2813 2787 2811 1 penh l=1.1e-06 w=9.2e-06
+ as=7.82e-12 ad=1.091e-11 ps=1.7e-06 pd=2.3e-06
+ nrs=0.09 nrd=0.13
m7329 0 2787 38 0 nenh l=1.1e-06 w=7.2e-06
+ as=1.964e-11 ad=8.79e-12 ps=1.172e-05 pd=4.66e-06
+ nrs=0.38 nrd=0.17
m7330 0 2787 15 0 nenh l=1.1e-06 w=7.2e-06
+ as=1.964e-11 ad=8.79e-12 ps=1.172e-05 pd=4.66e-06
+ nrs=0.38 nrd=0.17
m7331 2814 2787 2812 1 penh l=1.1e-06 w=9.2e-06
+ as=7.82e-12 ad=8.85e-12 ps=1.7e-06 pd=2.3e-06
+ nrs=0.09 nrd=0.1
m7332 1 1 2764 1 penh l=1.1e-06 w=1.16e-05
+ as=2.808e-11 ad=3.314e-11 ps=2.003e-05 pd=1.69e-05
+ nrs=0.21 nrd=0.25
m7333 0 1 2764 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.527e-11 ad=1.708e-11 ps=9.12e-06 pd=1.17e-05
+ nrs=0.49 nrd=0.54
m7334 2815 0 11 0 nenh l=1.1e-06 w=6e-06
+ as=5.1e-12 ad=1.11e-11 ps=1.7e-06 pd=3.7e-06
+ nrs=0.14 nrd=0.31
m7335 11 0 2806 1 penh l=1.1e-06 w=1.24e-05
+ as=1.318e-11 ad=1.798e-11 ps=2.74e-06 pd=7.46e-06
+ nrs=0.09 nrd=0.12
m7336 0 2764 2815 0 nenh l=1.1e-06 w=6e-06
+ as=1.636e-11 ad=5.1e-12 ps=9.77e-06 pd=1.7e-06
+ nrs=0.45 nrd=0.14
m7337 2806 2764 11 1 penh l=1.1e-06 w=1.2e-05
+ as=1.74e-11 ad=1.276e-11 ps=7.22e-06 pd=2.66e-06
+ nrs=0.12 nrd=0.09
m7338 38 2773 2813 1 penh l=1.1e-06 w=9.2e-06
+ as=1.782e-11 ad=7.82e-12 ps=1.53e-05 pd=1.7e-06
+ nrs=0.21 nrd=0.09
m7339 38 2773 0 0 nenh l=1.1e-06 w=9.2e-06
+ as=1.124e-11 ad=2.509e-11 ps=5.95e-06 pd=1.498e-05
+ nrs=0.13 nrd=0.3
m7340 15 2779 0 0 nenh l=1.1e-06 w=9.2e-06
+ as=1.124e-11 ad=2.509e-11 ps=5.95e-06 pd=1.498e-05
+ nrs=0.13 nrd=0.3
m7341 15 2779 2814 1 penh l=1.1e-06 w=9.2e-06
+ as=1.846e-11 ad=7.82e-12 ps=1.53e-05 pd=1.7e-06
+ nrs=0.22 nrd=0.09
m7342 2389 2816 1 1 penh l=1.1e-06 w=7.6e-06
+ as=8.13e-12 ad=1.84e-11 ps=2.37e-06 pd=1.312e-05
+ nrs=0.14 nrd=0.32
m7343 2817 2816 2389 0 nenh l=1.1e-06 w=6e-06
+ as=5.55e-12 ad=1.606e-11 ps=2.34e-06 pd=1.13e-05
+ nrs=0.15 nrd=0.45
m7344 2818 2296 2819 0 nenh l=1.1e-06 w=6e-06
+ as=5.55e-12 ad=1.606e-11 ps=2.34e-06 pd=1.13e-05
+ nrs=0.15 nrd=0.45
m7345 2820 2819 0 0 nenh l=1.1e-06 w=2.8e-06
+ as=4.62e-12 ad=7.64e-12 ps=3.3e-06 pd=4.56e-06
+ nrs=0.59 nrd=0.97
m7346 1 2655 2389 1 penh l=1.1e-06 w=8.4e-06
+ as=2.033e-11 ad=8.99e-12 ps=1.45e-05 pd=2.63e-06
+ nrs=0.29 nrd=0.13
m7347 0 2655 2817 0 nenh l=1.1e-06 w=6.8e-06
+ as=1.855e-11 ad=6.29e-12 ps=1.107e-05 pd=2.66e-06
+ nrs=0.4 nrd=0.14
m7348 2819 2296 1 1 penh l=1.1e-06 w=7.6e-06
+ as=8.13e-12 ad=1.84e-11 ps=2.37e-06 pd=1.312e-05
+ nrs=0.14 nrd=0.32
m7349 2821 2819 2820 1 penh l=1.1e-06 w=1.12e-05
+ as=1.348e-11 ad=1.88e-11 ps=2.69e-06 pd=1.41e-05
+ nrs=0.11 nrd=0.15
m7350 2822 2823 1 1 penh l=1.1e-06 w=8.4e-06
+ as=2.562e-11 ad=2.033e-11 ps=1.45e-05 pd=1.45e-05
+ nrs=0.36 nrd=0.29
m7351 2824 2825 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.932e-11 ad=1.355e-11 ps=1.25e-05 pd=9.67e-06
+ nrs=0.62 nrd=0.43
m7352 2824 2825 0 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.64e-12 ps=8.9e-06 pd=4.56e-06
+ nrs=1.09 nrd=0.97
m7353 2826 2825 2827 0 nenh l=1.1e-06 w=2.8e-06
+ as=2.38e-12 ad=8.54e-12 ps=1.7e-06 pd=8.9e-06
+ nrs=0.3 nrd=1.09
m7354 2822 2823 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.527e-11 ps=1.17e-05 pd=9.12e-06
+ nrs=0.54 nrd=0.49
m7355 2828 2824 2827 1 penh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.708e-11 ps=1.7e-06 pd=1.17e-05
+ nrs=0.15 nrd=0.54
m7356 2829 2823 2654 1 penh l=1.1e-06 w=1.72e-05
+ as=1.462e-11 ad=5.246e-11 ps=1.7e-06 pd=2.33e-05
+ nrs=0.05 nrd=0.18
m7357 2830 2822 2654 0 nenh l=1.1e-06 w=9.6e-06
+ as=8.16e-12 ad=2.928e-11 ps=1.7e-06 pd=1.57e-05
+ nrs=0.09 nrd=0.32
m7358 1 0 2821 1 penh l=1.1e-06 w=9.6e-06
+ as=2.324e-11 ad=1.156e-11 ps=1.657e-05 pd=2.31e-06
+ nrs=0.25 nrd=0.13
m7359 0 0 2820 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.64e-12 ad=4.62e-12 ps=4.56e-06 pd=3.3e-06
+ nrs=0.97 nrd=0.59
m7360 0 2389 2818 0 nenh l=1.1e-06 w=6.8e-06
+ as=1.855e-11 ad=6.29e-12 ps=1.107e-05 pd=2.66e-06
+ nrs=0.4 nrd=0.14
m7361 1 2389 2819 1 penh l=1.1e-06 w=8.4e-06
+ as=2.033e-11 ad=8.99e-12 ps=1.45e-05 pd=2.63e-06
+ nrs=0.29 nrd=0.13
m7362 2471 2655 1 1 penh l=1.1e-06 w=8e-06
+ as=8.56e-12 ad=1.936e-11 ps=2.5e-06 pd=1.381e-05
+ nrs=0.13 nrd=0.3
m7363 2831 2655 0 0 nenh l=1.1e-06 w=6.4e-06
+ as=5.92e-12 ad=1.746e-11 ps=2.5e-06 pd=1.042e-05
+ nrs=0.14 nrd=0.43
m7364 2832 2389 0 0 nenh l=1.1e-06 w=6.4e-06
+ as=5.92e-12 ad=1.746e-11 ps=2.5e-06 pd=1.042e-05
+ nrs=0.14 nrd=0.43
m7365 1 2833 2471 1 penh l=1.1e-06 w=8e-06
+ as=1.936e-11 ad=8.56e-12 ps=1.381e-05 pd=2.5e-06
+ nrs=0.3 nrd=0.13
m7366 2471 2833 2831 0 nenh l=1.1e-06 w=6.4e-06
+ as=1.504e-11 ad=5.92e-12 ps=1.09e-05 pd=2.5e-06
+ nrs=0.37 nrd=0.14
m7367 2296 2761 1 1 penh l=1.1e-06 w=7.6e-06
+ as=8.13e-12 ad=1.84e-11 ps=2.37e-06 pd=1.312e-05
+ nrs=0.14 nrd=0.32
m7368 0 2761 2833 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.64e-12 ad=8.54e-12 ps=4.56e-06 pd=8.9e-06
+ nrs=0.97 nrd=1.09
m7369 1 2761 2833 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.708e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.54
m7370 2816 2766 0 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.64e-12 ps=8.9e-06 pd=4.56e-06
+ nrs=1.09 nrd=0.97
m7371 2834 2761 2296 0 nenh l=1.1e-06 w=6e-06
+ as=5.55e-12 ad=1.606e-11 ps=2.34e-06 pd=1.13e-05
+ nrs=0.15 nrd=0.45
m7372 2835 2389 1 1 penh l=1.1e-06 w=8e-06
+ as=8.56e-12 ad=1.936e-11 ps=2.5e-06 pd=1.381e-05
+ nrs=0.13 nrd=0.3
m7373 2836 0 1 1 penh l=1.1e-06 w=9.6e-06
+ as=1.156e-11 ad=2.324e-11 ps=2.31e-06 pd=1.657e-05
+ nrs=0.13 nrd=0.25
m7374 2825 0 0 0 nenh l=1.1e-06 w=2.8e-06
+ as=4.62e-12 ad=7.64e-12 ps=3.3e-06 pd=4.56e-06
+ nrs=0.59 nrd=0.97
m7375 2835 2471 2832 0 nenh l=1.1e-06 w=6.4e-06
+ as=1.504e-11 ad=5.92e-12 ps=1.09e-05 pd=2.5e-06
+ nrs=0.37 nrd=0.14
m7376 1 2471 2835 1 penh l=1.1e-06 w=8e-06
+ as=1.936e-11 ad=8.56e-12 ps=1.381e-05 pd=2.5e-06
+ nrs=0.3 nrd=0.13
m7377 2825 2835 2836 1 penh l=1.1e-06 w=1.12e-05
+ as=1.88e-11 ad=1.348e-11 ps=1.41e-05 pd=2.69e-06
+ nrs=0.15 nrd=0.11
m7378 0 2835 2825 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.64e-12 ad=4.62e-12 ps=4.56e-06 pd=3.3e-06
+ nrs=0.97 nrd=0.59
m7379 2837 2471 1 1 penh l=1.1e-06 w=7.2e-06
+ as=1.188e-11 ad=1.743e-11 ps=3.3e-06 pd=1.243e-05
+ nrs=0.23 nrd=0.34
m7380 2838 2837 0 0 nenh l=1.1e-06 w=2.8e-06
+ as=4.62e-12 ad=7.64e-12 ps=3.3e-06 pd=4.56e-06
+ nrs=0.59 nrd=0.97
m7381 2839 2471 2837 0 nenh l=1.1e-06 w=6e-06
+ as=5.55e-12 ad=1.606e-11 ps=2.34e-06 pd=1.13e-05
+ nrs=0.15 nrd=0.45
m7382 1 2655 2296 1 penh l=1.1e-06 w=8.4e-06
+ as=2.033e-11 ad=8.99e-12 ps=1.45e-05 pd=2.63e-06
+ nrs=0.29 nrd=0.13
m7383 0 2655 2834 0 nenh l=1.1e-06 w=6.8e-06
+ as=1.855e-11 ad=6.29e-12 ps=1.107e-05 pd=2.66e-06
+ nrs=0.4 nrd=0.14
m7384 2840 2837 2838 1 penh l=1.1e-06 w=9.6e-06
+ as=8.16e-12 ad=2.928e-11 ps=1.7e-06 pd=1.57e-05
+ nrs=0.09 nrd=0.32
m7385 2841 8 2634 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.061e-11 ps=1.17e-05 pd=6.1e-06
+ nrs=0.54 nrd=0.34
m7386 2841 2842 2634 1 penh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=9.57e-12 ps=1.17e-05 pd=3.89e-06
+ nrs=0.54 nrd=0.31
m7387 0 2841 2826 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.64e-12 ad=2.38e-12 ps=4.56e-06 pd=1.7e-06
+ nrs=0.97 nrd=0.3
m7388 1 2841 2828 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=4.76e-12 ps=9.67e-06 pd=1.7e-06
+ nrs=0.43 nrd=0.15
m7389 1 2841 2829 1 penh l=1.1e-06 w=1.72e-05
+ as=4.163e-11 ad=1.462e-11 ps=2.97e-05 pd=1.7e-06
+ nrs=0.14 nrd=0.05
m7390 0 2841 2830 0 nenh l=1.1e-06 w=9.6e-06
+ as=2.618e-11 ad=8.16e-12 ps=1.563e-05 pd=1.7e-06
+ nrs=0.28 nrd=0.09
m7391 2842 2843 0 0 nenh l=1.1e-06 w=8.4e-06
+ as=1.314e-11 ad=2.291e-11 ps=4.03e-06 pd=1.368e-05
+ nrs=0.19 nrd=0.32
m7392 1 0 2840 1 penh l=1.1e-06 w=9.6e-06
+ as=2.324e-11 ad=8.16e-12 ps=1.657e-05 pd=1.7e-06
+ nrs=0.25 nrd=0.09
m7393 0 0 2838 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.64e-12 ad=4.62e-12 ps=4.56e-06 pd=3.3e-06
+ nrs=0.97 nrd=0.59
m7394 2844 2845 0 0 nenh l=1.1e-06 w=2.8e-06
+ as=2.94e-12 ad=7.64e-12 ps=2.1e-06 pd=4.56e-06
+ nrs=0.38 nrd=0.97
m7395 2845 8 2665 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.061e-11 ps=1.17e-05 pd=6.1e-06
+ nrs=0.54 nrd=0.34
m7396 2845 2842 2665 1 penh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=9.57e-12 ps=1.17e-05 pd=3.89e-06
+ nrs=0.54 nrd=0.31
m7397 2846 2845 1 1 penh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.355e-11 ps=1.7e-06 pd=9.67e-06
+ nrs=0.15 nrd=0.43
m7398 2847 2845 1 1 penh l=1.1e-06 w=1.72e-05
+ as=1.462e-11 ad=4.163e-11 ps=1.7e-06 pd=2.97e-05
+ nrs=0.05 nrd=0.14
m7399 2848 2845 0 0 nenh l=1.1e-06 w=9.6e-06
+ as=1.156e-11 ad=2.618e-11 ps=2.31e-06 pd=1.563e-05
+ nrs=0.13 nrd=0.28
m7400 2827 2838 2844 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=2.94e-12 ps=8.9e-06 pd=2.1e-06
+ nrs=1.09 nrd=0.38
m7401 1 2838 2849 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.708e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.54
m7402 0 2838 2849 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.64e-12 ad=8.54e-12 ps=4.56e-06 pd=8.9e-06
+ nrs=0.97 nrd=1.09
m7403 2842 2843 1 1 penh l=1.1e-06 w=1.96e-05
+ as=3.234e-11 ad=4.744e-11 ps=3.3e-06 pd=3.384e-05
+ nrs=0.08 nrd=0.12
m7404 2816 2766 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.54 nrd=0.43
m7405 0 2298 2839 0 nenh l=1.1e-06 w=6.8e-06
+ as=1.855e-11 ad=6.29e-12 ps=1.107e-05 pd=2.66e-06
+ nrs=0.4 nrd=0.14
m7406 1 2298 2837 1 penh l=1.1e-06 w=7.2e-06
+ as=1.743e-11 ad=1.188e-11 ps=1.243e-05 pd=3.3e-06
+ nrs=0.34 nrd=0.23
m7407 2298 2655 1 1 penh l=1.1e-06 w=8e-06
+ as=8.56e-12 ad=1.936e-11 ps=2.5e-06 pd=1.381e-05
+ nrs=0.13 nrd=0.3
m7408 2850 2655 0 0 nenh l=1.1e-06 w=6.4e-06
+ as=5.92e-12 ad=1.746e-11 ps=2.5e-06 pd=1.042e-05
+ nrs=0.14 nrd=0.43
m7409 2851 2298 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=4.98e-12 ad=1.527e-11 ps=1.96e-06 pd=9.12e-06
+ nrs=0.16 nrd=0.49
m7410 1 2766 2298 1 penh l=1.1e-06 w=8e-06
+ as=1.936e-11 ad=8.56e-12 ps=1.381e-05 pd=2.5e-06
+ nrs=0.3 nrd=0.13
m7411 2298 2766 2850 0 nenh l=1.1e-06 w=6.4e-06
+ as=1.504e-11 ad=5.92e-12 ps=1.09e-05 pd=2.5e-06
+ nrs=0.37 nrd=0.14
m7412 0 2843 2842 0 nenh l=1.1e-06 w=1.12e-05
+ as=3.055e-11 ad=1.752e-11 ps=1.824e-05 pd=5.37e-06
+ nrs=0.24 nrd=0.14
m7413 1 2843 2842 1 penh l=1.1e-06 w=1.96e-05
+ as=4.744e-11 ad=3.234e-11 ps=3.384e-05 pd=3.3e-06
+ nrs=0.12 nrd=0.08
m7414 2852 2298 1 1 penh l=1.1e-06 w=8.4e-06
+ as=1.399e-11 ad=2.033e-11 ps=4.2e-06 pd=1.45e-05
+ nrs=0.2 nrd=0.29
m7415 2853 0 1 1 penh l=1.1e-06 w=9.6e-06
+ as=8.16e-12 ad=2.324e-11 ps=1.7e-06 pd=1.657e-05
+ nrs=0.09 nrd=0.25
m7416 2854 0 0 0 nenh l=1.1e-06 w=2.8e-06
+ as=4.62e-12 ad=7.64e-12 ps=3.3e-06 pd=4.56e-06
+ nrs=0.59 nrd=0.97
m7417 8 2842 0 0 nenh l=1.1e-06 w=1.4e-05
+ as=2.386e-11 ad=3.818e-11 ps=4.27e-06 pd=2.28e-05
+ nrs=0.12 nrd=0.19
m7418 2852 2296 2851 0 nenh l=1.1e-06 w=6.4e-06
+ as=1.504e-11 ad=5.7e-12 ps=1.09e-05 pd=2.24e-06
+ nrs=0.37 nrd=0.14
m7419 2854 2852 2853 1 penh l=1.1e-06 w=9.6e-06
+ as=2.928e-11 ad=8.16e-12 ps=1.57e-05 pd=1.7e-06
+ nrs=0.32 nrd=0.09
m7420 1 2296 2852 1 penh l=1.1e-06 w=7.2e-06
+ as=1.743e-11 ad=1.199e-11 ps=1.243e-05 pd=3.6e-06
+ nrs=0.34 nrd=0.23
m7421 0 2852 2854 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.64e-12 ad=4.62e-12 ps=4.56e-06 pd=3.3e-06
+ nrs=0.97 nrd=0.59
m7422 8 2842 1 1 penh l=1.1e-06 w=2.52e-05
+ as=4.158e-11 ad=6.099e-11 ps=3.3e-06 pd=4.351e-05
+ nrs=0.07 nrd=0.1
m7423 2855 8 2687 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.061e-11 ps=1.17e-05 pd=6.1e-06
+ nrs=0.54 nrd=0.34
m7424 2855 2842 2687 1 penh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=9.57e-12 ps=1.17e-05 pd=3.89e-06
+ nrs=0.54 nrd=0.31
m7425 2827 2849 2846 1 penh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=4.76e-12 ps=1.17e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m7426 2675 2823 2847 1 penh l=1.1e-06 w=1.72e-05
+ as=3.486e-11 ad=1.462e-11 ps=2.33e-05 pd=1.7e-06
+ nrs=0.12 nrd=0.05
m7427 2856 2820 1 1 penh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.355e-11 ps=1.17e-05 pd=9.67e-06
+ nrs=0.54 nrd=0.43
m7428 2856 2820 0 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=7.64e-12 ps=8.9e-06 pd=4.56e-06
+ nrs=1.09 nrd=0.97
m7429 2857 2820 2827 0 nenh l=1.1e-06 w=2.8e-06
+ as=2.38e-12 ad=8.54e-12 ps=1.7e-06 pd=8.9e-06
+ nrs=0.3 nrd=1.09
m7430 2675 2822 2848 0 nenh l=1.1e-06 w=1.12e-05
+ as=1.88e-11 ad=1.348e-11 ps=1.41e-05 pd=2.69e-06
+ nrs=0.15 nrd=0.11
m7431 2858 2856 2827 1 penh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.708e-11 ps=1.7e-06 pd=1.17e-05
+ nrs=0.15 nrd=0.54
m7432 2859 2823 2697 1 penh l=1.1e-06 w=1.72e-05
+ as=1.462e-11 ad=4.174e-11 ps=1.7e-06 pd=2.33e-05
+ nrs=0.05 nrd=0.14
m7433 2860 2822 2697 0 nenh l=1.1e-06 w=9.6e-06
+ as=8.16e-12 ad=2.256e-11 ps=1.7e-06 pd=1.57e-05
+ nrs=0.09 nrd=0.24
m7434 0 2855 2857 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.64e-12 ad=2.38e-12 ps=4.56e-06 pd=1.7e-06
+ nrs=0.97 nrd=0.3
m7435 1 2855 2858 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=4.76e-12 ps=9.67e-06 pd=1.7e-06
+ nrs=0.43 nrd=0.15
m7436 1 2855 2859 1 penh l=1.1e-06 w=1.72e-05
+ as=4.163e-11 ad=1.462e-11 ps=2.97e-05 pd=1.7e-06
+ nrs=0.14 nrd=0.05
m7437 0 2855 2860 0 nenh l=1.1e-06 w=9.6e-06
+ as=2.618e-11 ad=8.16e-12 ps=1.563e-05 pd=1.7e-06
+ nrs=0.28 nrd=0.09
m7438 2861 8 2709 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.061e-11 ps=1.17e-05 pd=6.1e-06
+ nrs=0.54 nrd=0.34
m7439 2861 2842 2709 1 penh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=9.57e-12 ps=1.17e-05 pd=3.89e-06
+ nrs=0.54 nrd=0.31
m7440 2862 2861 0 0 nenh l=1.1e-06 w=2.8e-06
+ as=2.38e-12 ad=7.64e-12 ps=1.7e-06 pd=4.56e-06
+ nrs=0.3 nrd=0.97
m7441 2863 2861 1 1 penh l=1.1e-06 w=5.6e-06
+ as=4.76e-12 ad=1.355e-11 ps=1.7e-06 pd=9.67e-06
+ nrs=0.15 nrd=0.43
m7442 2864 2861 1 1 penh l=1.1e-06 w=1.72e-05
+ as=1.784e-11 ad=4.163e-11 ps=5.07e-06 pd=2.97e-05
+ nrs=0.06 nrd=0.14
m7443 2865 2861 0 0 nenh l=1.1e-06 w=9.6e-06
+ as=8.16e-12 ad=2.618e-11 ps=1.7e-06 pd=1.563e-05
+ nrs=0.09 nrd=0.28
m7444 1 2854 2866 1 penh l=1.1e-06 w=5.6e-06
+ as=1.355e-11 ad=1.708e-11 ps=9.67e-06 pd=1.17e-05
+ nrs=0.43 nrd=0.54
m7445 0 2854 2866 0 nenh l=1.1e-06 w=2.8e-06
+ as=7.64e-12 ad=8.54e-12 ps=4.56e-06 pd=8.9e-06
+ nrs=0.97 nrd=1.09
m7446 2827 2854 2862 0 nenh l=1.1e-06 w=2.8e-06
+ as=8.54e-12 ad=2.38e-12 ps=8.9e-06 pd=1.7e-06
+ nrs=1.09 nrd=0.3
m7447 2827 2866 2863 1 penh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=4.76e-12 ps=1.17e-05 pd=1.7e-06
+ nrs=0.54 nrd=0.15
m7448 2864 2823 2719 1 penh l=1.1e-06 w=1.84e-05
+ as=1.908e-11 ad=4.346e-11 ps=5.43e-06 pd=1.62e-05
+ nrs=0.06 nrd=0.13
m7449 2719 2822 2865 0 nenh l=1.1e-06 w=9.6e-06
+ as=2.928e-11 ad=8.16e-12 ps=1.57e-05 pd=1.7e-06
+ nrs=0.32 nrd=0.09
m7450 0 2842 8 0 nenh l=1.1e-06 w=1.68e-05
+ as=4.582e-11 ad=2.864e-11 ps=2.735e-05 pd=5.13e-06
+ nrs=0.16 nrd=0.1
m7451 1 2842 8 1 penh l=1.1e-06 w=2.52e-05
+ as=6.099e-11 ad=4.158e-11 ps=4.351e-05 pd=3.3e-06
+ nrs=0.1 nrd=0.07
m7452 2823 0 1 1 penh l=1.1e-06 w=8.4e-06
+ as=2.562e-11 ad=2.033e-11 ps=1.45e-05 pd=1.45e-05
+ nrs=0.36 nrd=0.29
m7453 2823 0 0 0 nenh l=1.1e-06 w=5.6e-06
+ as=1.708e-11 ad=1.527e-11 ps=1.17e-05 pd=9.12e-06
+ nrs=0.54 nrd=0.49
c60 2852 0 3.422e-15
c61 2816 0 6.537e-15
c62 2837 0 3.162e-15
c63 2835 0 3.372e-15
c64 2833 0 4.112e-15
c66 2819 0 5.593e-15
c67 2762 0 5.638e-15
c68 2755 0 3.317e-15
c69 2631 0 3.225e-15
c70 2629 0 3.448e-15
c71 2628 0 3.33e-15
c72 2626 0 3.408e-15
c73 2608 0 8.146e-15
c74 2598 0 7.935e-15
c75 2597 0 7.971e-15
c76 2604 0 7.545e-15
c77 2609 0 4.865e-15
c78 2601 0 4.85e-15
c79 2591 0 3.225e-15
c80 2589 0 3.448e-15
c81 2588 0 3.33e-15
c82 2586 0 3.408e-15
c83 2566 0 8.146e-15
c84 2556 0 7.935e-15
c85 2555 0 7.971e-15
c86 2562 0 7.945e-15
c87 2567 0 4.865e-15
c88 2559 0 4.85e-15
c89 2549 0 3.225e-15
c90 2547 0 3.448e-15
c91 2546 0 3.33e-15
c92 2544 0 3.408e-15
c93 2526 0 8.146e-15
c94 2516 0 7.935e-15
c95 2515 0 7.971e-15
c96 2522 0 7.945e-15
c97 2527 0 4.865e-15
c98 2519 0 4.85e-15
c99 2509 0 3.225e-15
c100 2507 0 3.448e-15
c101 2506 0 3.33e-15
c102 2504 0 3.408e-15
c103 2484 0 8.146e-15
c104 2474 0 7.935e-15
c105 2473 0 7.971e-15
c106 2480 0 7.945e-15
c107 2485 0 4.865e-15
c108 2477 0 4.85e-15
c109 2466 0 3.225e-15
c110 2464 0 3.448e-15
c111 2463 0 3.33e-15
c112 2461 0 3.408e-15
c113 2443 0 8.146e-15
c114 2433 0 7.935e-15
c115 2432 0 7.971e-15
c116 2439 0 7.945e-15
c117 2444 0 4.865e-15
c118 2436 0 4.85e-15
c119 2426 0 3.225e-15
c120 2424 0 3.448e-15
c121 2423 0 3.33e-15
c122 2421 0 3.408e-15
c123 2401 0 8.146e-15
c124 2391 0 7.935e-15
c125 2390 0 7.971e-15
c126 2397 0 7.945e-15
c127 2402 0 4.865e-15
c128 2394 0 4.85e-15
c129 2383 0 3.225e-15
c130 2381 0 3.448e-15
c131 2380 0 3.33e-15
c132 2378 0 3.408e-15
c133 2359 0 8.146e-15
c134 2347 0 7.935e-15
c135 2346 0 7.971e-15
c136 2354 0 7.945e-15
c137 2360 0 4.865e-15
c138 2350 0 4.85e-15
c139 2339 0 3.225e-15
c140 2337 0 3.448e-15
c141 2336 0 3.33e-15
c142 2334 0 3.408e-15
c143 2313 0 8.146e-15
c144 2301 0 7.935e-15
c145 2308 0 7.945e-15
c146 2314 0 4.865e-15
c147 2304 0 4.85e-15
c148 176 0 5.974e-15
c149 171 0 5.953e-15
c150 166 0 5.974e-15
c151 160 0 5.953e-15
c152 155 0 5.974e-15
c153 150 0 5.953e-15
c154 145 0 5.974e-15
c155 139 0 5.953e-15
c156 134 0 5.974e-15
c157 129 0 5.953e-15
c158 124 0 5.974e-15
c159 118 0 5.953e-15
c160 113 0 5.974e-15
c161 108 0 5.953e-15
c162 103 0 5.974e-15
c163 97 0 5.953e-15
c164 92 0 5.974e-15
c165 87 0 5.953e-15
c166 82 0 5.974e-15
c167 76 0 5.953e-15
c168 71 0 5.974e-15
c169 66 0 5.953e-15
c170 61 0 5.974e-15
c171 55 0 5.953e-15
c172 50 0 5.974e-15
c173 45 0 5.953e-15
c174 40 0 5.974e-15
c175 34 0 5.953e-15
c176 29 0 5.974e-15
c177 23 0 5.953e-15
c178 17 0 5.974e-15
c179 9 0 5.953e-15
c180 5 0 4.774e-15
c181 4 0 3.578e-15
c182 1077 217 2.14e-16
c183 0 2169 2.623e-15
c184 2200 201 7.77e-16
c185 8 23 1.96e-16
c186 1634 229 2.5e-16
c187 216 153 3.24e-16
c188 2781 2786 1.21e-16
c189 204 168 3.34e-16
c190 208 163 3.24e-16
c191 0 556 2.585e-15
c192 2136 233 7.77e-16
c193 1 1070 1.6e-16
c194 199 168 3.24e-16
c195 196 178 3.34e-16
c196 2351 2409 4.4e-16
c197 1989 224 7.76e-16
c198 0 375 2.957e-15
c199 2572 230 5.06e-16
c200 2545 222 1.7e-16
c201 407 202 7.23e-16
c202 207 105 3.24e-16
c203 90 187 3.34e-16
c204 0 885 2.926e-15
c205 115 193 1.9e-16
c206 111 189 1.99e-16
c207 105 202 1.99e-16
c208 3 184 3.08e-16
c209 0 128 1.82e-16
c210 2655 2427 1.96e-16
c211 0 1197 2.926e-15
c212 1 191 3.42e-15
c213 1 2842 2.839e-15
c214 0 1640 2.957e-15
c215 1760 231 2.13e-16
c216 2409 2397 3.92e-16
c217 58 185 3.31e-16
c218 20 213 3.34e-16
c219 2296 2462 1.58e-16
c220 1 2139 1.6e-16
c221 1046 203 7.91e-16
c222 1910 1911 6.77e-16
c223 1465 216 7.91e-16
c224 0 1952 2.957e-15
c225 1044 1045 6.77e-16
c226 1 1462 1.6e-16
c227 2327 186 4.83e-16
c228 292 293 6.77e-16
c229 164 79 3.31e-16
c230 1332 216 2.13e-16
c231 1808 191 2.13e-16
c232 1810 189 2.5e-16
c233 1652 184 2.13e-16
c234 2324 183 3.12e-16
c235 150 153 3.92e-16
c236 2842 2845 1.96e-16
c237 0 665 2.623e-15
c238 676 209 8.32e-16
c239 677 208 7.76e-16
c240 615 242 7.23e-16
c241 1025 182 2.54e-16
c242 1027 180 2.8e-16
c243 0 1606 2.623e-15
c244 240 241 2e-16
c245 2217 2216 6.77e-16
c246 1740 222 8.32e-16
c247 2105 217 2.54e-16
c248 2104 216 2.13e-16
c249 1470 1471 6.77e-16
c250 0 646 2.623e-15
c251 0 482 2.957e-15
c252 142 207 1.94e-16
c253 136 208 1.94e-16
c254 1172 201 8.32e-16
c255 1173 200 7.76e-16
c256 0 977 2.623e-15
c257 604 605 6.77e-16
c258 1018 187 7.23e-16
c259 1801 1800 6.77e-16
c260 42 225 1.9e-16
c261 31 220 3.34e-16
c262 143 58 3.26e-16
c263 142 202 3.34e-16
c264 1880 233 7.77e-16
c265 2587 2516 1.24e-16
c266 227 458 7.23e-16
c267 2835 2471 1.402e-15
c268 0 1418 2.957e-15
c269 1435 202 7.91e-16
c270 1436 198 8.32e-16
c271 0 1304 2.957e-15
c272 1317 209 2.14e-16
c273 0 1913 2.623e-15
c274 1 814 1.6e-16
c275 6 5 3.204e-15
c276 2240 0 2.957e-15
c277 2492 2526 3.92e-16
c278 38 17 1.74e-16
c279 8 97 1.96e-16
c280 648 193 7.77e-16
c281 229 90 1.99e-16
c282 1 299 1.6e-16
c283 732 231 2.13e-16
c284 27 209 3.31e-16
c285 2223 0 2.957e-15
c286 1 1126 1.6e-16
c287 2113 2112 6.77e-16
c288 1361 1360 6.77e-16
c289 222 100 1.9e-16
c290 220 94 3.34e-16
c291 42 198 3.31e-16
c292 27 203 3.34e-16
c293 1 611 1.6e-16
c294 0 1548 2.585e-15
c295 1562 203 7.23e-16
c296 0 2042 2.957e-15
c297 2074 202 2.5e-16
c298 2078 197 2.8e-16
c299 2077 198 2.14e-16
c300 2076 199 2.13e-16
c301 2079 196 2.5e-16
c302 1504 231 2.13e-16
c303 2392 2402 1.38e-16
c304 8 45 1.96e-16
c305 58 231 1.94e-16
c306 52 234 1.99e-16
c307 0 424 2.957e-15
c308 1 1883 1.6e-16
c309 236 237 6.86e-16
c310 0 1367 2.957e-15
c311 100 217 3.31e-16
c312 84 219 1.99e-16
c313 276 200 2.13e-16
c314 3 239 3.08e-16
c315 2572 2477 6.17e-16
c316 2492 2485 2.8e-16
c317 0 736 2.957e-15
c318 2709 2643 3.54e-16
c319 1 246 1.6e-16
c320 1286 195 7.91e-16
c321 1643 242 7.91e-16
c322 2722 0 1.65e-16
c323 2145 230 2.54e-16
c324 2641 2592 1.96e-16
c325 2358 2587 4.25e-16
c326 2299 2574 2.28e-16
c327 80 27 1.59e-16
c328 0 48 7.8194e-14
c329 1 1513 1.6e-16
c330 1849 217 2.54e-16
c331 1848 216 2.13e-16
c332 2645 2490 1.58e-16
c333 2294 2572 8.48e-16
c334 0 390 2.623e-15
c335 364 238 8.32e-16
c336 366 236 7.91e-16
c337 0 900 2.585e-15
c338 916 201 8.32e-16
c339 917 200 7.76e-16
c340 822 823 6.77e-16
c341 2019 2018 6.77e-16
c342 2383 194 2.339e-15
c343 1 1825 1.6e-16
c345 2761 2766 2.57e-16
c346 2734 2758 3.92e-16
c347 550 210 2.8e-16
c348 0 1212 2.585e-15
c349 1061 209 2.14e-16
c350 0 1657 2.623e-15
c351 1623 234 7.23e-16
c352 1622 235 7.91e-16
c353 20 222 3.31e-16
c354 2268 231 2.13e-16
c355 2627 238 1.7e-16
c356 183 153 1.94e-16
c357 0 1031 2.957e-15
c358 703 212 2.5e-16
c359 240 485 7.76e-16
c360 0 1474 2.957e-15
c361 0 1969 2.623e-15
c362 1134 1135 6.77e-16
c363 1975 219 2.5e-16
c364 380 182 8.32e-16
c365 382 180 7.91e-16
c366 379 186 7.91e-16
c367 888 185 7.77e-16
c368 2827 2824 2.37e-16
c369 2654 2634 1.96e-16
c370 1776 239 2.13e-16
c371 1778 237 2.5e-16
c372 2279 0 2.957e-15
c373 20 217 1.9e-16
c374 0 349 2.926e-15
c375 2585 2581 6.13e-16
c376 11 0 8.8322e-14
c377 1 14 7.6e-16
c378 1654 1655 6.77e-16
c379 1 2814 2.88e-16
c380 0 1621 2.926e-15
c381 1124 241 8.32e-16
c382 1 1177 1.6e-16
c383 0 661 2.926e-15
c384 2649 2351 1.96e-16
c385 2647 2651 5.88e-16
c386 0 499 2.623e-15
c387 164 157 3.31e-16
c388 1891 1890 6.77e-16
c389 1 500 1.6e-16
c390 0 1916 2.585e-15
c391 1025 1024 6.77e-16
c392 2497 218 4.83e-16
c393 2475 0 6.737e-15
c394 0 973 2.926e-15
c395 273 272 6.77e-16
c396 221 466 2.5e-16
c397 220 467 2.8e-16
c398 961 214 2.54e-16
c399 1375 228 2.5e-16
c400 69 232 3.24e-16
c401 63 234 1.99e-16
c402 1792 183 2.13e-16
c403 1794 181 2.5e-16
c404 1966 1967 6.77e-16
c405 2305 2386 1.96e-16
c406 2508 2484 2.86e-16
c407 2732 0 2.0734e-14
c408 958 213 2.8e-16
c409 0 1728 2.957e-15
c410 2238 0 2.623e-15
c411 2585 2519 4.73e-16
c412 2632 2512 2.3e-16
c413 1451 1450 6.77e-16
c414 2358 0 6.8501e-14
c415 1 1569 1.6e-16
c416 2641 2382 1.96e-16
c417 1 2746 3.66e-16
c418 1098 226 2.5e-16
c419 1099 227 2.8e-16
c420 0 2059 2.623e-15
c421 2519 2512 1.38e-16
c422 1513 240 7.91e-16
c423 52 241 1.9e-16
c424 48 243 3.34e-16
c425 2273 2272 6.77e-16
c426 0 441 2.623e-15
c427 1 2060 1.6e-16
c428 2299 2567 1.196e-15
c429 232 168 1.94e-16
c430 235 163 3.34e-16
c431 223 592 2.13e-16
c432 750 237 2.8e-16
c433 749 238 2.14e-16
c434 748 239 2.13e-16
c435 751 236 2.5e-16
c436 0 1382 2.623e-15
c437 2784 2793 4.97e-16
c438 1419 194 7.91e-16
c439 1420 190 8.32e-16
c440 1500 230 8.32e-16
c441 2012 231 2.13e-16
c442 2215 211 2.5e-16
c443 2299 2304 1.496e-15
c444 0 258 2.957e-15
c445 0 753 2.623e-15
c446 2795 122 4.62e-16
c447 2800 2760 3.89e-16
c448 234 105 1.99e-16
c449 0 1694 2.623e-15
c450 31 186 1.99e-16
c451 1 1267 1.6e-16
c452 1520 239 2.13e-16
c453 1522 237 2.5e-16
c454 1553 190 2.54e-16
c455 1555 188 2.8e-16
c456 238 153 1.9e-16
c457 2298 2294 2.621e-15
c458 2296 2635 1.58e-16
c459 13 143 1.237e-15
c460 220 121 1.99e-16
c461 223 115 3.24e-16
c462 2152 240 2.13e-16
c463 1 2203 1.6e-16
c464 0 1080 2.957e-15
c465 164 145 4.85e-16
c466 1 590 1.6e-16
c467 1233 222 2.54e-16
c468 1546 195 7.23e-16
c469 211 174 3.34e-16
c470 2141 230 2.14e-16
c471 2312 2627 2.29e-16
c472 2651 2550 1.96e-16
c473 2305 2625 2.83e-16
c474 2647 2585 1.96e-16
c475 0 405 2.926e-15
c476 1596 1597 6.77e-16
c477 143 140 2.32e-16
c478 90 210 3.34e-16
c479 762 186 2.5e-16
c480 766 181 2.8e-16
c481 765 182 2.14e-16
c482 764 183 2.13e-16
c483 767 180 2.5e-16
c484 1845 217 2.14e-16
c485 100 184 3.24e-16
c486 94 186 1.99e-16
c487 218 219 3.76e-16
c488 0 211 2.5224e-14
c489 3 206 2.38e-16
c490 0 717 2.926e-15
c491 14 240 3.24e-16
c492 2279 243 2.5e-16
c493 164 37 3.31e-16
c494 2185 192 7.91e-16
c495 3 201 2.38e-16
c496 58 207 1.94e-16
c497 2700 0 1.65e-16
c498 122 8 1.485e-15
c499 0 1046 2.623e-15
c500 711 226 7.23e-16
c501 710 227 7.91e-16
c502 1 2505 1.354e-15
c503 58 202 3.34e-16
c504 48 193 3.31e-16
c505 52 191 3.24e-16
c506 234 142 3.34e-16
c507 235 136 1.99e-16
c508 900 193 8.32e-16
c509 901 192 7.76e-16
c510 1 353 1.6e-16
c511 803 802 6.77e-16
c512 0 1803 2.623e-15
c513 2336 183 2.186e-15
c514 1 1804 1.6e-16
c515 80 89 6.55e-16
c516 122 92 8.48e-16
c517 2734 2318 8.28e-16
c518 223 336 2.13e-16
c519 1814 203 7.91e-16
c520 1 699 1.6e-16
c521 878 879 6.77e-16
c522 0 2115 2.623e-15
c523 1966 204 7.91e-16
c524 1964 206 8.32e-16
c525 0 676 2.585e-15
c526 0 1170 2.957e-15
c527 1 2116 1.6e-16
c528 1030 194 2.8e-16
c529 8 31 2.3e-16
c530 0 1438 2.623e-15
c531 1 1011 1.6e-16
c532 1115 1114 6.77e-16
c533 0 495 2.957e-15
c534 0 988 2.585e-15
c535 1 2506 7.03e-16
c536 0 1433 2.623e-15
c537 968 224 2.13e-16
c538 1383 242 7.23e-16
c539 1382 243 7.91e-16
c540 63 241 1.9e-16
c541 2303 2293 4.77e-16
c542 1885 230 2.14e-16
c543 20 184 1.94e-16
c544 14 189 1.99e-16
c545 2543 2516 1.86e-16
c546 2592 2515 2.86e-16
c547 2625 2553 1.34e-16
c548 2320 2300 3.92e-16
c549 220 463 2.5e-16
c550 827 219 2.8e-16
c551 2820 2819 1.96e-16
c553 1 2259 1.6e-16
c554 438 439 6.77e-16
c555 0 1317 2.926e-15
c556 1 329 1.6e-16
c557 0 1745 2.623e-15
c558 1589 217 2.14e-16
c559 2253 0 2.926e-15
c560 2545 2517 3.08e-16
c561 8 94 2.3e-16
c562 2320 2314 1.244e-15
c563 230 84 3.31e-16
c564 2241 214 2.54e-16
c565 2655 2322 1.072e-15
c566 0 27 7.8194e-14
c567 0 1562 2.957e-15
c568 1185 1184 6.77e-16
c569 0 2072 2.957e-15
c570 8 2379 5.14e-16
c571 2587 2572 1.58e-16
c572 242 163 3.34e-16
c573 0 1397 2.926e-15
c574 750 751 6.77e-16
c575 1 953 1.6e-16
c576 1719 218 7.23e-16
c577 2492 2490 3.782e-15
c578 1260 1261 6.77e-16
c579 239 100 1.94e-16
c580 1 1894 1.6e-16
c581 0 275 2.623e-15
c582 92 94 3.92e-16
c583 2586 229 2.431e-15
c584 2588 230 1.114e-15
c585 508 509 6.77e-16
c586 2652 2651 7.84e-16
c587 633 184 7.91e-16
c588 241 105 1.9e-16
c589 1 276 1.6e-16
c590 0 1709 2.926e-15
c591 2196 2197 6.77e-16
c592 2639 2505 1.96e-16
c593 2030 237 2.8e-16
c594 2029 238 2.14e-16
c595 2028 239 2.13e-16
c596 2031 236 2.5e-16
c597 2305 2545 1.96e-16
c598 2647 2503 1.96e-16
c599 2364 2592 3.32e-16
c600 2312 2548 2.5e-16
c601 2358 2543 2.1e-16
c602 227 153 3.34e-16
c603 572 215 2.13e-16
c604 0 914 2.957e-15
c605 73 195 1.99e-16
c606 69 188 1.99e-16
c607 63 191 3.24e-16
c608 1 1345 1.6e-16
c609 2160 238 7.77e-16
c610 2162 236 7.23e-16
c611 2163 237 7.91e-16
c612 2407 2439 1.96e-16
c613 758 187 7.91e-16
c614 2471 2649 1.58e-16
c615 2665 2641 4.24e-16
c616 858 234 2.5e-16
c617 859 235 2.8e-16
c618 1270 186 2.8e-16
c619 712 224 2.13e-16
c620 1537 182 2.54e-16
c621 1539 180 2.8e-16
c622 2766 2786 5.24e-16
c623 0 551 2.957e-15
c624 205 153 1.99e-16
c625 2132 232 2.13e-16
c626 560 206 7.77e-16
c627 561 207 7.91e-16
c628 562 204 7.23e-16
c629 563 205 7.91e-16
c630 2318 2320 6.68e-16
c631 0 1061 2.926e-15
c632 1213 215 7.76e-16
c633 0 1489 2.623e-15
c634 1530 187 7.23e-16
c635 200 153 3.24e-16
c636 0 544 2.957e-15
c637 188 168 3.34e-16
c638 192 163 3.24e-16
c639 187 178 1.99e-16
c640 380 381 6.77e-16
c641 1 2003 1.6e-16
c642 2630 2608 2.86e-16
c643 1577 1576 6.77e-16
c644 241 142 3.31e-16
c645 242 136 1.99e-16
c646 0 1487 2.957e-15
c647 0 1980 2.585e-15
c648 59 61 2.17e-16
c649 101 73 1.58e-16
c650 20 239 3.24e-16
c651 0 856 2.957e-15
c652 121 186 3.34e-16
c653 115 182 3.31e-16
c654 105 191 3.24e-16
c655 2856 0 3.765e-15
c656 2719 2298 4.58e-16
c657 1 180 3.719e-15
c658 1200 207 2.13e-16
c659 1202 205 2.5e-16
c660 1673 192 7.91e-16
c661 0 2128 2.957e-15
c662 1 1638 1.6e-16
c663 2761 2351 2.98e-16
c664 0 1187 2.623e-15
c665 1 2670 2.88e-16
c666 27 243 3.34e-16
c667 1 1188 1.6e-16
c668 1 1633 1.6e-16
c669 1959 210 7.23e-16
c670 2429 2438 1.6e-16
c671 38 40 2.17e-16
c672 2572 0 3.7515e-14
c673 0 510 2.623e-15
c674 1 1950 1.6e-16
c675 2587 2556 1.58e-16
c676 233 472 7.77e-16
c677 1123 229 7.91e-16
c678 977 223 7.91e-16
c679 1892 241 8.32e-16
c680 164 111 3.31e-16
c681 2296 2835 2.07e-16
c682 224 325 7.76e-16
c683 1798 195 7.91e-16
c684 2777 0 1.96e-16
c685 2248 224 2.13e-16
c686 2298 2587 8.66e-16
c687 2338 2651 1.19e-15
c688 2389 2592 1.58e-16
c689 1 2781 7.07e-16
c690 234 602 2.5e-16
c691 235 603 2.8e-16
c692 1014 186 2.8e-16
c693 0 1579 2.623e-15
c694 1729 214 2.54e-16
c695 1935 189 7.23e-16
c696 1933 191 7.76e-16
c697 1 1580 1.6e-16
c698 2237 214 2.14e-16
c699 2645 2379 1.96e-16
c700 2364 2382 1.96e-16
c701 2466 210 2.339e-15
c702 142 191 1.94e-16
c703 136 192 1.94e-16
c704 1 475 1.6e-16
c705 0 1412 2.585e-15
c706 1103 221 7.23e-16
c707 1102 220 7.91e-16
c708 1428 201 8.32e-16
c709 1429 200 7.76e-16
c710 0 1906 2.957e-15
c711 0 288 2.957e-15
c712 229 178 3.34e-16
c713 1795 1794 6.77e-16
c714 419 418 6.77e-16
c715 1 787 1.6e-16
c716 1143 187 2.5e-16
c717 31 208 1.94e-16
c718 73 212 3.34e-16
c719 1242 235 7.23e-16
c720 1 1297 1.6e-16
c721 2340 0 2.0104e-14
c722 8 121 3.47e-16
c723 0 600 2.957e-15
c724 3 233 2.38e-16
c725 27 193 3.31e-16
c726 944 207 2.13e-16
c727 946 205 2.5e-16
c728 0 1543 2.957e-15
c729 1558 202 2.8e-16
c730 1 1099 1.6e-16
c731 0 2036 2.585e-15
c732 2069 201 2.14e-16
c733 2351 2510 3.7e-16
c734 58 234 3.34e-16
c735 1 422 1.6e-16
c736 1400 185 7.77e-16
c737 2107 2106 6.77e-16
c738 731 730 6.77e-16
c739 1703 210 7.23e-16
c740 48 223 1.94e-16
c741 1241 1240 6.77e-16
c742 215 163 1.94e-16
c743 237 115 3.34e-16
c744 100 206 1.9e-16
c745 94 208 1.94e-16
c746 84 209 1.9e-16
c747 79 219 3.34e-16
c748 2333 2329 6.13e-16
c749 489 488 6.77e-16
c750 228 354 7.23e-16
c751 867 229 7.91e-16
c752 0 1243 2.623e-15
c753 1 734 1.6e-16
c754 1 1244 1.6e-16
c755 0 2179 2.623e-15
c756 2177 2176 6.77e-16
c757 0 106 1.82e-16
c758 100 201 3.31e-16
c759 84 203 1.99e-16
c760 1636 241 8.32e-16
c761 1430 1431 6.77e-16
c762 0 566 2.623e-15
c763 571 218 7.91e-16
c764 1 2180 1.6e-16
c765 2637 2630 1.96e-16
c766 1 2717 3.13e-16
c767 80 29 2.44e-16
c768 564 565 6.77e-16
c769 1220 224 2.13e-16
c770 0 53 1.82e-16
c771 213 126 3.34e-16
c772 2318 2409 3.54e-16
c773 0 895 2.957e-15
c774 1480 225 7.77e-16
c775 1828 208 2.13e-16
c776 1985 215 7.91e-16
c777 0 363 2.623e-15
c778 0 873 2.623e-15
c779 1 2301 3.504e-15
c780 1742 1743 6.77e-16
c781 1 364 1.6e-16
c782 847 221 7.23e-16
c783 846 220 7.91e-16
c784 1210 218 2.5e-16
c785 0 1814 2.623e-15
c786 1470 213 2.8e-16
c787 2632 2620 3.22e-16
c788 0 2145 2.623e-15
c789 2298 0 6.2497e-14
c790 1 710 1.6e-16
c791 0 2126 2.623e-15
c792 1618 220 7.23e-16
c793 2660 0 1.65e-16
c794 2740 2746 7.4e-16
c795 0 525 2.926e-15
c796 2112 214 7.77e-16
c797 361 360 6.77e-16
c798 373 184 7.76e-16
c799 372 185 8.32e-16
c800 1041 191 7.91e-16
c801 1 2627 1.354e-15
c802 1 1022 1.6e-16
c803 2111 213 7.23e-16
c804 2110 212 7.91e-16
c805 20 206 3.31e-16
c806 0 837 2.926e-15
c807 215 136 3.24e-16
c808 1812 1813 6.77e-16
c809 2855 2822 1.96e-16
c810 2687 2688 1.6e-16
c811 973 223 7.76e-16
c812 1 2784 1.863e-15
c813 2302 2314 1.38e-16
c814 20 201 1.9e-16
c815 2585 2559 7.44e-16
c816 2625 2557 2.6e-16
c817 1 1779 1.6e-16
c818 2409 2345 1.28e-16
c819 2851 2298 4.92e-16
c820 1 2270 1.6e-16
c821 2637 8 4.03e-16
c822 2655 2592 1.96e-16
c823 2343 2590 3.53e-16
c824 2647 2335 1.96e-16
c825 2645 2384 1.96e-16
c826 0 1149 2.926e-15
c827 707 706 6.77e-16
c828 0 1592 2.957e-15
c829 1113 233 2.54e-16
c830 2322 191 7.64e-16
c831 2296 2409 1.58e-16
c832 1 2091 1.6e-16
c833 2299 2609 1.196e-15
c834 2124 2125 6.77e-16
c835 1927 195 2.5e-16
c836 2592 2574 4.48e-16
c837 0 305 2.623e-15
c838 2299 2350 1.496e-15
c839 311 219 2.5e-16
c840 2508 2485 1.58e-16
c841 811 210 7.91e-16
c842 1019 1018 6.77e-16
c843 73 221 3.34e-16
c844 1572 208 2.13e-16
c845 1875 221 7.91e-16
c846 2234 219 7.23e-16
c847 2465 2433 6.99e-16
c848 2503 2474 5.81e-16
c849 2462 2443 1.58e-16
c850 1 1726 1.6e-16
c851 2779 59 1.673e-15
c852 38 2810 2.91e-16
c853 0 617 2.623e-15
c854 2637 2425 1.96e-16
c855 2343 2422 1.96e-16
c856 2299 2505 1.135e-15
c857 1 2643 1.695e-15
c858 1093 225 2.14e-16
c859 2312 2465 1.96e-16
c860 2358 2460 3.54e-16
c861 2643 2467 1.96e-16
c862 2305 2462 2.12e-16
c863 58 241 3.31e-16
c864 0 434 2.957e-15
c865 342 343 6.77e-16
c866 0 929 2.623e-15
c867 938 211 7.23e-16
c868 1412 193 8.32e-16
c869 1413 192 7.76e-16
c870 73 218 1.99e-16
c871 0 1870 2.623e-15
c872 1354 226 2.5e-16
c873 0 252 2.585e-15
c874 0 927 2.957e-15
c875 579 578 6.77e-16
c876 0 746 2.957e-15
c877 784 190 7.77e-16
c878 785 191 7.91e-16
c879 786 188 7.23e-16
c880 787 189 7.91e-16
c881 2471 2761 1.96e-16
c882 243 363 2.8e-16
c883 242 362 2.5e-16
c884 0 1355 2.623e-15
c885 0 1256 2.957e-15
c886 2267 2266 6.77e-16
c887 1855 213 7.23e-16
c888 1854 212 7.91e-16
c889 2192 0 2.957e-15
c890 2382 2375 5.82e-16
c891 2318 2302 2.39e-16
c892 2574 2472 2.74e-16
c893 2800 2786 1.96e-16
c894 2760 2758 1.58e-16
c895 2665 2364 3.54e-16
c896 2709 2351 4.55e-16
c897 0 581 2.926e-15
c898 226 115 1.99e-16
c899 2030 2031 6.77e-16
c900 654 655 6.77e-16
c901 717 223 7.76e-16
c902 1081 216 7.91e-16
c903 1851 1850 6.77e-16
c904 1542 194 2.8e-16
c905 0 2175 2.957e-15
c906 1 1078 1.6e-16
c907 2041 185 2.54e-16
c908 2040 184 2.13e-16
c909 219 157 1.99e-16
c910 1 1523 1.6e-16
c911 210 178 1.99e-16
c912 220 132 1.99e-16
c913 222 126 3.31e-16
c914 8 2630 2.83e-16
c915 2639 2627 1.96e-16
c916 2627 240 3.73e-16
c917 1 153 7.6e-16
c918 1 563 1.6e-16
c919 0 1500 2.585e-15
c920 2827 2654 1.58e-16
c921 1 1073 1.6e-16
c922 2362 2348 1.6e-16
c923 195 174 3.34e-16
c924 1 2014 1.6e-16
c925 0 376 2.957e-15
c926 208 121 3.24e-16
c927 204 115 3.34e-16
c928 90 194 3.34e-16
c929 1 1835 1.6e-16
c930 966 967 6.77e-16
c931 2163 2162 6.77e-16
c932 0 195 2.5241e-14
c933 3 190 2.38e-16
c934 217 126 1.9e-16
c935 115 199 3.24e-16
c936 1 1668 1.6e-16
c937 2655 2382 1.96e-16
c938 2462 206 1.7e-16
c939 1 197 3.749e-15
c940 1206 219 7.91e-16
c941 1 2691 2.88e-16
c942 0 2141 2.926e-15
c943 58 191 1.94e-16
c944 48 182 1.9e-16
c945 52 180 3.34e-16
c946 2683 0 1.65e-16
c947 2420 196 8.84e-16
c948 2121 225 2.54e-16
c949 1051 202 7.91e-16
c950 1054 196 7.91e-16
c951 1052 198 8.32e-16
c952 1 2548 1.989e-15
c953 1 2546 7.03e-16
c954 1 1465 1.6e-16
c955 2331 185 3.61e-16
c956 230 477 2.14e-16
c957 220 147 3.34e-16
c959 0 1331 2.623e-15
c960 1723 1722 6.77e-16
c961 1036 1037 6.77e-16
c962 1 1332 1.6e-16
c963 2296 2302 1.96e-16
c964 2592 2567 1.32e-16
c965 101 0 2.5863e-14
c966 1481 1480 6.77e-16
c967 122 120 6.74e-16
c968 0 671 2.957e-15
c969 2649 2318 1.96e-16
c970 2637 2645 5.88e-16
c971 2639 2643 9.12e-16
c972 2343 2364 7.84e-16
c973 0 1164 2.585e-15
c974 1 2804 2.84e-16
c975 0 1609 2.623e-15
c976 31 235 1.99e-16
c977 1745 223 7.91e-16
c978 2253 223 7.76e-16
c979 2298 2543 1.58e-16
c980 0 148 1.82e-16
c981 0 983 2.957e-15
c982 607 229 7.23e-16
c983 606 228 7.91e-16
c984 0 1426 2.957e-15
c985 27 223 1.94e-16
c987 1321 208 7.91e-16
c988 746 243 7.23e-16
c989 1 817 1.6e-16
c990 0 1738 2.957e-15
c991 1370 234 2.5e-16
c992 1371 235 2.8e-16
c993 1782 186 2.8e-16
c994 2284 2285 6.77e-16
c995 1259 242 7.91e-16
c996 15 16 4.11e-16
c997 8 92 1.96e-16
c998 233 100 3.31e-16
c999 235 94 1.99e-16
c1000 230 79 1.9e-16
c1001 42 211 1.99e-16
c1002 37 219 3.34e-16
c1003 0 1556 2.585e-15
c1004 1868 1869 6.77e-16
c1005 1247 228 2.5e-16
c1006 1 1129 1.6e-16
c1007 1918 180 7.91e-16
c1008 1916 182 8.32e-16
c1009 0 613 2.926e-15
c1010 1 2070 1.6e-16
c1011 0 451 2.623e-15
c1012 240 153 3.24e-16
c1013 302 204 7.91e-16
c1014 950 219 7.91e-16
c1015 1 452 1.6e-16
c1016 0 1885 2.926e-15
c1017 1353 1352 6.77e-16
c1018 1865 225 2.54e-16
c1019 2225 206 2.54e-16
c1020 2227 204 2.8e-16
c1021 2591 234 2.339e-15
c1022 2384 2376 6.67e-16
c1023 90 87 3.92e-16
c1024 164 14 3.31e-16
c1025 0 763 2.623e-15
c1026 798 196 7.91e-16
c1027 796 198 8.32e-16
c1028 2784 2776 1.96e-16
c1029 2764 2788 1.213e-15
c1030 0 1368 2.957e-15
c1031 0 1273 2.623e-15
c1032 1 764 1.6e-16
c1033 1351 227 2.5e-16
c1034 1712 207 2.13e-16
c1035 1714 205 2.5e-16
c1036 0 84 7.793e-14
c1037 1862 226 2.8e-16
c1038 212 174 1.99e-16
c1039 2508 2430 1.09e-16
c1040 2773 2777 6.61e-16
c1041 2296 2649 1.58e-16
c1042 0 1254 2.623e-15
c1043 214 90 1.9e-16
c1044 1 249 1.6e-16
c1045 0 2190 2.623e-15
c1046 48 237 1.99e-16
c1047 2052 192 2.13e-16
c1048 2726 0 1.65e-16
c1049 0 212 2.5381e-14
c1050 2645 2630 1.96e-16
c1051 2639 2548 1.96e-16
c1052 73 185 1.9e-16
c1053 63 180 3.34e-16
c1054 0 2026 2.957e-15
c1055 1489 223 7.91e-16
c1056 0 393 2.623e-15
c1057 2389 2343 1.327e-15
c1058 2655 2333 1.96e-16
c1059 853 233 2.14e-16
c1060 1 907 1.6e-16
c1061 1 2823 6.883e-15
c1062 1485 222 2.14e-16
c1063 20 233 1.9e-16
c1064 2274 229 2.5e-16
c1065 2275 228 2.8e-16
c1066 2761 2758 1.58e-16
c1067 1 2336 7.03e-16
c1068 552 209 7.77e-16
c1069 2637 2407 1.58e-16
c1070 2011 2010 6.77e-16
c1071 635 634 6.77e-16
c1072 1065 208 7.91e-16
c1073 0 1663 2.957e-15
c1074 1 1219 1.6e-16
c1075 1526 186 2.8e-16
c1076 0 2156 2.585e-15
c1077 189 153 1.99e-16
c1078 181 163 1.99e-16
c1079 2128 223 2.13e-16
c1080 0 1032 2.957e-15
c1081 707 213 7.91e-16
c1082 1 542 1.6e-16
c1083 0 1975 2.957e-15
c1084 1978 218 2.5e-16
c1085 105 180 3.34e-16
c1086 2697 2665 1.58e-16
c1087 2823 2845 1.96e-16
c1088 468 469 6.77e-16
c1089 143 73 3.26e-16
c1090 1 854 1.6e-16
c1091 2280 0 2.957e-15
c1092 2574 2604 1.96e-16
c1093 186 132 3.34e-16
c1094 184 126 1.94e-16
c1095 1754 235 7.23e-16
c1096 15 0 1.0683e-14
c1097 0 686 2.623e-15
c1098 1 17 2.79e-16
c1099 498 236 7.23e-16
c1100 499 237 7.91e-16
c1101 1190 211 7.91e-16
c1102 1 25 5.27e-16
c1103 1129 240 7.91e-16
c1104 1456 207 2.13e-16
c1105 1458 205 2.5e-16
c1106 31 242 1.99e-16
c1107 1606 226 2.8e-16
c1108 2645 8 3.54e-16
c1109 2294 2590 3.02e-16
c1110 2312 2351 4.221e-15
c1111 2358 2651 1.176e-15
c1112 164 169 1.34e-16
c1113 1646 1647 6.77e-16
c1114 0 998 2.623e-15
c1115 242 614 2.8e-16
c1116 232 468 2.13e-16
c1117 1116 230 8.32e-16
c1118 780 781 6.77e-16
c1119 1323 211 2.8e-16
c1120 1327 205 7.23e-16
c1121 1325 207 7.76e-16
c1122 1952 199 2.13e-16
c1123 1954 197 2.5e-16
c1124 2501 217 3.61e-16
c1125 2508 2490 1.58e-16
c1126 1 1923 1.6e-16
c1127 2655 2665 3.54e-16
c1128 1379 229 7.91e-16
c1129 73 231 3.24e-16
c1130 0 1755 2.623e-15
c1131 1881 233 2.54e-16
c1132 0 316 2.585e-15
c1133 2510 2502 6.67e-16
c1134 265 264 6.77e-16
c1135 1 1756 1.6e-16
c1136 2763 0 1.196e-15
c1137 0 810 2.957e-15
c1138 242 94 1.99e-16
c1139 243 84 1.99e-16
c1140 514 180 7.23e-16
c1141 1162 195 7.23e-16
c1142 1 2766 1.0136e-14
c1143 1958 1959 6.77e-16
c1144 1255 242 7.23e-16
c1145 1254 243 7.91e-16
c1146 1092 1093 6.77e-16
c1147 0 628 2.585e-15
c1148 2643 2427 1.96e-16
c1149 2294 2422 1.96e-16
c1150 2645 2425 1.96e-16
c1151 0 464 2.957e-15
c1152 147 186 1.99e-16
c1153 142 180 1.99e-16
c1154 136 181 3.34e-16
c1155 0 1122 2.957e-15
c1156 1537 1536 6.77e-16
c1157 0 1407 2.957e-15
c1158 0 1900 2.585e-15
c1159 0 447 2.957e-15
c1160 1329 1328 6.77e-16
c1161 2026 243 7.23e-16
c1162 8 155 1.96e-16
c1163 230 157 3.31e-16
c1164 0 940 2.585e-15
c1165 295 210 7.23e-16
c1166 2697 2343 1.96e-16
c1167 2675 2637 1.96e-16
c1168 0 1385 2.623e-15
c1169 1 286 1.6e-16
c1170 1305 200 7.91e-16
c1171 1359 221 7.23e-16
c1172 1358 220 7.91e-16
c1173 2218 210 2.5e-16
c1174 2222 205 2.8e-16
c1175 2221 206 2.14e-16
c1176 2220 207 2.13e-16
c1177 2223 204 2.5e-16
c1178 2384 2372 3.22e-16
c1179 221 174 1.99e-16
c1180 0 759 2.957e-15
c1181 2728 0 1.65e-16
c1182 791 202 7.23e-16
c1183 235 121 3.34e-16
c1184 232 115 1.94e-16
c1185 0 1269 2.926e-15
c1186 1 2211 1.6e-16
c1187 27 182 1.9e-16
c1188 31 192 1.94e-16
c1189 0 1697 2.623e-15
c1190 1 598 1.6e-16
c1191 2205 0 2.926e-15
c1192 8 132 3.47e-16
c1193 236 163 1.99e-16
c1194 0 221 2.3961e-14
c1195 2299 2627 4.18e-16
c1196 1 593 1.6e-16
c1197 1 1534 1.6e-16
c1198 218 174 3.34e-16
c1199 2358 2585 2.15e-16
c1200 48 226 3.34e-16
c1201 90 216 3.24e-16
c1202 79 209 3.31e-16
c1203 269 191 7.76e-16
c1204 271 189 7.23e-16
c1205 1 176 2.79e-16
c1206 2655 2343 1.334e-15
c1207 2687 2637 3.54e-16
c1208 239 126 3.24e-16
c1209 219 111 3.34e-16
c1210 100 190 1.9e-16
c1211 94 192 1.94e-16
c1212 84 193 1.9e-16
c1213 79 203 3.34e-16
c1214 1 1846 1.6e-16
c1215 0 218 2.3954e-14
c1216 2333 2304 7.17e-16
c1217 2283 242 7.91e-16
c1218 564 217 8.32e-16
c1219 565 216 7.76e-16
c1220 2641 2587 1.96e-16
c1221 1 103 2.79e-16
c1222 0 1678 2.623e-15
c1223 1235 1234 6.77e-16
c1224 48 204 1.99e-16
c1225 2702 0 1.65e-16
c1226 2379 192 3.73e-16
c1227 2637 2492 3.54e-16
c1228 2343 2574 9.78e-16
c1229 0 1049 2.623e-15
c1230 1 2465 1.25e-15
c1231 999 242 7.23e-16
c1232 998 243 7.91e-16
c1233 48 199 1.94e-16
c1234 52 197 3.34e-16
c1235 0 1990 2.623e-15
c1236 1476 224 2.13e-16
c1237 2124 222 8.32e-16
c1238 1310 1311 6.77e-16
c1239 2305 2469 1.96e-16
c1240 392 192 2.13e-16
c1241 393 193 2.54e-16
c1242 8 147 2.3e-16
c1243 0 866 2.957e-15
c1244 2827 2861 1.96e-16
c1245 2697 2854 1.58e-16
c1246 2246 2247 6.77e-16
c1247 2625 2599 8.84e-16
c1248 2841 0 7.667e-15
c1249 0 701 2.926e-15
c1250 2263 234 7.23e-16
c1251 2262 235 7.91e-16
c1252 2733 2312 1.802e-15
c1253 2734 2305 1.069e-15
c1254 842 227 7.23e-16
c1255 2559 2552 1.38e-16
c1256 2364 2294 1.138e-15
c1257 2298 2460 1.58e-16
c1258 495 237 7.23e-16
c1259 493 239 7.76e-16
c1260 535 202 7.23e-16
c1261 136 236 3.34e-16
c1262 2425 2407 1.58e-16
c1263 0 1013 2.926e-15
c1264 1032 193 7.77e-16
c1265 1 2642 2.88e-16
c1266 870 871 6.77e-16
c1267 0 1441 2.623e-15
c1268 1450 211 7.23e-16
c1269 37 230 1.9e-16
c1270 2067 2066 6.77e-16
c1271 59 55 4.22e-16
c1272 0 496 2.957e-15
c1273 449 448 6.77e-16
c1274 1 337 1.6e-16
c1275 1107 1106 6.77e-16
c1276 1946 203 7.23e-16
c1277 0 1768 2.957e-15
c1278 2261 0 2.926e-15
c1279 1888 231 2.13e-16
c1280 20 190 3.31e-16
c1281 2550 2526 4.98e-16
c1282 2625 2563 1.34e-16
c1283 0 827 2.623e-15
c1284 1390 1391 6.77e-16
c1285 215 321 7.91e-16
c1286 27 237 1.99e-16
c1287 0 1751 2.957e-15
c1288 1 649 1.6e-16
c1289 1593 216 7.91e-16
c1290 0 2080 2.957e-15
c1291 1 1590 1.6e-16
c1292 660 200 2.13e-16
c1293 2634 2625 3.92e-16
c1294 430 431 6.77e-16
c1295 507 187 2.8e-16
c1296 511 181 7.23e-16
c1297 509 183 7.76e-16
c1298 0 1139 2.623e-15
c1299 31 215 3.24e-16
c1300 1 1140 1.6e-16
c1301 1 961 1.6e-16
c1302 0 462 2.623e-15
c1303 2676 2574 3.05e-16
c1304 804 209 8.32e-16
c1305 805 208 7.76e-16
c1306 214 448 7.77e-16
c1307 1702 1703 6.77e-16
c1308 1868 222 8.32e-16
c1309 1 1897 1.6e-16
c1310 2230 218 2.8e-16
c1311 122 9 7.01e-16
c1312 2503 2475 6.24e-16
c1313 2465 2434 4.09e-16
c1314 2462 2444 4.17e-16
c1315 0 774 2.623e-15
c1316 2641 0 3.8808e-14
c1317 2296 2761 8.64e-16
c1318 2675 8 1.891e-15
c1319 2773 101 8.73e-16
c1320 2654 2635 1.96e-16
c1321 242 121 3.34e-16
c1322 742 743 6.77e-16
c1323 0 1284 2.585e-15
c1324 1939 1938 6.77e-16
c1325 1252 1253 6.77e-16
c1326 215 94 3.24e-16
c1327 2639 2465 1.96e-16
c1328 2318 2510 2.83e-16
c1329 2299 2548 6.19e-16
c1330 227 586 7.23e-16
c1331 934 210 2.8e-16
c1332 2188 2189 6.77e-16
c1333 73 207 3.24e-16
c1334 2358 2503 1.96e-16
c1335 2007 234 7.23e-16
c1336 2006 235 7.91e-16
c1337 225 163 3.31e-16
c1338 1772 1773 6.77e-16
c1339 241 357 2.14e-16
c1340 73 202 1.99e-16
c1341 63 197 3.34e-16
c1342 869 240 7.76e-16
c1343 1289 192 7.91e-16
c1344 0 1858 2.957e-15
c1345 263 195 2.5e-16
c1346 2687 8 1.96e-16
c1347 2389 2294 1.464e-15
c1348 2471 2312 3.54e-16
c1349 1 2383 7.03e-16
c1350 38 36 6.74e-16
c1351 1690 203 7.23e-16
c1352 209 157 1.9e-16
c1353 2758 2786 1.58e-16
c1354 0 552 2.957e-15
c1355 2645 2407 1.58e-16
c1356 0 1495 2.957e-15
c1357 0 2005 2.926e-15
c1358 2084 2085 6.77e-16
c1359 203 157 1.99e-16
c1360 2349 2342 4.77e-16
c1361 198 163 1.9e-16
c1362 194 178 1.99e-16
c1363 185 174 3.31e-16
c1364 2651 2572 3.54e-16
c1365 404 200 2.13e-16
c1366 90 183 1.94e-16
c1367 0 883 2.623e-15
c1368 1 374 1.6e-16
c1369 122 69 1.58e-16
c1370 1 884 1.6e-16
c1371 2296 2348 1.96e-16
c1372 1771 242 7.91e-16
c1373 2176 183 2.13e-16
c1374 2178 181 2.5e-16
c1375 0 185 2.4546e-14
c1376 208 132 3.24e-16
c1377 121 192 3.24e-16
c1378 206 126 3.31e-16
c1379 115 188 3.34e-16
c1380 105 197 3.34e-16
c1381 2687 2425 3.92e-16
c1382 0 1195 2.623e-15
c1383 1 1196 1.6e-16
c1384 1759 228 2.5e-16
c1385 201 126 1.9e-16
c1386 202 203 3.76e-16
c1387 1 1641 1.6e-16
c1388 58 180 1.99e-16
c1389 2296 2510 3.34e-16
c1390 302 303 6.77e-16
c1391 1044 201 8.32e-16
c1392 1045 200 7.76e-16
c1393 1462 219 7.91e-16
c1394 0 513 2.623e-15
c1395 2721 2409 1.47e-16
c1396 1 1953 1.6e-16
c1397 539 538 6.77e-16
c1398 225 136 1.9e-16
c1399 0 1785 2.623e-15
c1400 2227 2226 6.77e-16
c1401 1897 240 7.91e-16
c1402 122 108 7.01e-16
c1403 0 1159 2.957e-15
c1404 1 2800 3.53e-16
c1405 0 1766 2.623e-15
c1406 0 1602 2.957e-15
c1407 0 2097 2.623e-15
c1408 2103 219 2.5e-16
c1409 143 0 2.3594e-14
c1410 2322 2301 3.92e-16
c1411 143 113 3.31e-16
c1412 0 642 2.957e-15
c1413 2340 2651 5.5e-16
c1414 215 317 7.76e-16
c1415 519 194 7.23e-16
c1416 147 208 1.94e-16
c1417 1016 185 7.77e-16
c1418 1880 1881 6.77e-16
c1419 1 483 1.6e-16
c1420 851 850 6.77e-16
c1421 27 226 3.34e-16
c1422 1904 239 2.13e-16
c1423 1906 237 2.5e-16
c1424 1937 190 2.54e-16
c1425 1939 188 2.8e-16
c1426 0 477 2.926e-15
c1427 142 197 1.99e-16
c1428 136 198 3.31e-16
c1429 2587 2515 1.24e-16
c1430 225 457 2.54e-16
c1431 2832 2835 6.67e-16
c1432 1365 233 2.14e-16
c1433 1 1419 1.6e-16
c1434 8 171 1.96e-16
c1435 1 1305 1.6e-16
c1436 2585 2572 1.58e-16
c1437 231 174 1.94e-16
c1438 15 12 1.34e-16
c1439 0 789 2.926e-15
c1440 38 2779 1.58e-16
c1441 2675 2645 1.96e-16
c1442 2697 2294 1.96e-16
c1443 1 2241 1.6e-16
c1444 684 685 6.77e-16
c1445 1146 186 2.5e-16
c1446 1150 181 2.8e-16
c1447 1149 182 2.14e-16
c1448 1148 183 2.13e-16
c1449 1151 180 2.5e-16
c1450 37 209 3.31e-16
c1451 27 204 1.99e-16
c1452 2590 0 2.4066e-14
c1453 230 111 1.9e-16
c1454 223 84 3.24e-16
c1455 1 2222 1.6e-16
c1456 0 231 2.605e-14
c1457 0 1101 2.926e-15
c1458 42 195 1.99e-16
c1459 37 203 3.34e-16
c1460 27 199 1.94e-16
c1461 1 2351 1.06e-16
c1462 921 920 6.77e-16
c1463 0 1544 2.957e-15
c1464 1560 201 7.77e-16
c1465 1 228 3.719e-15
c1466 2073 200 7.91e-16
c1467 2635 2420 1.96e-16
c1468 2351 2467 1.96e-16
c1469 48 232 3.24e-16
c1470 1 2043 1.6e-16
c1471 90 238 1.9e-16
c1472 2562 229 2.07e-16
c1473 1862 1863 6.77e-16
c1474 2784 164 1.386e-15
c1475 1 425 1.6e-16
c1476 1086 213 2.8e-16
c1477 996 997 6.77e-16
c1478 1 1366 1.6e-16
c1479 2424 201 1.207e-15
c1480 0 79 7.8194e-14
c1481 214 178 3.31e-16
c1482 2574 2477 2.19e-16
c1483 2425 2403 1.7e-16
c1484 2764 2769 1.96e-16
c1485 2687 2645 3.54e-16
c1486 2655 2294 1.634e-15
c1487 2709 2318 3.54e-16
c1488 1 2397 1.424e-15
c1489 1284 193 8.32e-16
c1490 1285 192 7.76e-16
c1491 1 737 1.6e-16
c1492 2409 2443 3.92e-16
c1493 2467 2397 3.93e-16
c1494 1641 240 7.91e-16
c1495 2422 0 1.9851e-14
c1496 0 569 2.623e-15
c1497 215 121 1.94e-16
c1498 2364 2587 2.12e-16
c1499 2641 2543 1.96e-16
c1500 80 37 1.59e-16
c1501 101 42 1.58e-16
c1502 59 34 2.44e-16
c1503 0 1510 2.623e-15
c1504 2169 2168 6.77e-16
c1505 0 2020 2.585e-15
c1506 2294 2574 3.54e-16
c1507 2305 2409 3.54e-16
c1508 2645 2492 3.54e-16
c1509 2647 2490 1.58e-16
c1510 0 386 2.957e-15
c1511 1 40 2.79e-16
c1512 252 182 8.32e-16
c1513 254 180 7.91e-16
c1514 556 557 6.77e-16
c1515 0 896 2.957e-15
c1516 1753 1752 6.77e-16
c1517 0 1822 2.623e-15
c1518 2380 191 2.186e-15
c1519 2539 220 1.54e-16
c1520 235 346 7.23e-16
c1521 0 1208 2.957e-15
c1522 1767 242 7.23e-16
c1523 1766 243 7.91e-16
c1524 0 2151 2.957e-15
c1525 2170 187 7.23e-16
c1526 1621 232 7.76e-16
c1527 0 533 2.926e-15
c1528 700 214 8.32e-16
c1529 1 1030 1.6e-16
c1530 1973 217 2.14e-16
c1531 1 1475 1.6e-16
c1532 544 199 2.13e-16
c1533 546 197 2.5e-16
c1534 2490 225 5.06e-16
c1535 0 845 2.926e-15
c1536 0 1452 2.585e-15
c1537 2719 2389 1.58e-16
c1538 2697 2825 1.58e-16
c1539 0 1946 2.957e-15
c1540 22 0 1.82e-16
c1541 14 219 3.34e-16
c1542 0 347 2.623e-15
c1543 2585 2556 1.58e-16
c1544 2632 2566 1.9e-16
c1545 2787 0 1.4895e-14
c1546 2854 2842 3.61e-16
c1547 1 2278 1.6e-16
c1548 1 348 1.6e-16
c1549 830 213 2.8e-16
c1550 0 1781 2.926e-15
c1551 0 1619 2.623e-15
c1552 1 1620 1.6e-16
c1553 0 659 2.623e-15
c1554 2639 2351 1.372e-15
c1555 164 153 3.31e-16
c1556 1 660 1.6e-16
c1557 0 2093 2.926e-15
c1558 2298 2585 5.5e-16
c1559 0 971 2.623e-15
c1560 223 464 2.13e-16
c1561 42 212 3.34e-16
c1562 1 972 1.6e-16
c1563 1930 194 2.5e-16
c1564 1372 230 8.32e-16
c1565 73 234 1.99e-16
c1566 2298 2512 1.96e-16
c1567 2550 2490 2.59e-16
c1568 314 218 2.5e-16
c1569 0 311 2.957e-15
c1570 0 804 2.585e-15
c1571 243 79 3.34e-16
c1572 2389 2587 7.52e-16
c1573 956 215 2.13e-16
c1574 1158 194 2.8e-16
c1575 1 2733 7.06e-16
c1576 69 220 1.99e-16
c1577 2234 0 2.957e-15
c1578 1 1729 1.6e-16
c1579 2364 0 8.8637e-14
c1580 0 623 2.957e-15
c1581 2299 2465 3.55e-16
c1582 0 1116 2.585e-15
c1583 1096 224 2.13e-16
c1584 1511 242 7.23e-16
c1585 1510 243 7.91e-16
c1586 591 220 2.5e-16
c1587 0 935 2.957e-15
c1588 0 1378 2.957e-15
c1589 1086 1087 6.77e-16
c1590 0 1873 2.623e-15
c1591 2213 209 2.14e-16
c1592 220 168 3.34e-16
c1593 1531 1530 6.77e-16
c1594 290 197 2.5e-16
c1595 288 199 2.13e-16
c1596 227 90 3.34e-16
c1597 1 259 1.6e-16
c1598 665 664 6.77e-16
c1599 0 1690 2.957e-15
c1600 31 181 3.34e-16
c1601 1346 213 2.5e-16
c1602 1347 212 2.8e-16
c1603 2151 243 2.5e-16
c1604 3 224 3.08e-16
c1605 235 132 3.34e-16
c1606 233 126 1.9e-16
c1607 1606 1607 6.77e-16
c1608 0 1525 2.926e-15
c1609 1544 193 7.77e-16
c1610 1 1081 1.6e-16
c1611 0 157 7.793e-14
c1612 216 178 1.94e-16
c1613 207 174 1.94e-16
c1614 0 403 2.623e-15
c1615 646 647 6.77e-16
c1616 90 205 1.99e-16
c1617 1843 1842 6.77e-16
c1618 2697 2719 1.58e-16
c1619 1 404 1.6e-16
c1620 0 1837 2.926e-15
c1621 2348 2360 1.38e-16
c1622 202 174 3.34e-16
c1623 977 976 6.77e-16
c1624 0 207 2.6044e-14
c1625 0 894 2.623e-15
c1626 209 111 3.31e-16
c1627 94 181 3.34e-16
c1628 90 200 3.24e-16
c1629 84 182 3.31e-16
c1630 79 193 3.31e-16
c1631 216 217 2e-16
c1632 247 186 7.23e-16
c1633 105 103 3.92e-16
c1634 0 715 2.623e-15
c1635 2276 241 8.32e-16
c1636 0 1225 2.623e-15
c1637 1 716 1.6e-16
c1638 2182 195 7.91e-16
c1639 0 202 2.3912e-14
c1640 3 196 3.48e-16
c1641 111 203 3.34e-16
c1642 0 1206 2.623e-15
c1643 1676 1677 6.77e-16
c1644 709 224 7.76e-16
c1645 0 1042 2.957e-15
c1646 0 1651 2.623e-15
c1647 58 197 1.99e-16
c1648 48 188 1.99e-16
c1649 2299 2436 1.496e-15
c1650 1913 1912 6.77e-16
c1651 235 147 1.99e-16
c1652 2654 2820 1.58e-16
c1653 2697 2849 4.15e-16
c1654 2675 2687 1.081e-15
c1655 2719 2655 3.55e-16
c1656 986 234 2.5e-16
c1657 987 235 2.8e-16
c1658 0 1963 2.623e-15
c1659 2290 0 2.957e-15
c1660 2625 2605 1.34e-16
c1661 2389 0 6.4738e-14
c1662 699 219 2.8e-16
c1663 220 335 2.5e-16
c1664 0 1796 2.585e-15
c1665 1988 1989 6.77e-16
c1666 1 2471 1.817e-15
c1667 1812 201 8.32e-16
c1668 1813 200 7.76e-16
c1669 1658 187 7.23e-16
c1670 0 672 2.957e-15
c1671 2258 220 7.23e-16
c1672 2744 2358 6.4e-16
c1673 2318 2312 1.314e-15
c1674 2675 2492 2.261e-15
c1675 2665 2505 3.92e-16
c1676 1 2810 2.88e-16
c1677 0 1615 2.957e-15
c1678 1 1171 1.6e-16
c1679 1446 210 2.8e-16
c1680 0 2108 2.585e-15
c1681 27 232 3.24e-16
c1682 2298 2503 1.82e-16
c1683 2509 218 2.339e-15
c1684 528 191 2.13e-16
c1685 530 189 2.5e-16
c1686 0 984 2.957e-15
c1687 1 494 1.6e-16
c1688 42 221 3.34e-16
c1689 967 227 2.5e-16
c1690 1942 202 2.8e-16
c1691 1381 240 7.76e-16
c1692 73 241 1.9e-16
c1693 0 326 2.623e-15
c1694 1548 1549 6.77e-16
c1695 222 460 8.32e-16
c1696 825 217 2.54e-16
c1697 824 216 2.13e-16
c1698 0 1315 2.623e-15
c1699 31 236 3.34e-16
c1700 1 1316 1.6e-16
c1701 2251 0 2.623e-15
c1702 2543 2527 6.29e-16
c1703 2087 210 7.23e-16
c1704 1 2252 1.6e-16
c1705 2634 2640 1.6e-16
c1706 0 37 7.8194e-14
c1707 738 228 7.23e-16
c1708 42 218 1.99e-16
c1709 1251 229 7.91e-16
c1710 1 1563 1.6e-16
c1711 2351 2427 1.96e-16
c1712 2635 2377 1.96e-16
c1713 1 2073 1.6e-16
c1714 2587 2574 1.58e-16
c1715 243 157 1.99e-16
c1716 0 950 2.623e-15
c1717 955 218 7.91e-16
c1718 518 519 6.77e-16
c1719 0 1395 2.623e-15
c1720 1 1396 1.6e-16
c1721 52 228 3.34e-16
c1722 236 94 3.34e-16
c1723 237 84 3.34e-16
c1724 164 17 4.85e-16
c1725 1 2426 7.03e-16
c1726 0 1279 2.957e-15
c1728 0 1707 2.623e-15
c1729 1355 226 7.91e-16
c1730 2490 2474 3.92e-16
c1731 2425 2391 5.75e-16
c1732 282 203 7.23e-16
c1733 2422 2401 4.14e-16
c1734 1 1708 1.6e-16
c1735 2773 143 5.5e-16
c1736 2296 2312 9.15e-16
c1737 242 132 3.34e-16
c1738 2641 2460 1.96e-16
c1739 2343 2505 2.81e-16
c1740 2637 2508 1.96e-16
c1741 435 205 7.91e-16
c1742 434 204 7.23e-16
c1743 433 207 7.91e-16
c1744 432 206 7.77e-16
c1745 830 831 6.77e-16
c1746 0 580 2.585e-15
c1747 2643 2592 1.96e-16
c1748 2364 2543 1.96e-16
c1749 928 198 7.77e-16
c1750 929 199 7.91e-16
c1751 930 196 7.23e-16
c1752 931 197 7.91e-16
c1753 0 1342 2.623e-15
c1754 69 186 3.34e-16
c1755 73 191 3.24e-16
c1756 1 915 1.6e-16
c1757 0 1852 2.585e-15
c1758 2002 220 7.23e-16
c1759 0 399 2.957e-15
c1760 0 909 2.926e-15
c1761 2697 0 3.2515e-14
c1762 756 185 8.32e-16
c1763 757 184 7.76e-16
c1764 2798 2757 1.58e-16
c1765 2471 2639 4.83e-16
c1766 2333 180 8.84e-16
c1767 825 824 6.77e-16
c1768 856 232 2.13e-16
c1769 1074 205 2.5e-16
c1770 1686 202 2.8e-16
c1771 8 9 1.96e-16
c1772 1142 1143 6.77e-16
c1773 14 230 1.9e-16
c1774 228 351 2.5e-16
c1775 0 1221 2.926e-15
c1776 390 391 6.77e-16
c1777 0 1059 2.623e-15
c1778 1587 1586 6.77e-16
c1779 0 1664 2.957e-15
c1780 1 550 1.6e-16
c1781 900 901 6.77e-16
c1782 1528 185 7.77e-16
c1783 1 1060 1.6e-16
c1784 193 157 1.9e-16
c1785 186 168 1.99e-16
c1786 183 178 3.24e-16
c1787 2545 224 3.73e-16
c1788 1 545 1.6e-16
c1789 242 147 1.99e-16
c1790 995 229 7.91e-16
c1791 1137 1136 6.77e-16
c1792 0 1976 2.957e-15
c1793 1 1486 1.6e-16
c1794 121 181 1.99e-16
c1795 2655 0 8.0131e-14
c1796 2719 2816 1.58e-16
c1797 1 2544 7.03e-16
c1798 2078 2079 6.77e-16
c1799 1 857 1.6e-16
c1800 1670 195 7.91e-16
c1801 192 132 3.24e-16
c1802 190 126 3.31e-16
c1803 1212 1213 6.77e-16
c1804 0 689 2.623e-15
c1805 460 461 6.77e-16
c1806 695 219 2.5e-16
c1807 2299 2351 7.84e-16
c1808 1657 1656 6.77e-16
c1809 1 2129 1.6e-16
c1810 1 2819 1.088e-15
c1811 1 2664 4.02e-16
c1812 0 1630 2.623e-15
c1813 37 243 3.34e-16
c1814 1608 225 7.77e-16
c1815 1956 208 2.13e-16
c1816 2574 0 4.8742e-14
c1817 0 506 2.957e-15
c1818 0 1001 2.623e-15
c1819 2587 2555 5.41e-16
c1820 1121 231 7.91e-16
c1821 1329 206 2.54e-16
c1822 1331 204 2.8e-16
c1823 1598 213 2.8e-16
c1824 0 1925 2.926e-15
c1825 2420 2409 1.58e-16
c1826 2299 2397 6.36e-16
c1827 2587 2567 7.1e-16
c1828 2842 2825 5.55e-16
c1829 164 103 4.85e-16
c1830 772 773 6.77e-16
c1831 8 69 3.47e-16
c1832 1969 1968 6.77e-16
c1833 63 228 3.34e-16
c1834 1796 193 8.32e-16
c1835 1797 192 7.76e-16
c1836 1738 226 2.5e-16
c1837 1739 227 2.8e-16
c1838 0 636 2.585e-15
c1839 2247 227 2.5e-16
c1840 2320 190 5.06e-16
c1841 2665 2670 1.6e-16
c1842 2389 2543 1.58e-16
c1843 1168 190 7.77e-16
c1844 1169 191 7.91e-16
c1845 1170 188 7.23e-16
c1846 1171 189 7.91e-16
c1847 1 2758 3.53e-16
c1848 232 600 2.13e-16
c1849 31 225 1.9e-16
c1850 2643 2382 1.96e-16
c1851 2647 2379 1.96e-16
c1852 147 192 1.94e-16
c1853 2463 207 2.186e-15
c1854 1101 223 7.76e-16
c1855 0 1408 2.957e-15
c1856 8 168 2.3e-16
c1857 1 1907 1.6e-16
c1858 234 174 3.34e-16
c1859 2587 2524 1.34e-16
c1860 2793 2779 4.93e-16
c1861 11 2764 7.42e-16
c1862 2787 2773 3.92e-16
c1863 2654 2649 1.96e-16
c1864 0 1294 2.623e-15
c1865 1 289 1.6e-16
c1866 1141 185 2.14e-16
c1867 1241 233 2.54e-16
c1868 2213 0 2.926e-15
c1869 13 2804 1.05e-16
c1870 8 108 1.96e-16
c1871 0 234 2.3912e-14
c1872 224 100 3.24e-16
c1873 228 105 3.34e-16
c1874 225 94 1.9e-16
c1875 226 84 1.99e-16
c1876 223 79 1.94e-16
c1877 727 235 2.5e-16
c1878 42 185 1.9e-16
c1879 37 193 3.31e-16
c1880 27 188 1.99e-16
c1881 31 198 3.31e-16
c1882 1 601 1.6e-16
c1883 1238 234 2.8e-16
c1884 0 2032 2.957e-15
c1885 1 1542 1.6e-16
c1886 238 178 3.31e-16
c1887 429 207 7.76e-16
c1888 431 205 7.23e-16
c1889 427 211 2.8e-16
c1890 0 1091 2.623e-15
c1891 2579 234 4.83e-16
c1892 499 498 6.77e-16
c1893 0 1357 2.926e-15
c1894 1320 1321 6.77e-16
c1895 0 414 2.623e-15
c1896 236 121 1.99e-16
c1897 84 204 3.34e-16
c1898 275 188 2.8e-16
c1899 273 190 2.54e-16
c1900 230 353 2.54e-16
c1901 1 90 7.6e-16
c1902 865 231 7.91e-16
c1903 1916 1917 6.77e-16
c1904 0 111 7.8194e-14
c1905 100 196 1.99e-16
c1906 94 198 3.31e-16
c1907 84 199 3.24e-16
c1908 2465 2394 5.36e-16
c1909 2490 2429 1.097e-15
c1910 2462 2386 1.58e-16
c1911 2475 2485 1.38e-16
c1912 0 726 2.623e-15
c1913 2634 2635 4e-16
c1914 2298 2335 2.07e-16
c1915 0 1236 2.585e-15
c1916 0 1681 2.623e-15
c1917 0 2015 2.957e-15
c1918 2707 0 1.65e-16
c1919 215 132 1.94e-16
c1920 0 1055 2.957e-15
c1921 143 42 3.26e-16
c1922 912 190 7.77e-16
c1923 913 191 7.91e-16
c1924 914 188 7.23e-16
c1925 915 189 7.91e-16
c1926 0 1993 2.623e-15
c1927 1983 213 7.23e-16
c1928 1982 212 7.91e-16
c1929 2375 193 3.61e-16
c1930 2632 2608 9.05e-16
c1931 2503 212 8.84e-16
c1932 228 142 1.99e-16
c1933 2719 2842 5.69e-16
c1934 2542 227 3.61e-16
c1935 2732 2755 6.76e-16
c1936 1 2300 1.43e-15
c1937 991 229 7.23e-16
c1938 990 228 7.91e-16
c1939 845 223 7.76e-16
c1940 1209 216 7.91e-16
c1941 0 1810 2.957e-15
c1942 1468 215 2.13e-16
c1943 2166 186 2.8e-16
c1944 2407 2391 3.92e-16
c1945 20 224 1.94e-16
c1946 2733 2740 8.81e-16
c1947 371 370 6.77e-16
c1948 2238 2239 6.77e-16
c1949 881 880 6.77e-16
c1950 0 2122 2.957e-15
c1951 2294 2746 1.669e-15
c1952 497 238 2.54e-16
c1953 0 523 2.623e-15
c1954 2377 2320 1.604e-15
c1955 1 524 1.6e-16
c1956 0 1447 2.957e-15
c1957 42 231 3.24e-16
c1958 0 1940 2.585e-15
c1959 2109 215 7.76e-16
c1960 14 209 3.31e-16
c1961 215 147 3.24e-16
c1962 0 835 2.623e-15
c1963 683 210 7.91e-16
c1964 686 204 7.91e-16
c1965 684 206 8.32e-16
c1966 2059 2058 6.77e-16
c1967 1 836 1.6e-16
c1968 14 203 3.34e-16
c1969 20 196 3.34e-16
c1970 1193 1192 6.77e-16
c1971 2655 2543 1.96e-16
c1972 2647 2384 1.96e-16
c1973 2641 2651 5.88e-16
c1974 2643 2333 1.96e-16
c1975 441 440 6.77e-16
c1976 1136 238 7.77e-16
c1977 1137 239 7.91e-16
c1978 1138 236 7.23e-16
c1979 1139 237 7.91e-16
c1980 0 1147 2.623e-15
c1981 1179 202 7.91e-16
c1982 1182 196 7.91e-16
c1983 1180 198 8.32e-16
c1984 1 1148 1.6e-16
c1985 2134 2135 6.77e-16
c1986 1382 1383 6.77e-16
c1987 1 1593 1.6e-16
c1988 513 182 2.54e-16
c1989 515 180 2.8e-16
c1990 1925 193 2.14e-16
c1991 2459 211 3.61e-16
c1992 241 174 3.31e-16
c1993 309 217 2.14e-16
c1994 0 799 2.957e-15
c1995 240 90 3.24e-16
c1996 753 752 6.77e-16
c1997 2228 0 2.585e-15
c1998 1873 223 7.91e-16
c1999 2232 217 7.77e-16
c2000 0 282 2.957e-15
c2001 80 14 1.59e-16
c2002 2503 2473 1.41e-16
c2003 2585 2514 3.1e-16
c2004 0 777 2.623e-15
c2005 25 13 4.983e-15
c2006 0 241 2.4607e-14
c2007 243 111 3.34e-16
c2008 1694 1695 6.77e-16
c2009 0 1111 2.957e-15
c2010 1 2318 1.456e-15
c2011 1175 1174 6.77e-16
c2012 0 2049 2.623e-15
c2013 2305 2510 1.96e-16
c2014 2645 2508 1.96e-16
c2015 2318 2467 1.96e-16
c2016 2364 2460 3.54e-16
c2017 2294 2505 1.96e-16
c2018 2649 2420 1.96e-16
c2019 439 218 7.23e-16
c2020 1931 1930 6.77e-16
c2021 936 209 7.77e-16
c2022 0 1372 2.585e-15
c2023 69 208 3.24e-16
c2024 1 435 1.6e-16
c2025 0 1866 2.957e-15
c2026 1498 234 2.5e-16
c2027 1499 235 2.8e-16
c2028 1910 186 2.8e-16
c2029 1 61 2.79e-16
c2030 223 157 3.24e-16
c2031 227 178 1.99e-16
c2032 212 578 7.23e-16
c2033 2471 2299 1.568e-15
c2034 240 360 2.13e-16
c2035 1 926 1.6e-16
c2036 1 747 1.6e-16
c2037 1341 214 2.14e-16
c2038 0 1684 2.585e-15
c2039 1 1257 1.6e-16
c2040 160 163 3.92e-16
c2041 1853 215 7.76e-16
c2042 2601 2594 1.38e-16
c2043 266 194 2.5e-16
c2044 1764 1765 6.77e-16
c2045 2759 2781 1.58e-16
c2046 2665 2643 4.24e-16
c2047 225 121 3.31e-16
c2048 1 2193 1.6e-16
c2049 1078 219 7.91e-16
c2050 1696 198 7.77e-16
c2051 1697 199 7.91e-16
c2052 1698 196 7.23e-16
c2053 1699 197 7.91e-16
c2054 38 34 2.57e-16
c2055 2203 203 2.8e-16
c2056 2207 197 7.23e-16
c2057 2205 199 7.76e-16
c2058 2039 187 2.5e-16
c2059 2475 2486 1.6e-16
c2060 219 153 3.34e-16
c2061 211 163 3.34e-16
c2062 208 168 1.94e-16
c2063 205 178 3.34e-16
c2064 2138 235 7.23e-16
c2065 1 2174 1.6e-16
c2066 2641 2585 1.96e-16
c2067 2343 2627 8.5e-16
c2068 2637 2632 3.24e-16
c2069 0 1070 2.623e-15
c2070 880 238 7.77e-16
c2071 881 239 7.91e-16
c2072 882 236 7.23e-16
c2073 883 237 7.91e-16
c2074 0 1496 2.957e-15
c2075 1633 230 2.54e-16
c2076 1840 207 2.13e-16
c2077 1842 205 2.5e-16
c2078 200 178 1.94e-16
c2079 191 174 1.94e-16
c2080 1990 226 2.8e-16
c2081 90 189 1.99e-16
c2082 79 182 1.9e-16
c2083 1 377 1.6e-16
c2084 59 64 1.34e-16
c2085 121 198 1.9e-16
c2086 111 193 3.31e-16
c2087 2842 0 2.466e-14
c2088 0 191 2.6057e-14
c2089 3 187 3.48e-16
c2090 1204 217 8.32e-16
c2091 1205 216 7.76e-16
c2092 1 2296 1.531e-15
c2093 0 2139 2.623e-15
c2094 1763 229 7.91e-16
c2095 2680 0 1.65e-16
c2096 2296 2467 1.58e-16
c2097 1 2140 1.6e-16
c2098 896 182 7.77e-16
c2099 897 183 7.91e-16
c2100 898 180 7.23e-16
c2101 899 181 7.91e-16
c2102 0 1462 2.623e-15
c2103 1467 218 7.91e-16
c2104 981 233 2.14e-16
c2105 1613 222 2.14e-16
c2106 1046 1047 6.77e-16
c2107 2492 215 7.64e-16
c2108 294 295 6.77e-16
c2109 1334 218 2.8e-16
c2110 0 1791 2.957e-15
c2111 1654 186 2.8e-16
c2112 2407 2342 3.7e-16
c2113 122 115 1.58e-16
c2114 679 210 7.23e-16
c2115 2639 2318 1.459e-15
c2116 2637 2647 5.88e-16
c2117 2389 2460 1.58e-16
c2118 0 1160 2.957e-15
c2119 1 2797 2.88e-16
c2120 1 670 1.6e-16
c2121 2219 2218 6.77e-16
c2122 1743 221 7.23e-16
c2123 1742 220 7.91e-16
c2124 0 2103 2.957e-15
c2125 2106 218 2.5e-16
c2126 164 40 4.85e-16
c2127 2665 2548 3.92e-16
c2128 0 485 2.926e-15
c2129 136 211 1.99e-16
c2130 605 231 7.76e-16
c2131 606 607 6.77e-16
c2132 1440 198 7.77e-16
c2133 1441 199 7.91e-16
c2134 1442 196 7.23e-16
c2135 1443 197 7.91e-16
c2136 1803 1802 6.77e-16
c2137 37 223 1.94e-16
c2138 1 982 1.6e-16
c2139 1 1427 1.6e-16
c2140 1882 235 7.23e-16
c2141 0 814 2.623e-15
c2142 1 2466 7.03e-16
c2143 1318 211 7.91e-16
c2144 745 241 2.54e-16
c2145 1368 232 2.13e-16
c2146 1257 240 7.91e-16
c2147 1584 207 2.13e-16
c2148 1586 205 2.5e-16
c2149 2490 2516 3.92e-16
c2150 0 299 2.623e-15
c2151 2572 2526 3.58e-16
c2152 2630 2519 1.15e-16
c2153 2508 2481 1.09e-16
c2154 1 1739 1.6e-16
c2155 651 195 2.8e-16
c2156 655 189 7.23e-16
c2157 653 191 7.76e-16
c2158 232 84 1.94e-16
c2159 1 300 1.6e-16
c2160 0 1126 2.623e-15
c2161 42 207 3.24e-16
c2162 0 1552 2.957e-15
c2163 1244 230 8.32e-16
c2164 2080 199 2.13e-16
c2165 2082 197 2.5e-16
c2166 2115 2114 6.77e-16
c2167 0 611 2.623e-15
c2168 1363 1362 6.77e-16
c2169 2651 2422 1.96e-16
c2170 3 229 6.13e-16
c2171 676 677 6.77e-16
c2172 42 202 1.99e-16
c2173 1 612 1.6e-16
c2174 948 217 8.32e-16
c2175 949 216 7.76e-16
c2176 0 2045 2.926e-15
c2177 0 1883 2.623e-15
c2178 1507 229 7.91e-16
c2179 58 228 1.99e-16
c2180 2016 230 7.77e-16
c2181 2296 2434 1.96e-16
c2182 237 79 1.99e-16
c2183 1 1884 1.6e-16
c2184 1438 1439 6.77e-16
c2185 1088 214 7.77e-16
c2186 1348 225 8.32e-16
c2187 1 1369 1.6e-16
c2188 1860 224 2.13e-16
c2189 278 202 2.8e-16
c2190 0 246 2.623e-15
c2191 2422 2402 1.58e-16
c2192 2425 2392 1.58e-16
c2193 777 193 2.54e-16
c2194 776 192 2.13e-16
c2195 2764 2777 1.96e-16
c2196 2296 2639 2.11e-16
c2197 2709 2305 3.54e-16
c2198 0 1250 2.957e-15
c2199 988 989 6.77e-16
c2200 0 2186 2.957e-15
c2201 2379 2369 1.13e-16
c2202 1433 1432 6.77e-16
c2203 0 575 2.957e-15
c2204 2146 229 2.5e-16
c2205 2147 228 2.8e-16
c2206 2647 2630 1.96e-16
c2207 2637 2550 1.96e-16
c2208 2641 2503 1.96e-16
c2209 2343 2548 1.96e-16
c2210 0 1513 2.623e-15
c2211 1 213 3.749e-15
c2212 1338 219 7.23e-16
c2213 73 180 3.34e-16
c2214 0 46 1.14e-16
c2215 1850 218 2.5e-16
c2216 2358 2490 3.15e-16
c2217 2635 2625 1.96e-16
c2218 8 2632 2.83e-16
c2219 1 2027 1.6e-16
c2220 877 239 7.76e-16
c2221 919 202 7.23e-16
c2222 1508 1509 6.77e-16
c2223 1 2586 7.03e-16
c2224 0 1825 2.623e-15
c2225 45 48 3.92e-16
c2226 2590 2512 8.7e-16
c2227 2272 231 2.13e-16
c2228 1745 1744 6.77e-16
c2229 2768 2766 2.12e-16
c2230 1062 211 7.91e-16
c2231 0 2152 2.957e-15
c2232 1 1662 1.6e-16
c2233 182 157 3.31e-16
c2234 705 215 7.91e-16
c2235 242 486 2.8e-16
c2236 0 1477 2.926e-15
c2237 1820 1821 6.77e-16
c2238 1 1033 1.6e-16
c2239 1977 216 7.91e-16
c2240 1 1974 1.6e-16
c2241 891 187 2.8e-16
c2242 893 183 7.76e-16
c2243 14 0 7.8203e-14
c2244 1753 233 2.54e-16
c2245 181 132 1.99e-16
c2246 124 126 3.92e-16
c2247 0 682 2.957e-15
c2248 1 2281 1.6e-16
c2249 2655 2460 1.96e-16
c2250 832 214 7.77e-16
c2251 0 1177 2.623e-15
c2252 1188 209 8.32e-16
c2253 1189 208 7.76e-16
c2254 1 2779 1.836e-15
c2255 1127 242 7.23e-16
c2256 1126 243 7.91e-16
c2257 1604 224 2.13e-16
c2258 2647 8 3.78e-16
c2259 2364 2651 1.176e-15
c2260 0 500 2.585e-15
c2261 164 162 6.74e-16
c2262 0 994 2.957e-15
c2263 240 612 2.13e-16
c2264 861 860 6.77e-16
c2265 1320 208 2.13e-16
c2266 1027 1026 6.77e-16
c2267 2508 2492 1.58e-16
c2268 275 274 6.77e-16
c2269 2820 2634 1.58e-16
c2270 1 2480 1.424e-15
c2271 962 213 2.5e-16
c2272 963 212 2.8e-16
c2273 1377 231 7.91e-16
c2274 69 235 3.34e-16
c2275 0 312 2.957e-15
c2276 122 128 1.34e-16
c2277 623 237 7.23e-16
c2278 621 239 7.76e-16
c2279 741 241 2.14e-16
c2280 1 811 1.6e-16
c2281 1160 193 7.77e-16
c2282 0 1569 2.623e-15
c2283 1253 240 7.76e-16
c2284 1578 211 7.23e-16
c2285 2746 0 2.2584e-14
c2286 2515 2512 1.154e-15
c2287 0 624 2.957e-15
c2288 647 195 2.5e-16
c2289 2649 2377 1.96e-16
c2290 2647 2425 1.96e-16
c2291 2318 2427 1.96e-16
c2292 147 181 3.34e-16
c2293 1 465 1.6e-16
c2294 1 1123 1.6e-16
c2295 1424 190 7.77e-16
c2296 1425 191 7.91e-16
c2297 1426 188 7.23e-16
c2298 1427 189 7.91e-16
c2299 0 2060 2.585e-15
c2300 1 1406 1.6e-16
c2301 2025 241 2.54e-16
c2302 2275 2274 6.77e-16
c2303 345 344 6.77e-16
c2304 235 168 1.99e-16
c2305 230 153 1.9e-16
c2306 292 208 2.13e-16
c2307 221 595 7.91e-16
c2308 0 936 2.957e-15
c2309 2652 2637 5.88e-16
c2310 1 446 1.6e-16
c2311 0 72 1.14e-16
c2312 1503 229 7.23e-16
c2313 1502 228 7.91e-16
c2314 0 1879 2.957e-15
c2315 1357 223 7.76e-16
c2316 1 76 2.79e-16
c2317 2217 208 7.91e-16
c2318 2299 2314 1.196e-15
c2319 0 261 2.926e-15
c2320 788 200 2.13e-16
c2321 2796 101 4.11e-16
c2322 2843 2757 2e-16
c2323 226 79 3.34e-16
c2324 0 1267 2.623e-15
c2325 1 758 1.6e-16
c2326 37 182 1.9e-16
c2327 1 1268 1.6e-16
c2328 2203 0 2.623e-15
c2329 2064 191 2.13e-16
c2330 2066 189 2.5e-16
c2331 237 157 3.34e-16
c2332 0 590 2.623e-15
c2333 223 111 1.94e-16
c2334 220 115 3.34e-16
c2335 2155 242 7.91e-16
c2336 1 2204 1.6e-16
c2337 2766 2638 1.09e-16
c2338 23 27 3.92e-16
c2339 657 656 6.77e-16
c2340 1234 221 2.5e-16
c2341 1235 220 2.8e-16
c2342 1 222 4.537e-15
c2343 0 169 1.82e-16
c2344 2143 228 2.5e-16
c2345 2645 2632 1.96e-16
c2346 2351 2592 1.96e-16
c2347 2364 2585 5.21e-16
c2348 2294 2627 2.29e-16
c2349 2635 2545 1.96e-16
c2350 8 2550 1.36e-16
c2351 1598 1599 6.77e-16
c2352 79 204 1.99e-16
c2353 1 178 7.6e-16
c2354 1274 187 7.23e-16
c2355 1846 219 7.91e-16
c2356 3 210 6.13e-16
c2357 0 119 1.14e-16
c2358 236 132 1.99e-16
c2359 100 187 3.34e-16
c2360 84 188 3.34e-16
c2361 79 199 1.94e-16
c2362 2281 240 7.91e-16
c2363 14 243 3.34e-16
c2364 0 1231 2.957e-15
c2365 1 217 4.406e-15
c2366 0 1674 2.957e-15
c2367 969 968 6.77e-16
c2368 1648 238 7.77e-16
c2369 1649 239 7.91e-16
c2370 1650 236 7.23e-16
c2371 1651 237 7.91e-16
c2372 2187 194 7.91e-16
c2373 2190 188 7.91e-16
c2374 2188 190 8.32e-16
c2375 2492 2437 1.31e-16
c2376 2505 0 2.2654e-14
c2377 2296 2427 1.58e-16
c2378 997 240 7.76e-16
c2379 0 1986 2.957e-15
c2380 2290 237 2.5e-16
c2381 2288 239 2.13e-16
c2382 391 195 2.5e-16
c2383 0 353 2.623e-15
c2384 1489 1488 6.77e-16
c2385 903 194 7.23e-16
c2386 2675 2855 9.61e-16
c2387 1 867 1.6e-16
c2388 0 1804 2.585e-15
c2389 1818 203 7.23e-16
c2390 101 98 2.32e-16
c2391 80 83 1.34e-16
c2392 0 699 2.623e-15
c2393 2261 232 7.76e-16
c2394 2299 2318 5.88e-16
c2395 221 339 7.91e-16
c2396 841 225 2.54e-16
c2397 1 700 1.6e-16
c2398 1664 182 7.77e-16
c2399 1665 183 7.91e-16
c2400 1666 180 7.23e-16
c2401 1667 181 7.91e-16
c2402 1749 233 2.14e-16
c2403 0 2116 2.585e-15
c2404 2312 2305 1.558e-15
c2405 2647 2645 7.84e-16
c2406 532 200 2.13e-16
c2407 147 236 3.34e-16
c2408 0 1173 2.926e-15
c2409 0 1011 2.623e-15
c2410 0 1616 2.957e-15
c2411 1448 209 7.77e-16
c2412 42 234 1.99e-16
c2413 1 1012 1.6e-16
c2414 0 1935 2.957e-15
c2415 101 50 2.44e-16
c2416 122 48 1.58e-16
c2417 0 138 1.82e-16
c2418 1899 242 7.91e-16
c2419 1 497 1.6e-16
c2420 2856 2857 1.16e-16
c2421 2687 2855 5.75e-16
c2422 971 226 7.91e-16
c2423 1944 201 7.77e-16
c2424 69 242 3.34e-16
c2425 2259 0 2.623e-15
c2426 1887 228 2.5e-16
c2427 20 187 1.99e-16
c2428 14 193 3.31e-16
c2429 0 329 2.623e-15
c2430 1 1769 1.6e-16
c2431 1 2260 1.6e-16
c2432 212 318 7.91e-16
c2433 213 319 7.23e-16
c2434 37 237 1.99e-16
c2435 1590 219 7.91e-16
c2436 1 1750 1.6e-16
c2437 229 100 1.99e-16
c2438 2242 213 2.5e-16
c2439 2243 212 2.8e-16
c2440 61 63 3.92e-16
c2441 2389 2585 1.58e-16
c2442 505 185 2.54e-16
c2443 504 184 2.13e-16
c2444 1 2081 1.6e-16
c2445 0 35 1.14e-16
c2446 0 1565 2.926e-15
c2447 1392 238 7.77e-16
c2448 1393 239 7.91e-16
c2449 1394 236 7.23e-16
c2450 1395 237 7.91e-16
c2451 1187 1186 6.77e-16
c2452 0 458 2.957e-15
c2453 242 168 1.99e-16
c2454 240 178 1.94e-16
c2455 0 953 2.623e-15
c2456 0 1894 2.623e-15
c2457 1262 1263 6.77e-16
c2458 0 276 2.585e-15
c2459 2548 2477 3.41e-16
c2460 2545 2469 9.52e-16
c2461 0 770 2.957e-15
c2462 510 511 6.77e-16
c2463 2652 8 3.26e-16
c2464 2779 2776 4.13e-16
c2465 2784 80 1.088e-15
c2466 2697 2651 1.96e-16
c2467 2296 2299 1.372e-15
c2468 635 186 7.91e-16
c2469 638 180 7.91e-16
c2470 636 182 8.32e-16
c2471 0 1280 2.957e-15
c2472 1716 217 8.32e-16
c2473 1717 216 7.76e-16
c2474 2198 2199 6.77e-16
c2475 631 187 2.5e-16
c2476 2343 2465 1.96e-16
c2477 225 585 2.54e-16
c2478 1408 182 7.77e-16
c2479 1409 183 7.91e-16
c2480 1410 180 7.23e-16
c2481 1411 181 7.91e-16
c2482 2058 195 7.23e-16
c2483 1493 233 2.14e-16
c2484 2294 2548 1.96e-16
c2485 2645 2550 1.96e-16
c2486 2364 2503 1.96e-16
c2487 2005 232 7.76e-16
c2488 226 157 1.99e-16
c2489 0 917 2.926e-15
c2490 0 1345 2.623e-15
c2491 69 192 3.24e-16
c2492 73 197 3.34e-16
c2493 52 213 3.34e-16
c2494 1 1859 1.6e-16
c2495 261 193 2.14e-16
c2496 2759 2766 1.58e-16
c2497 2634 2649 3.54e-16
c2498 2655 2651 1.568e-15
c2499 401 400 6.77e-16
c2500 715 226 7.91e-16
c2501 1688 201 7.77e-16
c2502 1224 225 7.77e-16
c2503 0 2165 2.926e-15
c2504 20 229 3.34e-16
c2505 209 153 3.31e-16
c2506 204 157 3.34e-16
c2507 225 132 3.31e-16
c2508 224 126 1.94e-16
c2509 2647 2407 1.58e-16
c2510 1 553 1.6e-16
c2511 1214 213 2.8e-16
c2512 0 2003 2.623e-15
c2513 203 153 3.34e-16
c2514 199 157 3.24e-16
c2515 1 1494 1.6e-16
c2516 195 163 3.34e-16
c2517 192 168 1.94e-16
c2518 189 178 3.34e-16
c2519 180 174 1.99e-16
c2520 2651 2574 2.33e-16
c2521 382 383 6.77e-16
c2522 1 2004 1.6e-16
c2523 1579 1578 6.77e-16
c2524 892 893 6.77e-16
c2525 713 712 6.77e-16
c2526 1769 240 7.91e-16
c2527 0 180 2.5381e-14
c2528 115 186 1.99e-16
c2529 111 182 1.9e-16
c2530 2709 2715 1.6e-16
c2531 1 184 3.792e-15
c2532 0 1638 2.623e-15
c2533 1675 194 7.91e-16
c2534 1678 188 7.91e-16
c2535 1676 190 8.32e-16
c2536 1756 230 8.32e-16
c2537 198 132 1.9e-16
c2538 196 126 3.34e-16
c2539 200 201 2e-16
c2540 2446 2434 1.6e-16
c2541 0 695 2.957e-15
c2542 1412 1413 6.77e-16
c2543 2574 237 5.64e-16
c2544 0 1188 2.585e-15
c2545 1 2674 4.65e-16
c2546 0 1633 2.623e-15
c2547 1460 217 8.32e-16
c2548 1461 216 7.76e-16
c2549 42 241 1.9e-16
c2550 1204 1205 6.77e-16
c2551 0 1950 2.623e-15
c2552 1649 1648 6.77e-16
c2553 0 1007 2.957e-15
c2554 164 90 3.31e-16
c2555 235 474 7.23e-16
c2556 225 147 1.9e-16
c2557 1802 195 7.23e-16
c2558 1895 242 7.23e-16
c2559 1894 243 7.91e-16
c2560 2572 2566 3.92e-16
c2561 2630 2559 1.59e-16
c2562 101 102 1.34e-16
c2563 2822 2841 2.67e-16
c2564 226 326 2.8e-16
c2565 0 1762 2.957e-15
c2566 1 1158 1.6e-16
c2567 2101 217 2.14e-16
c2568 2781 0 8.591e-15
c2569 2322 2300 3.92e-16
c2570 1 1603 1.6e-16
c2571 672 199 2.13e-16
c2572 674 197 2.5e-16
c2573 2251 226 7.91e-16
c2574 2407 198 5.06e-16
c2575 2471 2592 8.99e-16
c2576 2389 2503 2.9e-16
c2577 516 192 2.13e-16
c2578 1961 1960 6.77e-16
c2579 1 643 1.6e-16
c2580 0 1580 2.585e-15
c2581 37 226 3.34e-16
c2582 1730 213 2.5e-16
c2583 1731 212 2.8e-16
c2584 2322 2314 7.85e-16
c2585 2239 212 2.5e-16
c2586 2358 2379 1.96e-16
c2587 2298 2490 1.58e-16
c2588 0 475 2.623e-15
c2589 147 198 3.31e-16
c2590 136 195 1.99e-16
c2591 1 476 1.6e-16
c2592 2833 2389 1.96e-16
c2593 1431 202 7.23e-16
c2594 0 1909 2.926e-15
c2595 2036 2037 6.77e-16
c2596 2585 2574 1.58e-16
c2597 8 166 1.96e-16
c2598 15 7 1.34e-16
c2599 0 787 2.623e-15
c2600 11 2806 9.14e-16
c2601 2652 2645 5.88e-16
c2602 2654 2312 1.96e-16
c2603 2675 2647 1.96e-16
c2604 232 79 3.24e-16
c2605 0 1297 2.623e-15
c2606 1 788 1.6e-16
c2607 1145 184 7.91e-16
c2608 37 204 1.99e-16
c2609 31 211 1.99e-16
c2610 69 215 1.94e-16
c2611 63 213 3.34e-16
c2612 2574 2512 2.74e-16
c2613 2033 238 2.54e-16
c2614 2035 236 2.8e-16
c2615 8 115 2.3e-16
c2616 0 1099 2.623e-15
c2617 42 191 3.24e-16
c2618 37 199 1.94e-16
c2619 1 1100 1.6e-16
c2620 2070 203 7.91e-16
c2621 1 1545 1.6e-16
c2622 2403 2392 1.6e-16
c2623 2635 2462 1.96e-16
c2624 0 422 2.623e-15
c2625 2583 233 3.61e-16
c2626 1 2626 7.03e-16
c2627 1084 215 2.13e-16
c2628 1403 187 2.8e-16
c2629 48 220 1.99e-16
c2630 52 222 3.31e-16
c2631 1243 1242 6.77e-16
c2632 0 83 1.14e-16
c2633 237 111 1.99e-16
c2634 100 210 3.34e-16
c2635 94 211 1.99e-16
c2636 212 163 1.99e-16
c2637 215 168 3.24e-16
c2638 2425 2398 2.01e-16
c2639 491 490 6.77e-16
c2640 0 734 2.623e-15
c2641 2764 2763 1.96e-16
c2642 2687 2647 3.54e-16
c2643 0 1244 2.585e-15
c2644 1 239 3.42e-15
c2645 2179 2178 6.77e-16
c2646 0 2180 2.585e-15
c2647 1639 242 7.23e-16
c2648 1638 243 7.91e-16
c2649 2049 182 2.54e-16
c2650 2051 180 2.8e-16
c2651 2665 2351 8.24e-16
c2652 213 105 3.34e-16
c2653 2643 2587 1.96e-16
c2654 122 27 1.58e-16
c2655 566 567 6.77e-16
c2656 0 1506 2.957e-15
c2657 0 2016 2.957e-15
c2658 52 217 1.9e-16
c2659 2647 2492 3.54e-16
c2660 2299 2480 6.36e-16
c2661 324 325 6.77e-16
c2662 1 55 2.79e-16
c2663 0 1056 2.957e-15
c2664 1 387 1.6e-16
c2665 1 897 1.6e-16
c2666 0 1818 2.957e-15
c2667 1482 227 7.23e-16
c2668 1830 210 2.8e-16
c2669 1313 1312 6.77e-16
c2670 0 364 2.585e-15
c2671 2757 2761 4.7e-16
c2672 233 345 2.54e-16
c2673 0 1653 2.926e-15
c2674 2249 2248 6.77e-16
c2675 1 1209 1.6e-16
c2676 1765 240 7.76e-16
c2677 2168 185 7.77e-16
c2678 0 710 2.623e-15
c2679 14 223 1.94e-16
c2680 1 2150 1.6e-16
c2681 1 532 1.6e-16
c2682 0 1965 2.926e-15
c2683 164 61 4.85e-16
c2684 2627 0 2.8344e-14
c2685 2114 212 7.23e-16
c2686 363 362 6.77e-16
c2687 375 186 7.23e-16
c2688 0 1022 2.623e-15
c2689 0 1448 2.957e-15
c2690 1 2522 1.424e-15
c2691 873 872 6.77e-16
c2692 1 844 1.6e-16
c2693 20 210 1.99e-16
c2694 1 1947 1.6e-16
c2695 2585 2555 1.58e-16
c2696 2784 0 1.2169e-14
c2697 2320 2359 3.92e-16
c2698 213 142 1.99e-16
c2699 212 136 3.34e-16
c2700 2709 2861 5.09e-16
c2701 2854 2866 9.94e-16
c2702 1 2517 1.79e-16
c2703 1814 1815 6.77e-16
c2704 2687 2692 1.6e-16
c2705 974 221 2.8e-16
c2706 828 215 2.13e-16
c2707 0 1779 2.623e-15
c2708 1 2812 2.88e-16
c2709 948 949 6.77e-16
c2710 2270 0 2.623e-15
c2711 2145 2144 6.77e-16
c2712 2585 2567 3.38e-16
c2713 1 1780 1.6e-16
c2714 2409 2353 1.08e-16
c2715 1393 1392 6.77e-16
c2716 2655 2503 1.96e-16
c2717 2343 2351 9.8e-16
c2718 1114 234 2.5e-16
c2719 1115 235 2.8e-16
c2720 0 2091 2.623e-15
c2721 2296 2322 9.3e-16
c2722 1 2092 1.6e-16
c2723 2126 2127 6.77e-16
c2724 1929 192 7.91e-16
c2725 1786 187 7.23e-16
c2726 2550 2492 2.44e-16
c2727 2299 2360 1.196e-15
c2728 313 216 7.91e-16
c2729 0 800 2.957e-15
c2730 1 2443 1.947e-15
c2731 1705 1704 6.77e-16
c2732 1 310 1.6e-16
c2733 0 1726 2.623e-15
c2734 63 222 3.31e-16
c2735 1574 210 2.8e-16
c2736 2467 2443 1.021e-15
c2737 101 23 2.44e-16
c2738 59 20 2.17e-16
c2739 80 17 2.44e-16
c2740 2643 0 3.9799e-14
c2741 1 2235 1.6e-16
c2742 0 1112 2.957e-15
c2743 1 2305 7.27e-16
c2744 1 622 1.6e-16
c2745 1095 227 2.5e-16
c2746 0 2055 2.957e-15
c2747 1509 240 7.76e-16
c2748 2294 2465 2.75e-16
c2749 2305 2467 2.75e-16
c2750 2312 2420 1.96e-16
c2751 0 437 2.926e-15
c2752 232 157 1.94e-16
c2753 588 222 8.32e-16
c2754 1415 194 7.23e-16
c2755 63 217 1.9e-16
c2756 0 62 1.14e-16
c2757 1 934 1.6e-16
c2758 1912 185 7.77e-16
c2759 1 1379 1.6e-16
c2760 221 163 1.99e-16
c2761 0 749 2.926e-15
c2762 2634 2761 4.08e-16
c2763 1344 215 2.13e-16
c2764 2574 2479 2.31e-16
c2765 1 1691 1.6e-16
c2766 1340 1341 6.77e-16
c2767 2148 241 8.32e-16
c2768 226 111 3.34e-16
c2769 222 105 3.31e-16
c2770 718 221 2.8e-16
c2771 0 1078 2.623e-15
c2772 1083 218 7.91e-16
c2773 0 1523 2.623e-15
c2774 1229 222 2.14e-16
c2775 2042 186 2.5e-16
c2776 2046 181 2.8e-16
c2777 2045 182 2.14e-16
c2778 2044 183 2.13e-16
c2779 2047 180 2.5e-16
c2780 0 153 7.8194e-14
c2781 1 1524 1.6e-16
c2782 218 163 3.34e-16
c2783 0 563 2.623e-15
c2784 2649 2625 1.96e-16
c2785 419 196 2.8e-16
c2786 417 198 2.54e-16
c2787 0 1073 2.623e-15
c2788 143 151 3.02e-16
c2789 2823 2719 1.197e-15
c2790 2652 2675 1.96e-16
c2791 0 2014 2.623e-15
c2792 0 1835 2.623e-15
c2793 197 174 1.99e-16
c2794 1992 225 7.77e-16
c2795 410 203 7.23e-16
c2796 211 121 3.34e-16
c2797 208 115 1.94e-16
c2798 204 111 1.99e-16
c2799 105 217 1.9e-16
c2800 79 188 1.99e-16
c2801 1 1836 1.6e-16
c2802 244 184 2.13e-16
c2803 0 890 2.957e-15
c2804 1 206 4.537e-15
c2805 80 77 2.32e-16
c2806 0 1668 2.585e-15
c2807 111 199 1.94e-16
c2808 2180 193 8.32e-16
c2809 2181 192 7.76e-16
c2810 0 197 2.3955e-14
c2811 3 194 6.13e-16
c2812 2465 209 7.02e-16
c2813 2709 2377 2.819e-15
c2814 0 1202 2.957e-15
c2815 1 201 4.406e-15
c2816 1 2695 1.65e-16
c2817 2160 2161 6.77e-16
c2818 1 1043 1.6e-16
c2819 52 184 1.94e-16
c2820 48 186 3.34e-16
c2821 2548 0 2.2042e-14
c2822 2122 226 2.5e-16
c2823 2123 227 2.8e-16
c2824 305 304 6.77e-16
c2825 1 2686 4.29e-16
c2826 2652 2687 2.44e-16
c2827 0 1465 2.623e-15
c2828 984 232 2.13e-16
c2829 1616 223 2.13e-16
c2830 1998 1999 6.77e-16
c2831 2332 187 3.61e-16
c2832 228 479 2.5e-16
c2833 222 142 1.9e-16
c2834 221 136 3.34e-16
c2835 101 97 7.53e-16
c2836 697 217 2.54e-16
c2837 696 216 2.13e-16
c2838 0 1332 2.585e-15
c2839 2733 2343 1.214e-15
c2840 2732 2637 1.58e-16
c2841 1 2291 1.6e-16
c2842 1336 217 7.77e-16
c2843 0 1792 2.957e-15
c2844 1038 1039 6.77e-16
c2845 1656 185 7.77e-16
c2846 2804 0 6.375e-15
c2847 1483 1482 6.77e-16
c2848 2257 222 2.54e-16
c2849 2639 2305 1.372e-15
c2850 617 616 6.77e-16
c2851 1 673 1.6e-16
c2852 37 232 3.24e-16
c2853 0 2104 2.957e-15
c2854 1 1614 1.6e-16
c2855 2254 221 2.8e-16
c2856 101 45 2.44e-16
c2857 142 217 3.31e-16
c2858 136 218 1.99e-16
c2859 2389 2552 1.96e-16
c2860 0 1429 2.926e-15
c2861 27 220 1.99e-16
c2862 964 225 8.32e-16
c2863 1 985 1.6e-16
c2864 143 50 3.31e-16
c2865 14 182 1.9e-16
c2866 0 322 2.957e-15
c2867 0 817 2.623e-15
c2868 823 219 2.5e-16
c2869 2833 2816 1.58e-16
c2871 0 1741 2.926e-15
c2872 2286 2287 6.77e-16
c2873 929 928 6.77e-16
c2874 2592 2528 1.34e-16
c2875 2084 208 2.13e-16
c2877 657 190 2.54e-16
c2878 659 188 2.8e-16
c2879 737 230 2.54e-16
c2880 0 1129 2.623e-15
c2881 1870 1871 6.77e-16
c2882 1249 231 7.91e-16
c2883 0 2070 2.623e-15
c2884 1 34 2.79e-16
c2885 0 452 2.585e-15
c2886 1628 1629 6.77e-16
c2887 243 153 3.34e-16
c2888 0 946 2.957e-15
c2889 252 253 6.77e-16
c2890 2392 2391 1.149e-15
c2891 8 48 3.47e-16
c2892 1866 226 2.5e-16
c2893 1867 227 2.8e-16
c2894 0 271 2.957e-15
c2895 0 764 2.585e-15
c2896 2779 164 1.239e-15
c2898 1353 224 7.91e-16
c2899 1 1278 1.6e-16
c2900 2492 2474 3.92e-16
c2901 2490 2473 3.92e-16
c2902 280 201 7.77e-16
c2903 0 249 2.623e-15
c2904 52 239 3.24e-16
c2905 2054 194 2.8e-16
c2906 0 576 2.957e-15
c2907 2318 2592 8.78e-16
c2908 2649 2545 1.96e-16
c2909 2643 2543 1.96e-16
c2910 2358 2630 1.96e-16
c2911 3 214 2.38e-16
c2912 0 1519 2.957e-15
c2913 0 1338 2.957e-15
c2914 69 181 1.99e-16
c2915 63 184 1.94e-16
c2916 0 2029 2.926e-15
c2917 0 1848 2.957e-15
c2918 58 213 1.99e-16
c2919 2001 222 2.54e-16
c2920 2823 0 1.4201e-14
c2921 0 907 2.623e-15
c2922 2759 2733 7.8e-16
c2923 2655 2335 1.96e-16
c2924 2471 2343 3.54e-16
c2925 1 398 1.6e-16
c2926 855 235 2.5e-16
c2927 1 908 1.6e-16
c2928 0 1831 2.957e-15
c2929 1 2654 5.881e-15
c2930 1487 220 2.5e-16
c2931 0 2160 2.957e-15
c2932 1500 1501 6.77e-16
c2933 2757 2786 1.58e-16
c2934 230 348 8.32e-16
c2935 555 211 2.8e-16
c2936 559 205 7.23e-16
c2937 557 207 7.76e-16
c2938 0 1219 2.623e-15
c2939 1067 210 7.91e-16
c2940 1070 204 7.91e-16
c2941 1068 206 8.32e-16
c2942 1 1220 1.6e-16
c2943 1 1665 1.6e-16
c2944 193 153 3.31e-16
c2945 188 157 3.34e-16
c2946 181 168 3.34e-16
c2947 185 163 3.31e-16
c2948 2298 2379 1.58e-16
c2949 0 542 2.623e-15
c2950 2131 221 7.91e-16
c2951 2574 232 7.35e-16
c2952 403 188 2.8e-16
c2953 401 190 2.54e-16
c2954 241 488 7.77e-16
c2955 993 231 7.91e-16
c2956 164 76 4.85e-16
c2957 14 237 1.99e-16
c2958 1 1977 1.6e-16
c2959 2572 2608 3.92e-16
c2960 105 184 1.94e-16
c2961 0 854 2.623e-15
c2962 2675 2847 8.14e-16
c2963 2697 2838 2.44e-16
c2964 470 471 6.77e-16
c2965 1194 211 7.23e-16
c2966 1668 193 8.32e-16
c2967 1669 192 7.76e-16
c2968 187 126 1.99e-16
c2969 25 0 1.00678e-13
c2970 693 217 2.14e-16
c2971 2732 8 4.63e-16
c2972 0 1183 2.957e-15
c2973 1040 190 7.77e-16
c2974 1042 188 7.23e-16
c2975 1043 189 7.91e-16
c2976 0 1626 2.957e-15
c2977 2305 2738 1.22e-16
c2978 2358 8 1.78e-16
c2979 2294 2351 9.94e-16
c2980 2296 2592 1.58e-16
c2981 1 507 1.6e-16
c2982 1119 229 7.23e-16
c2983 1118 228 7.91e-16
c2984 782 783 6.77e-16
c2985 0 1923 2.623e-15
c2986 1596 215 2.13e-16
c2987 2502 219 3.61e-16
c2988 2462 2409 1.58e-16
c2989 1292 1293 6.77e-16
c2990 1 1924 1.6e-16
c2991 2849 2846 1.12e-16
c2992 73 228 3.34e-16
c2993 0 1756 2.585e-15
c2994 267 266 6.77e-16
c2995 1736 224 2.13e-16
c2996 2766 0 1.9268e-14
c2997 0 632 2.957e-15
c2998 2244 225 8.32e-16
c2999 625 238 2.54e-16
c3000 627 236 2.8e-16
c3001 2665 2664 1.6e-16
c3002 599 235 2.5e-16
c3003 0 1575 2.957e-15
c3004 1725 214 2.14e-16
c3005 1094 1095 6.77e-16
c3006 2312 2377 1.96e-16
c3007 2358 2425 1.96e-16
c3008 2305 2427 1.96e-16
c3009 2318 2382 1.96e-16
c3010 142 184 3.24e-16
c3011 136 185 1.9e-16
c3012 1539 1538 6.77e-16
c3013 814 204 7.91e-16
c3014 812 206 8.32e-16
c3015 69 236 1.99e-16
c3016 63 239 3.24e-16
c3017 1331 1330 6.77e-16
c3018 1 1409 1.6e-16
c3019 8 160 1.96e-16
c3020 8 2601 4.54e-16
c3021 231 163 1.94e-16
c3022 0 286 2.623e-15
c3024 2784 2773 3.92e-16
c3025 2787 2764 7.21e-16
c3026 2654 2639 1.96e-16
c3027 0 77 1.14e-16
c3028 0 1290 2.957e-15
c3029 1264 238 7.77e-16
c3030 1265 239 7.91e-16
c3031 1266 236 7.23e-16
c3032 1267 237 7.91e-16
c3033 1307 202 7.91e-16
c3034 1310 196 7.91e-16
c3035 1308 198 8.32e-16
c3036 1089 1088 6.77e-16
c3037 2211 0 2.623e-15
c3038 2803 2804 3.22e-16
c3039 101 122 7.9e-16
c3040 0 598 2.623e-15
c3041 232 111 3.24e-16
c3042 235 115 1.99e-16
c3043 1 2212 1.6e-16
c3044 1303 203 2.5e-16
c3045 724 233 8.32e-16
c3046 42 180 3.34e-16
c3047 37 188 1.99e-16
c3048 27 186 3.34e-16
c3049 31 195 1.99e-16
c3050 1 761 1.6e-16
c3051 1 233 4.406e-15
c3052 1236 232 2.13e-16
c3053 1164 1165 6.77e-16
c3054 236 168 3.34e-16
c3055 0 593 2.623e-15
c3056 229 126 3.34e-16
c3057 2651 2505 1.96e-16
c3058 412 413 6.77e-16
c3059 1609 1608 6.77e-16
c3060 1 2033 1.6e-16
c3061 2299 2522 6.36e-16
c3062 424 208 2.13e-16
c3063 425 209 2.54e-16
c3064 0 1534 2.623e-15
c3065 1 1356 1.6e-16
c3066 58 222 1.9e-16
c3067 0 410 2.957e-15
c3068 2299 2517 7.84e-16
c3069 143 136 3.26e-16
c3070 239 105 3.24e-16
c3071 90 219 3.34e-16
c3072 863 229 7.23e-16
c3073 862 228 7.91e-16
c3074 1280 182 7.77e-16
c3075 1281 183 7.91e-16
c3076 1282 180 7.23e-16
c3077 1283 181 7.91e-16
c3078 0 1846 2.623e-15
c3079 1997 222 2.14e-16
c3080 100 194 3.34e-16
c3081 94 195 1.99e-16
c3082 3 216 3.08e-16
c3083 2335 2304 1.58e-16
c3084 2492 2429 6.25e-16
c3085 0 722 2.957e-15
c3086 2298 2384 4.17e-16
c3087 567 218 7.23e-16
c3088 724 725 6.77e-16
c3089 0 1232 2.957e-15
c3090 1 2715 2.88e-16
c3091 122 29 8.48e-16
c3092 101 31 1.58e-16
c3093 58 217 3.31e-16
c3094 48 208 3.24e-16
c3095 52 206 3.31e-16
c3096 2465 0 1.9727e-14
c3097 2296 2382 1.58e-16
c3098 2641 2490 1.58e-16
c3099 2637 2572 1.58e-16
c3100 1 2420 3.466e-15
c3101 1 2562 1.424e-15
c3102 1 1054 1.6e-16
c3103 52 201 1.9e-16
c3104 2127 221 7.23e-16
c3105 2126 220 7.91e-16
c3106 1981 215 7.76e-16
c3107 0 359 2.957e-15
c3108 2299 2443 1.96e-16
c3109 399 188 2.5e-16
c3110 396 191 2.13e-16
c3111 397 190 2.14e-16
c3112 398 189 2.8e-16
c3113 394 194 2.5e-16
c3114 231 136 3.24e-16
c3115 0 869 2.926e-15
c3116 2719 2866 2.4e-16
c3117 2697 2822 9.28e-16
c3118 1 2557 1.79e-16
c3119 989 231 7.76e-16
c3120 1824 198 7.77e-16
c3121 1825 199 7.91e-16
c3122 1826 196 7.23e-16
c3123 1827 197 7.91e-16
c3124 1 1811 1.6e-16
c3125 2555 2552 1.154e-15
c3126 2407 2390 3.92e-16
c3127 122 84 1.58e-16
c3128 101 94 1.58e-16
c3129 80 88 3.02e-16
c3130 14 226 3.34e-16
c3131 2299 2305 7.84e-16
c3132 1008 238 7.77e-16
c3133 1009 239 7.91e-16
c3134 1010 236 7.23e-16
c3135 1011 237 7.91e-16
c3136 1968 207 2.13e-16
c3137 1970 205 2.5e-16
c3138 29 31 3.92e-16
c3139 2645 2358 7.3e-16
c3140 2312 2735 8.78e-16
c3141 2305 2740 3.92e-16
c3142 142 239 1.94e-16
c3143 1 2123 1.6e-16
c3144 1556 1557 6.77e-16
c3145 1035 195 2.8e-16
c3146 1039 189 7.23e-16
c3147 1037 191 7.76e-16
c3148 1 2650 6.31e-16
c3149 8 27 3.47e-16
c3150 0 1936 2.957e-15
c3151 80 40 2.44e-16
c3152 1 1446 1.6e-16
c3153 14 204 1.99e-16
c3154 0 337 2.623e-15
c3155 451 450 6.77e-16
c3156 2315 2302 1.6e-16
c3157 1891 229 7.91e-16
c3158 20 194 1.99e-16
c3159 14 199 1.94e-16
c3160 0 649 2.623e-15
c3161 2318 2333 1.96e-16
c3162 0 1590 2.623e-15
c3163 1595 218 7.91e-16
c3164 1109 233 2.14e-16
c3165 1732 225 8.32e-16
c3166 662 202 2.8e-16
c3167 2322 184 7.35e-16
c3168 0 1140 2.585e-15
c3169 0 961 2.623e-15
c3170 31 212 3.34e-16
c3171 763 762 6.77e-16
c3172 2630 2572 1.58e-16
c3173 1273 1272 6.77e-16
c3174 0 301 2.926e-15
c3175 0 959 2.957e-15
c3176 2619 242 4.83e-16
c3177 521 520 6.77e-16
c3178 807 210 7.23e-16
c3179 0 1402 2.957e-15
c3180 212 450 7.23e-16
c3181 0 1897 2.623e-15
c3182 1 798 1.6e-16
c3183 69 225 3.31e-16
c3184 1722 219 7.23e-16
c3185 2224 0 2.957e-15
c3186 1871 221 7.23e-16
c3187 1870 220 7.91e-16
c3188 2467 2444 1.7e-16
c3189 242 115 1.99e-16
c3190 1 283 1.6e-16
c3191 0 1714 2.957e-15
c3192 1568 198 7.77e-16
c3193 1569 199 7.91e-16
c3194 1570 196 7.23e-16
c3195 1571 197 7.91e-16
c3196 1254 1255 6.77e-16
c3197 143 23 3.31e-16
c3198 1 1110 1.6e-16
c3199 214 100 1.9e-16
c3200 212 94 3.34e-16
c3201 2649 2462 1.96e-16
c3202 2643 2460 1.96e-16
c3203 2647 2508 1.96e-16
c3204 2639 2420 1.96e-16
c3205 436 216 2.13e-16
c3206 2190 2191 6.77e-16
c3207 833 832 6.77e-16
c3208 63 206 3.31e-16
c3209 1496 232 2.13e-16
c3210 225 168 1.9e-16
c3211 223 153 1.94e-16
c3212 1 1867 1.6e-16
c3213 214 577 2.54e-16
c3214 779 195 2.8e-16
c3215 783 189 7.23e-16
c3216 781 191 7.76e-16
c3217 0 1351 2.957e-15
c3218 1774 1775 6.77e-16
c3219 243 359 2.5e-16
c3220 69 198 1.9e-16
c3221 63 201 1.9e-16
c3222 870 242 2.8e-16
c3223 1291 194 7.91e-16
c3224 1294 188 7.91e-16
c3225 1292 190 8.32e-16
c3226 0 1861 2.926e-15
c3227 2377 2373 6.13e-16
c3228 265 192 7.91e-16
c3229 2384 195 9.65e-16
c3230 2759 2758 1.58e-16
c3231 2805 2757 2.48e-16
c3232 2471 2294 5.5e-16
c3233 2298 2637 1.58e-16
c3234 2634 2312 3.54e-16
c3235 2665 2318 6.07e-16
c3236 2296 2333 1.58e-16
c3237 1076 217 8.32e-16
c3238 1077 216 7.76e-16
c3239 38 43 1.34e-16
c3240 2201 201 2.54e-16
c3241 2200 200 2.13e-16
c3242 1145 1144 6.77e-16
c3243 2037 185 2.14e-16
c3244 2780 143 1.6e-16
c3245 2781 2770 2.21e-16
c3246 207 163 1.94e-16
c3247 2137 233 2.54e-16
c3248 2351 2587 1.96e-16
c3249 2358 2407 1.58e-16
c3250 393 392 6.77e-16
c3251 0 1066 2.957e-15
c3252 1216 214 7.77e-16
c3253 2086 2087 6.77e-16
c3254 1 1497 1.6e-16
c3255 198 168 3.31e-16
c3256 202 163 3.34e-16
c3257 2635 2409 3.54e-16
c3258 1988 224 2.13e-16
c3259 406 202 2.8e-16
c3260 0 374 2.623e-15
c3261 206 105 3.31e-16
c3262 0 884 2.585e-15
c3263 2546 223 2.186e-15
c3264 2369 192 3.8e-16
c3265 2289 239 7.91e-16
c3266 3 183 3.08e-16
c3267 0 125 1.14e-16
c3268 211 132 3.34e-16
c3269 121 195 3.34e-16
c3270 210 126 1.99e-16
c3271 115 192 1.94e-16
c3272 111 188 1.99e-16
c3273 105 201 1.9e-16
c3274 2866 0 3.449e-15
c3275 0 1196 2.585e-15
c3276 1 2861 2.775e-15
c3277 1 190 4.537e-15
c3278 0 1641 2.623e-15
c3279 1761 231 7.91e-16
c3280 58 184 3.24e-16
c3281 2434 2444 1.38e-16
c3282 20 214 3.31e-16
c3283 2117 225 2.14e-16
c3284 2389 2594 1.96e-16
c3285 1007 237 7.23e-16
c3286 1005 239 7.76e-16
c3287 1047 202 7.23e-16
c3288 0 1458 2.957e-15
c3289 2156 2157 6.77e-16
c3290 0 1953 2.623e-15
c3291 1962 211 7.23e-16
c3292 2630 2556 2.14e-16
c3293 0 1327 2.957e-15
c3294 1808 190 7.77e-16
c3295 1809 191 7.91e-16
c3296 1810 188 7.23e-16
c3297 1811 189 7.91e-16
c3298 1 1790 1.6e-16
c3299 2800 0 9.754e-15
c3300 143 97 3.31e-16
c3301 2842 2838 2.085e-15
c3302 676 208 2.13e-16
c3303 2343 2318 1.348e-15
c3304 225 328 7.77e-16
c3305 0 1605 2.926e-15
c3306 1 1161 1.6e-16
c3307 1741 223 7.76e-16
c3308 2105 216 7.91e-16
c3309 164 55 4.85e-16
c3310 0 645 2.926e-15
c3311 2298 2630 2.44e-16
c3312 0 483 2.623e-15
c3313 1716 1717 6.77e-16
c3314 147 211 1.99e-16
c3315 142 206 1.9e-16
c3316 136 207 3.24e-16
c3317 1 2102 1.6e-16
c3318 1172 200 2.13e-16
c3319 1019 187 2.8e-16
c3320 1023 181 7.23e-16
c3321 1021 183 7.76e-16
c3322 1 484 1.6e-16
c3323 31 221 3.34e-16
c3324 143 45 3.31e-16
c3325 142 201 3.31e-16
c3326 136 202 1.99e-16
c3327 226 458 2.5e-16
c3328 227 459 2.8e-16
c3329 0 1419 2.623e-15
c3330 0 1305 2.623e-15
c3331 1316 209 8.32e-16
c3332 1317 208 7.76e-16
c3333 1367 235 2.5e-16
c3334 1 1420 1.6e-16
c3335 2241 0 2.623e-15
c3336 2492 2516 3.92e-16
c3337 2490 2515 3.92e-16
c3338 228 174 1.99e-16
c3339 2574 2526 2.19e-16
c3340 2675 2358 1.96e-16
c3341 649 193 2.54e-16
c3342 648 192 2.13e-16
c3343 230 90 1.9e-16
c3344 0 1303 2.957e-15
c3345 686 687 6.77e-16
c3346 27 208 3.24e-16
c3347 31 218 1.99e-16
c3348 2222 0 2.623e-15
c3349 2351 0 1.04112e-13
c3350 1 1553 1.6e-16
c3351 221 94 3.34e-16
c3352 220 84 3.34e-16
c3353 0 228 2.5386e-14
c3354 42 197 3.34e-16
c3355 923 922 6.77e-16
c3356 1563 203 2.8e-16
c3357 1567 197 7.23e-16
c3358 1565 199 7.76e-16
c3359 0 2043 2.623e-15
c3360 2075 202 7.91e-16
c3361 2078 196 7.91e-16
c3362 2076 198 8.32e-16
c3363 1505 231 7.91e-16
c3364 52 233 1.9e-16
c3365 48 235 3.34e-16
c3366 1 2044 1.6e-16
c3367 0 425 2.623e-15
c3368 2590 2566 5.97e-16
c3369 0 1366 2.623e-15
c3370 998 999 6.77e-16
c3371 1706 211 7.23e-16
c3372 2426 203 1.083e-15
c3373 3 238 2.38e-16
c3374 0 88 1.14e-16
c3375 100 216 3.24e-16
c3376 94 218 1.99e-16
c3377 2573 229 4.83e-16
c3378 2420 2416 6.13e-16
c3379 2492 2475 6.08e-16
c3380 0 737 2.623e-15
c3381 775 195 2.5e-16
c3382 2687 2358 3.54e-16
c3383 2296 2343 9.4e-16
c3384 1287 194 7.23e-16
c3385 1 1251 1.6e-16
c3386 2377 2346 1.429e-15
c3387 2382 2360 1.58e-16
c3388 58 239 1.94e-16
c3389 2298 8 1.9e-16
c3390 2144 231 2.13e-16
c3391 212 121 1.99e-16
c3392 215 115 3.24e-16
c3393 1 2187 1.6e-16
c3394 1 2377 7.39e-16
c3395 1 574 1.6e-16
c3396 2171 2170 6.77e-16
c3397 1849 216 7.91e-16
c3398 2645 2572 1.58e-16
c3399 2364 2490 8.01e-16
c3400 2358 2492 3.54e-16
c3401 0 389 2.926e-15
c3402 558 559 6.77e-16
c3403 916 200 2.13e-16
c3404 1755 1754 6.77e-16
c3405 1068 1069 6.77e-16
c3406 58 55 3.92e-16
c3407 316 317 6.77e-16
c3408 14 232 3.24e-16
c3409 1060 209 8.32e-16
c3410 1061 208 7.76e-16
c3411 1622 234 2.8e-16
c3412 2298 2425 1.58e-16
c3413 182 153 1.9e-16
c3414 1 2153 1.6e-16
c3415 703 213 7.23e-16
c3416 702 212 7.91e-16
c3417 0 1030 2.623e-15
c3418 240 484 2.13e-16
c3419 0 1475 2.623e-15
c3420 1974 219 7.91e-16
c3421 0 530 2.957e-15
c3422 1 1476 1.6e-16
c3423 628 629 6.77e-16
c3424 889 185 2.54e-16
c3425 888 184 2.13e-16
c3426 2719 2471 4.18e-16
c3427 794 795 6.77e-16
c3428 1776 238 7.77e-16
c3429 1777 239 7.91e-16
c3430 1778 236 7.23e-16
c3431 1779 237 7.91e-16
c3432 2278 0 2.623e-15
c3433 20 216 1.94e-16
c3434 0 348 2.585e-15
c3435 0 842 2.957e-15
c3436 2687 2700 3.47e-16
c3437 1 683 1.6e-16
c3438 0 1620 2.585e-15
c3439 1900 1901 6.77e-16
c3440 1125 240 7.76e-16
c3441 0 660 2.585e-15
c3442 2649 2635 5.88e-16
c3443 2643 2651 5.88e-16
c3444 2409 210 5.7e-16
c3445 0 1154 2.957e-15
c3446 940 941 6.77e-16
c3447 2137 2136 6.77e-16
c3448 1 995 1.6e-16
c3449 1385 1384 6.77e-16
c3450 0 972 2.585e-15
c3451 221 467 7.91e-16
c3452 960 215 2.13e-16
c3453 1375 229 7.23e-16
c3454 1374 228 7.91e-16
c3455 63 233 1.9e-16
c3456 1792 182 7.77e-16
c3457 1793 183 7.91e-16
c3458 1794 180 7.23e-16
c3459 1795 181 7.91e-16
c3460 1877 233 2.14e-16
c3461 2510 2498 3.22e-16
c3462 2508 2474 6.99e-16
c3463 2305 2394 1.96e-16
c3464 2505 2484 1.58e-16
c3465 2733 0 1.9596e-14
c3466 1460 1461 6.77e-16
c3467 2471 2587 2.44e-16
c3468 1 313 1.6e-16
c3469 0 1729 2.623e-15
c3470 1 2757 1.935e-15
c3471 1576 209 7.77e-16
c3472 2237 0 2.926e-15
c3473 2632 2519 1.9e-16
c3474 645 193 2.14e-16
c3475 1697 1696 6.77e-16
c3476 2639 2377 1.96e-16
c3477 2641 2379 1.96e-16
c3478 2389 2490 2.32e-16
c3479 2299 2420 1.73e-16
c3480 2299 2562 6.36e-16
c3481 1 2735 7.06e-16
c3482 1 625 1.6e-16
c3483 1099 226 7.91e-16
c3484 0 2056 2.957e-15
c3485 48 242 3.34e-16
c3486 2299 2557 7.84e-16
c3487 234 163 3.34e-16
c3488 223 593 7.91e-16
c3489 221 220 6.86e-16
c3490 750 236 7.91e-16
c3491 748 238 8.32e-16
c3492 0 1381 2.926e-15
c3493 1 937 1.6e-16
c3494 1501 231 7.76e-16
c3495 2214 211 7.91e-16
c3496 0 259 2.623e-15
c3497 1 1878 1.6e-16
c3498 2798 2760 1.96e-16
c3499 233 105 1.9e-16
c3500 1 260 1.6e-16
c3501 667 666 6.77e-16
c3502 0 1693 2.926e-15
c3503 31 185 1.9e-16
c3504 1520 238 7.77e-16
c3505 1521 239 7.91e-16
c3506 1522 236 7.23e-16
c3507 1523 237 7.91e-16
c3508 168 166 3.92e-16
c3509 2298 2645 6.99e-16
c3510 0 586 2.957e-15
c3511 237 153 1.99e-16
c3512 2153 240 7.91e-16
c3513 3 227 3.48e-16
c3514 221 121 1.99e-16
c3515 720 222 7.77e-16
c3516 0 1081 2.623e-15
c3517 38 39 1.34e-16
c3518 1232 223 2.13e-16
c3519 1547 195 2.8e-16
c3520 1551 189 7.23e-16
c3521 1549 191 7.76e-16
c3522 2140 230 8.32e-16
c3523 219 178 1.99e-16
c3524 2312 2625 2.83e-16
c3525 2651 2548 2.1e-16
c3526 2643 2585 1.96e-16
c3527 2647 2632 1.96e-16
c3528 2351 2543 1.96e-16
c3529 0 404 2.585e-15
c3530 143 141 6.74e-16
c3531 90 209 3.31e-16
c3532 1 2599 1.79e-16
c3533 763 186 7.91e-16
c3534 766 180 7.91e-16
c3535 764 182 8.32e-16
c3536 1272 185 7.77e-16
c3537 1844 217 8.32e-16
c3538 1845 216 7.76e-16
c3539 979 978 6.77e-16
c3540 3 205 6.13e-16
c3541 218 121 3.34e-16
c3542 100 183 1.94e-16
c3543 94 185 1.9e-16
c3544 90 203 3.34e-16
c3545 84 186 1.99e-16
c3546 0 716 2.585e-15
c3547 2279 242 7.23e-16
c3548 2278 243 7.91e-16
c3549 164 34 4.85e-16
c3550 1 1230 1.6e-16
c3551 3 200 3.08e-16
c3552 1 1675 1.6e-16
c3553 58 206 1.9e-16
c3554 101 8 1.65e-15
c3555 1678 1679 6.77e-16
c3556 710 226 2.8e-16
c3557 0 1045 2.926e-15
c3558 143 31 3.26e-16
c3559 812 813 6.77e-16
c3560 58 201 3.31e-16
c3561 48 192 3.24e-16
c3562 52 190 3.31e-16
c3563 1 1987 1.6e-16
c3564 2299 2444 1.196e-15
c3565 389 193 2.14e-16
c3566 1056 199 2.13e-16
c3567 2535 224 3.8e-16
c3568 233 142 3.31e-16
c3569 234 136 1.99e-16
c3570 900 192 2.13e-16
c3571 0 1471 2.957e-15
c3572 2675 2856 2.03e-16
c3573 0 1800 2.957e-15
c3574 1049 1048 6.77e-16
c3575 1816 201 7.77e-16
c3576 2336 182 1.114e-15
c3577 2592 2584 6.67e-16
c3578 297 296 6.77e-16
c3579 2471 0 5.248e-14
c3580 101 92 2.44e-16
c3581 122 79 1.58e-16
c3582 223 337 7.91e-16
c3583 1990 1991 6.77e-16
c3584 1 2634 4.724e-15
c3585 1815 202 7.23e-16
c3586 0 2112 2.957e-15
c3587 1124 1125 6.77e-16
c3588 143 94 3.26e-16
c3589 2318 2294 1.152e-15
c3590 222 333 2.14e-16
c3591 0 1171 2.623e-15
c3592 8 29 1.96e-16
c3593 1 1172 1.6e-16
c3594 27 235 3.34e-16
c3595 31 231 3.24e-16
c3596 1 1617 1.6e-16
c3597 0 494 2.623e-15
c3598 1 1934 1.6e-16
c3599 609 608 6.77e-16
c3600 1 2504 7.03e-16
c3601 1 139 2.79e-16
c3602 969 224 7.91e-16
c3603 1382 242 2.8e-16
c3604 1884 230 8.32e-16
c3605 20 183 3.24e-16
c3606 14 188 1.99e-16
c3607 1550 1551 6.77e-16
c3608 2545 2535 1.13e-16
c3609 2592 2522 6.2e-16
c3610 2625 2551 1.34e-16
c3611 2320 2308 3.92e-16
c3612 221 463 7.23e-16
c3613 220 462 7.91e-16
c3614 0 823 2.957e-15
c3615 826 218 2.5e-16
c3616 2820 2821 5.9e-16
c3617 0 1316 2.585e-15
c3618 1588 217 8.32e-16
c3619 1589 216 7.76e-16
c3620 2252 0 2.585e-15
c3621 2592 2517 4.56e-16
c3622 2320 2302 3.15e-16
c3623 8 84 2.3e-16
c3624 2240 215 2.13e-16
c3625 231 94 3.24e-16
c3626 2634 2648 1.6e-16
c3627 2655 2490 1.58e-16
c3628 2298 2407 1.58e-16
c3629 503 187 2.5e-16
c3630 0 1135 2.957e-15
c3631 0 1563 2.623e-15
c3632 0 2073 2.623e-15
c3633 1920 183 2.13e-16
c3634 1922 181 2.5e-16
c3635 1 1564 1.6e-16
c3636 2452 208 3.8e-16
c3637 241 163 3.31e-16
c3638 306 205 2.5e-16
c3639 304 207 2.13e-16
c3640 1 459 1.6e-16
c3641 0 1396 2.585e-15
c3642 0 1890 2.957e-15
c3643 1718 218 2.8e-16
c3644 2492 2572 1.694e-15
c3645 0 272 2.957e-15
c3646 238 100 1.9e-16
c3647 244 245 6.77e-16
c3648 2460 2436 1.713e-15
c3649 2508 2429 1.17e-16
c3650 800 199 2.13e-16
c3651 802 197 2.5e-16
c3652 1441 1440 6.77e-16
c3653 2787 122 1.474e-15
c3654 1 771 1.6e-16
c3655 0 1708 2.585e-15
c3656 1 1281 1.6e-16
c3657 2427 2415 3.22e-16
c3658 2296 2294 1.227e-15
c3659 629 185 2.14e-16
c3660 1519 237 7.23e-16
c3661 1517 239 7.76e-16
c3662 2030 236 7.91e-16
c3663 2028 238 8.32e-16
c3664 2056 193 7.77e-16
c3665 2647 2550 1.96e-16
c3666 2312 2545 8.78e-16
c3667 2643 2503 1.96e-16
c3668 2305 2592 3.37e-16
c3669 226 153 3.34e-16
c3670 0 915 2.623e-15
c3671 63 190 3.31e-16
c3672 1 916 1.6e-16
c3673 48 215 1.94e-16
c3674 2163 236 2.8e-16
c3675 759 186 7.23e-16
c3676 2634 2639 3.91e-16
c3677 827 826 6.77e-16
c3678 859 234 7.91e-16
c3679 713 224 7.91e-16
c3680 204 153 1.99e-16
c3681 2767 2786 5.77e-16
c3682 2771 2781 1.097e-15
c3683 15 8 2.61e-16
c3684 0 550 2.623e-15
c3685 561 206 2.54e-16
c3686 563 204 2.8e-16
c3687 1 2164 1.6e-16
c3688 0 1060 2.585e-15
c3689 902 903 6.77e-16
c3690 1212 215 2.13e-16
c3691 1531 187 2.8e-16
c3692 1535 181 7.23e-16
c3693 1533 183 7.76e-16
c3694 1141 1140 6.77e-16
c3695 199 153 1.94e-16
c3696 191 163 1.94e-16
c3697 0 545 2.623e-15
c3698 2630 2598 6.99e-16
c3699 0 879 2.957e-15
c3700 2547 225 1.207e-15
c3701 241 136 1.9e-16
c3702 0 1486 2.623e-15
c3703 1139 1138 6.77e-16
c3704 80 61 2.44e-16
c3705 1472 214 7.77e-16
c3706 20 238 3.31e-16
c3707 121 185 3.31e-16
c3708 115 181 3.34e-16
c3709 105 190 3.31e-16
c3710 0 857 2.623e-15
c3711 1735 1734 6.77e-16
c3712 1 124 2.79e-16
c3713 1200 206 7.77e-16
c3714 1201 207 7.91e-16
c3715 1202 204 7.23e-16
c3716 1203 205 7.91e-16
c3717 1 2859 1.6e-16
c3718 0 1634 2.957e-15
c3719 18 0 1.14e-16
c3720 0 2129 2.623e-15
c3721 195 132 3.34e-16
c3722 194 126 1.99e-16
c3723 1214 1215 6.77e-16
c3724 462 463 6.77e-16
c3725 2761 2635 2.44e-16
c3726 0 1184 2.957e-15
c3727 1659 1658 6.77e-16
c3728 1 2669 2.88e-16
c3729 1 694 1.6e-16
c3730 27 242 3.34e-16
c3731 1610 227 7.23e-16
c3732 1958 210 2.8e-16
c3733 2429 2437 1.6e-16
c3734 0 509 2.926e-15
c3735 164 173 6.55e-16
c3736 233 473 2.54e-16
c3737 1 1006 1.6e-16
c3738 1800 193 7.77e-16
c3739 1893 240 7.76e-16
c3740 2574 2566 2e-16
c3741 2630 2569 1.34e-16
c3742 2641 2637 7.84e-16
c3743 224 324 2.13e-16
c3744 774 775 6.77e-16
c3745 1 2785 2.89e-16
c3746 1799 194 7.23e-16
c3747 1971 1970 6.77e-16
c3748 1284 1285 6.77e-16
c3749 1 1763 1.6e-16
c3750 2758 0 1.1295e-14
c3751 143 121 3.26e-16
c3752 2249 224 7.91e-16
c3753 2299 2377 3.66e-16
c3754 2471 2543 1.58e-16
c3755 1 2782 2.94e-16
c3756 234 603 7.91e-16
c3757 0 1576 2.957e-15
c3758 1728 215 2.13e-16
c3759 1934 189 2.8e-16
c3760 1933 190 2.14e-16
c3761 1932 191 2.13e-16
c3762 1935 188 2.5e-16
c3763 2236 214 8.32e-16
c3764 2364 2379 1.96e-16
c3765 2305 2382 1.96e-16
c3766 2298 2492 1.58e-16
c3767 147 195 1.99e-16
c3768 142 190 1.9e-16
c3769 136 191 3.24e-16
c3770 8 2598 1.789e-15
c3771 225 453 2.14e-16
c3772 1102 221 2.8e-16
c3773 1428 200 2.13e-16
c3774 0 1907 2.623e-15
c3775 0 289 2.623e-15
c3776 1 1908 1.6e-16
c3777 230 178 3.31e-16
c3778 298 211 7.23e-16
c3779 15 24 3.02e-16
c3780 2652 2647 5.88e-16
c3781 1142 187 7.91e-16
c3782 31 207 3.24e-16
c3783 73 213 3.34e-16
c3784 1242 234 2.5e-16
c3785 1243 235 2.8e-16
c3786 2804 2799 6.55e-16
c3787 0 601 2.623e-15
c3788 2621 236 1.54e-16
c3789 231 121 1.94e-16
c3790 227 100 3.34e-16
c3791 220 79 1.99e-16
c3792 27 192 3.24e-16
c3793 31 202 1.99e-16
c3794 944 206 7.77e-16
c3795 945 207 7.91e-16
c3796 946 204 7.23e-16
c3797 947 205 7.91e-16
c3798 0 1542 2.623e-15
c3799 2068 201 8.32e-16
c3800 2069 200 7.76e-16
c3801 2635 2510 3.53e-16
c3802 2351 2460 2.83e-16
c3803 2651 2465 1.96e-16
c3804 58 233 3.31e-16
c3805 0 418 2.957e-15
c3806 1401 185 2.54e-16
c3807 1400 184 2.13e-16
c3808 1156 1157 6.77e-16
c3809 1702 210 2.8e-16
c3810 236 115 3.34e-16
c3811 100 205 1.99e-16
c3812 94 207 3.24e-16
c3813 0 90 7.8194e-14
c3814 84 208 1.94e-16
c3815 2338 2313 2.86e-16
c3816 2757 6 2e-16
c3817 0 730 2.957e-15
c3818 1 2386 1.79e-16
c3819 228 355 2.8e-16
c3820 229 354 2.5e-16
c3821 0 1240 2.957e-15
c3822 1918 1919 6.77e-16
c3823 0 2176 2.957e-15
c3824 100 200 3.24e-16
c3825 94 202 1.99e-16
c3826 2467 2386 2.4e-16
c3827 1637 240 7.76e-16
c3828 0 565 2.926e-15
c3829 2318 2587 1.96e-16
c3830 2641 2630 1.96e-16
c3831 1 3 2.7224e-14
c3832 122 37 1.58e-16
c3833 1 1507 1.6e-16
c3834 212 132 1.99e-16
c3835 214 126 3.31e-16
c3836 2649 2409 3.54e-16
c3837 1 2017 1.6e-16
c3838 1 1057 1.6e-16
c3839 1481 225 2.54e-16
c3840 2376 195 3.61e-16
c3841 0 360 2.957e-15
c3842 2300 0 1.0394e-14
c3843 1 1819 1.6e-16
c3844 2719 2296 8.81e-16
c3845 846 221 2.8e-16
c3846 1211 218 7.91e-16
c3847 0 1813 2.926e-15
c3848 0 706 2.957e-15
c3849 1 1652 1.6e-16
c3850 20 227 1.99e-16
c3851 2755 2746 3.31e-16
c3852 883 882 6.77e-16
c3853 0 2125 2.926e-15
c3854 1618 221 2.5e-16
c3855 1619 220 2.8e-16
c3856 2659 0 1.65e-16
c3857 2740 2735 1.225e-15
c3858 0 524 2.585e-15
c3859 538 203 7.23e-16
c3860 2113 214 2.54e-16
c3861 0 1018 2.957e-15
c3862 1 1964 1.6e-16
c3863 372 184 2.13e-16
c3864 1041 190 2.54e-16
c3865 1 2625 4.49e-16
c3866 42 228 3.34e-16
c3867 1 1449 1.6e-16
c3868 2110 213 2.8e-16
c3869 20 205 3.34e-16
c3870 0 343 2.957e-15
c3871 212 147 3.34e-16
c3872 0 836 2.585e-15
c3873 972 223 2.13e-16
c3874 2266 0 2.957e-15
c3875 20 200 1.94e-16
c3876 2298 2293 1.96e-16
c3877 2632 2559 4.09e-16
c3878 2627 2552 4.61e-16
c3879 1195 1194 6.77e-16
c3880 2850 2298 6.33e-16
c3881 0 655 2.957e-15
c3882 2641 8 4.03e-16
c3883 2305 2333 1.893e-15
c3884 2647 2338 1.96e-16
c3885 2364 2384 8.78e-16
c3886 2637 2590 1.96e-16
c3887 443 442 6.77e-16
c3888 2296 2587 1.58e-16
c3889 0 1148 2.585e-15
c3890 0 1593 2.623e-15
c3891 1112 232 2.13e-16
c3892 2299 2599 7.84e-16
c3893 0 967 2.957e-15
c3895 27 215 1.94e-16
c3896 1926 195 7.91e-16
c3897 1784 185 7.77e-16
c3898 310 219 7.91e-16
c3899 2508 2475 6.33e-16
c3900 2505 2485 2.8e-16
c3901 40 42 3.92e-16
c3902 243 90 3.34e-16
c3903 755 754 6.77e-16
c3904 1 801 1.6e-16
c3905 73 222 3.31e-16
c3906 0 1722 2.957e-15
c3907 1265 1264 6.77e-16
c3908 2235 219 2.8e-16
c3909 2550 2474 1.996e-15
c3910 2462 2433 1.58e-16
c3911 2585 2521 2.62e-16
c3912 2318 0 1.04837e-13
c3913 513 512 6.77e-16
c3914 38 59 4.17e-16
c3915 2779 80 1.58e-16
c3916 2637 2422 1.96e-16
c3917 2641 2425 1.96e-16
c3918 3 240 3.08e-16
c3919 2201 2200 6.77e-16
c3920 1092 225 8.32e-16
c3921 1 1113 1.6e-16
c3922 2521 2512 1.6e-16
c3923 2358 2508 1.96e-16
c3924 2312 2462 1.96e-16
c3925 0 435 2.623e-15
c3926 1 2054 1.6e-16
c3927 232 153 3.24e-16
c3928 588 589 6.77e-16
c3929 939 211 2.8e-16
c3930 943 205 7.23e-16
c3931 941 207 7.76e-16
c3932 1412 192 2.13e-16
c3933 69 211 3.34e-16
c3934 73 217 1.9e-16
c3935 1785 1784 6.77e-16
c3936 1 436 1.6e-16
c3937 0 1869 2.926e-15
c3938 1 66 2.79e-16
c3939 220 157 3.34e-16
c3940 0 926 2.623e-15
c3941 0 747 2.623e-15
c3942 785 190 2.54e-16
c3943 787 188 2.8e-16
c3944 0 1352 2.957e-15
c3945 2789 2759 8.09e-16
c3946 242 363 7.91e-16
c3947 872 241 7.77e-16
c3948 0 1257 2.623e-15
c3949 1 748 1.6e-16
c3950 1343 212 2.5e-16
c3951 2193 0 2.623e-15
c3952 1854 213 2.8e-16
c3953 1766 1767 6.77e-16
c3954 2798 2786 1.96e-16
c3955 2709 2635 4.14e-16
c3956 2665 2305 3.54e-16
c3957 225 115 1.9e-16
c3958 0 1074 2.957e-15
c3959 716 223 2.13e-16
c3960 1 224 3.792e-15
c3961 0 2174 2.623e-15
c3962 2041 184 7.91e-16
c3963 2097 2096 6.77e-16
c3964 211 168 1.99e-16
c3965 209 178 1.9e-16
c3966 221 132 1.99e-16
c3967 2639 2625 1.96e-16
c3968 0 2010 2.957e-15
c3969 1635 228 2.8e-16
c3970 2361 2348 1.6e-16
c3971 203 178 1.99e-16
c3972 0 377 2.623e-15
c3973 408 201 7.77e-16
c3974 207 121 1.94e-16
c3975 90 193 3.31e-16
c3976 79 186 3.34e-16
c3977 80 76 5.88e-16
c3978 1 891 1.6e-16
c3979 1980 215 2.13e-16
c3980 218 132 3.34e-16
c3981 121 202 3.34e-16
c3982 216 126 1.94e-16
c3983 115 198 3.31e-16
c3984 2296 0 7.0824e-14
c3985 3 189 6.13e-16
c3986 2655 2379 1.96e-16
c3987 1207 218 7.23e-16
c3988 1 196 3.719e-15
c3989 0 1647 2.957e-15
c3990 1 2690 2.88e-16
c3991 1 1203 1.6e-16
c3992 0 2140 2.585e-15
c3993 58 190 1.9e-16
c3994 48 181 1.99e-16
c3995 2682 0 1.65e-16
c3996 143 8 2.345e-15
c3997 2120 224 2.13e-16
c3998 1 2545 2.41e-15
c3999 983 235 2.5e-16
c4000 0 1959 2.957e-15
c4001 1615 220 2.5e-16
c4002 2377 2322 2.36e-16
c4003 230 476 8.32e-16
c4004 221 147 3.34e-16
c4005 0 1328 2.957e-15
c4006 1 1793 1.6e-16
c4007 2499 212 1.54e-16
c4008 143 92 3.31e-16
c4009 122 111 1.58e-16
c4010 0 670 2.623e-15
c4011 2637 2364 1.443e-15
c4012 2641 2645 6.36e-16
c4013 2343 2305 8.32e-16
c4014 241 616 7.77e-16
c4015 31 234 1.99e-16
c4016 2252 223 2.13e-16
c4017 2590 8 2.83e-16
c4018 2651 2351 1.176e-15
c4019 0 137 1.82e-16
c4020 522 195 7.23e-16
c4021 147 218 1.99e-16
c4022 1 2105 1.6e-16
c4023 0 982 2.623e-15
c4024 606 229 2.8e-16
c4025 0 1427 2.623e-15
c4026 37 220 1.99e-16
c4027 1 1428 1.6e-16
c4028 821 217 2.14e-16
c4029 2825 2824 6.68e-16
c4031 0 1311 2.957e-15
c4032 1 323 1.6e-16
c4033 697 696 6.77e-16
c4034 746 242 2.5e-16
c4035 747 243 2.8e-16
c4036 1371 234 7.91e-16
c4037 0 1739 2.623e-15
c4038 2247 0 2.957e-15
c4039 0 300 2.585e-15
c4040 1 1740 1.6e-16
c4041 8 79 3.47e-16
c4042 234 94 1.99e-16
c4043 235 84 1.99e-16
c4044 1247 229 7.23e-16
c4045 1246 228 7.91e-16
c4046 0 2066 2.957e-15
c4047 0 612 2.585e-15
c4048 8 2422 5.14e-16
c4049 0 448 2.957e-15
c4050 0 1106 2.957e-15
c4051 678 679 6.77e-16
c4052 951 218 7.23e-16
c4053 0 1391 2.957e-15
c4054 1 947 1.6e-16
c4055 0 1884 2.585e-15
c4056 1009 1008 6.77e-16
c4057 2018 228 7.23e-16
c4058 0 431 2.957e-15
c4059 1864 224 2.13e-16
c4060 0 760 2.957e-15
c4061 0 1369 2.623e-15
c4062 1090 212 7.23e-16
c4063 1 270 1.6e-16
c4064 0 1703 2.957e-15
c4065 1351 226 7.23e-16
c4066 1350 227 7.91e-16
c4067 1712 206 7.77e-16
c4068 1713 207 7.91e-16
c4069 1714 204 7.23e-16
c4070 1715 205 7.91e-16
c4071 2492 2473 3.92e-16
c4072 213 174 1.99e-16
c4073 2508 2428 1.09e-16
c4074 0 743 2.957e-15
c4075 2764 2781 4.2e-16
c4076 142 139 3.92e-16
c4077 0 1253 2.926e-15
c4078 1 100 7.6e-16
c4079 990 991 6.77e-16
c4080 0 2189 2.926e-15
c4081 48 236 1.99e-16
c4082 2725 0 1.65e-16
c4083 1435 1434 6.77e-16
c4084 2639 2545 1.96e-16
c4085 2318 2543 1.076e-15
c4086 2364 2630 3.47e-16
c4087 0 213 2.3945e-14
c4088 569 568 6.77e-16
c4089 1 577 1.6e-16
c4090 73 184 1.94e-16
c4091 0 2027 2.623e-15
c4092 1 1518 1.6e-16
c4093 1 1339 1.6e-16
c4094 2257 2256 6.77e-16
c4095 2351 2585 1.96e-16
c4096 1 2028 1.6e-16
c4097 2585 228 8.84e-16
c4098 1 1849 1.6e-16
c4099 258 181 2.5e-16
c4100 256 183 2.13e-16
c4101 1510 1511 6.77e-16
c4102 2655 2384 1.96e-16
c4103 2389 2637 1.58e-16
c4104 1 2359 1.947e-15
c4105 852 233 8.32e-16
c4106 1 2827 1.421e-15
c4107 1484 222 8.32e-16
c4108 2020 2021 6.77e-16
c4109 2351 2512 1.96e-16
c4110 1 1830 1.6e-16
c4111 2275 229 7.91e-16
c4112 1747 1746 6.77e-16
c4113 1 2334 7.03e-16
c4114 553 209 2.54e-16
c4115 552 208 2.13e-16
c4116 2641 2407 1.58e-16
c4117 0 1662 2.623e-15
c4118 1624 233 7.77e-16
c4119 186 157 1.99e-16
c4120 188 153 1.99e-16
c4121 0 538 2.957e-15
c4122 2129 223 7.91e-16
c4123 180 163 1.99e-16
c4124 0 1033 2.623e-15
c4125 1822 1823 6.77e-16
c4126 0 1974 2.623e-15
c4127 1979 218 7.91e-16
c4128 2574 2608 3.92e-16
c4129 2630 2611 1.34e-16
c4130 2492 221 5.64e-16
c4131 0 850 2.957e-15
c4132 2827 2845 1.96e-16
c4133 1192 209 7.77e-16
c4134 2281 0 2.623e-15
c4135 6 3 1.086e-14
c4136 1754 234 2.5e-16
c4137 1755 235 2.8e-16
c4138 185 132 3.31e-16
c4139 183 126 3.24e-16
c4140 2779 0 1.3548e-14
c4141 0 685 2.926e-15
c4142 1 20 7.6e-16
c4143 499 236 2.8e-16
c4144 834 212 7.23e-16
c4145 1191 210 7.23e-16
c4146 1 19 8.37e-16
c4147 1456 206 7.77e-16
c4148 1457 207 7.91e-16
c4149 1458 204 7.23e-16
c4150 1459 205 7.91e-16
c4151 31 241 1.9e-16
c4152 1 1182 1.6e-16
c4153 1 1627 1.6e-16
c4154 2364 8 1.78e-16
c4155 2645 2590 1.96e-16
c4156 2492 218 5.7e-16
c4157 2296 2543 1.58e-16
c4158 164 167 1.34e-16
c4159 0 997 2.926e-15
c4160 1892 1893 6.77e-16
c4161 1117 231 7.76e-16
c4162 1322 210 2.5e-16
c4163 1326 205 2.8e-16
c4164 1325 206 2.14e-16
c4165 1324 207 2.13e-16
c4166 1327 204 2.5e-16
c4167 1952 198 7.77e-16
c4168 1953 199 7.91e-16
c4169 1954 196 7.23e-16
c4170 1955 197 7.91e-16
c4171 2505 2490 4.94e-16
c4172 2299 2386 4.02e-16
c4173 0 1752 2.957e-15
c4174 1735 227 2.5e-16
c4175 2096 207 2.13e-16
c4176 2098 205 2.5e-16
c4177 0 811 2.623e-15
c4178 240 100 3.24e-16
c4179 241 94 1.9e-16
c4180 242 84 1.99e-16
c4181 2389 2630 4.18e-16
c4182 743 243 2.5e-16
c4183 1163 195 2.8e-16
c4184 1167 189 7.23e-16
c4185 1165 191 7.76e-16
c4186 1 633 1.6e-16
c4187 1254 242 2.8e-16
c4188 1452 1453 6.77e-16
c4189 143 132 3.26e-16
c4190 1 1574 1.6e-16
c4191 2645 2422 1.96e-16
c4192 2364 2425 1.96e-16
c4193 0 465 2.623e-15
c4194 147 185 1.9e-16
c4195 136 180 3.34e-16
c4196 0 1123 2.623e-15
c4197 0 1406 2.623e-15
c4198 73 239 3.24e-16
c4199 0 446 2.623e-15
c4200 2026 242 2.5e-16
c4201 2027 243 2.8e-16
c4202 8 157 2.3e-16
c4203 347 346 6.77e-16
c4204 294 210 2.8e-16
c4205 2654 2343 1.96e-16
c4206 2697 2637 1.96e-16
c4207 2675 2641 1.96e-16
c4208 1358 221 2.8e-16
c4209 1 1291 1.6e-16
c4210 2219 210 7.91e-16
c4211 2222 204 7.91e-16
c4212 2220 206 8.32e-16
c4213 1 1881 1.6e-16
c4214 222 174 1.9e-16
c4215 2727 0 1.65e-16
c4216 0 758 2.623e-15
c4217 790 202 2.8e-16
c4218 234 121 3.34e-16
c4219 223 90 1.94e-16
c4220 0 1268 2.585e-15
c4221 1301 201 2.14e-16
c4222 1619 1618 6.77e-16
c4223 37 186 3.34e-16
c4224 27 181 1.99e-16
c4225 31 191 3.24e-16
c4226 2204 0 2.585e-15
c4227 0 222 2.4422e-14
c4228 231 132 1.94e-16
c4229 220 111 1.99e-16
c4230 2299 2625 4.18e-16
c4231 0 1087 2.957e-15
c4232 423 211 2.5e-16
c4233 164 139 4.85e-16
c4234 659 658 6.77e-16
c4235 0 1530 2.957e-15
c4236 0 178 7.7837e-14
c4237 217 174 3.31e-16
c4238 2358 2632 2.12e-16
c4239 2351 2503 3.53e-16
c4240 52 224 1.94e-16
c4241 48 225 3.31e-16
c4242 2416 196 1.54e-16
c4243 79 208 3.24e-16
c4244 271 188 2.5e-16
c4245 268 191 2.13e-16
c4246 269 190 2.14e-16
c4247 270 189 2.8e-16
c4248 1 2597 1.424e-15
c4249 2655 2637 7.46e-16
c4250 2687 2641 3.54e-16
c4251 1 411 1.6e-16
c4252 861 231 7.76e-16
c4253 0 1842 2.957e-15
c4254 2412 200 3.8e-16
c4255 0 217 2.4601e-14
c4256 238 126 3.31e-16
c4257 100 189 1.99e-16
c4258 94 191 3.24e-16
c4259 84 192 1.94e-16
c4260 250 187 7.23e-16
c4261 20 240 1.94e-16
c4262 2389 8 5.35e-16
c4263 564 216 2.13e-16
c4264 1 723 1.6e-16
c4265 0 1677 2.926e-15
c4266 971 970 6.77e-16
c4267 1 1233 1.6e-16
c4268 2701 0 1.65e-16
c4269 2379 191 3.57e-16
c4270 2637 2574 4.25e-16
c4271 2641 2492 3.54e-16
c4272 1 2462 7.39e-16
c4273 998 242 2.8e-16
c4274 0 1989 2.926e-15
c4275 48 198 1.9e-16
c4276 52 196 3.34e-16
c4277 2125 223 7.76e-16
c4278 2305 2477 1.96e-16
c4279 393 192 7.91e-16
c4280 8 145 1.96e-16
c4281 0 867 2.623e-15
c4282 1491 1490 6.77e-16
c4283 231 147 3.24e-16
c4284 2823 2822 3.92e-16
c4285 2654 2854 1.58e-16
c4286 804 805 6.77e-16
c4287 1 358 1.6e-16
c4288 1 868 1.6e-16
c4289 2001 2000 6.77e-16
c4290 2625 2613 2.32e-16
c4291 2298 2342 1.96e-16
c4292 2824 0 3.555e-15
c4293 0 700 2.585e-15
c4294 2262 234 2.8e-16
c4295 2732 2647 1.58e-16
c4296 2761 2649 2.568e-15
c4297 2389 2425 9.21e-16
c4298 842 226 2.5e-16
c4299 843 227 2.8e-16
c4300 1751 235 2.5e-16
c4301 2305 2294 1.843e-15
c4302 2364 2645 2.014e-15
c4303 2298 2508 2.28e-16
c4304 0 519 2.957e-15
c4305 494 237 2.8e-16
c4306 493 238 2.14e-16
c4307 492 239 2.13e-16
c4308 495 236 2.5e-16
c4309 534 202 2.8e-16
c4310 2422 2407 1.58e-16
c4311 0 1012 2.585e-15
c4312 1033 193 2.54e-16
c4313 1032 192 2.13e-16
c4314 1 2640 2.88e-16
c4315 8 37 3.47e-16
c4316 1451 211 2.8e-16
c4317 1453 207 7.76e-16
c4318 1116 1117 6.77e-16
c4319 59 57 6.74e-16
c4320 80 55 2.44e-16
c4321 0 497 2.623e-15
c4322 1 1937 1.6e-16
c4323 0 831 2.957e-15
c4324 2853 2854 5.9e-16
c4325 1947 203 2.8e-16
c4326 0 1769 2.623e-15
c4327 1384 241 7.77e-16
c4328 1889 231 7.91e-16
c4329 20 189 3.34e-16
c4330 2260 0 2.585e-15
c4331 2548 2526 3.95e-16
c4332 0 824 2.957e-15
c4333 1 334 1.6e-16
c4334 0 1143 2.957e-15
c4335 1636 1637 6.77e-16
c4336 1135 237 7.23e-16
c4337 1133 239 7.76e-16
c4338 1175 202 7.23e-16
c4339 0 1750 2.623e-15
c4340 27 236 1.99e-16
c4341 0 1586 2.957e-15
c4342 0 2081 2.623e-15
c4343 2090 211 7.23e-16
c4344 2471 2585 2.11e-16
c4345 506 186 2.5e-16
c4346 510 181 2.8e-16
c4347 509 182 2.14e-16
c4348 508 183 2.13e-16
c4349 511 180 2.5e-16
c4350 0 1136 2.957e-15
c4351 1634 1635 6.77e-16
c4352 1873 1872 6.77e-16
c4353 0 2079 2.957e-15
c4354 0 461 2.926e-15
c4355 2471 2512 2.39e-16
c4356 2630 2574 1.58e-16
c4357 243 178 1.99e-16
c4358 164 124 4.85e-16
c4359 804 208 2.13e-16
c4360 214 449 2.54e-16
c4361 1 958 1.6e-16
c4362 1948 1949 6.77e-16
c4363 1 1403 1.6e-16
c4364 1720 217 7.77e-16
c4365 63 224 1.94e-16
c4366 1869 223 7.76e-16
c4367 2503 2489 2.32e-16
c4368 122 14 1.58e-16
c4369 101 9 2.44e-16
c4370 2543 2480 3.15e-16
c4371 2550 2475 2.74e-16
c4372 2462 2434 3.15e-16
c4373 0 773 2.926e-15
c4374 2697 8 2.9e-16
c4375 2764 2804 5.15e-16
c4376 241 121 3.31e-16
c4377 1 2225 1.6e-16
c4378 1 1715 1.6e-16
c4379 215 84 3.24e-16
c4380 2639 2462 1.96e-16
c4381 2343 2420 1.96e-16
c4382 2318 2460 1.96e-16
c4383 2649 2510 1.96e-16
c4384 2299 2545 3.65e-16
c4385 226 586 2.5e-16
c4386 227 587 2.8e-16
c4387 73 206 3.31e-16
c4388 1495 235 2.5e-16
c4389 2358 2550 1.96e-16
c4390 2006 234 2.8e-16
c4391 164 2785 5.77e-16
c4392 241 356 8.32e-16
c4393 69 195 3.34e-16
c4394 73 201 1.9e-16
c4395 63 196 3.34e-16
c4396 868 240 2.13e-16
c4397 0 1859 2.623e-15
c4398 1 1350 1.6e-16
c4399 157 155 3.92e-16
c4400 1 1860 1.6e-16
c4401 262 195 7.91e-16
c4402 2760 2761 1.58e-16
c4403 164 2782 3.94e-16
c4404 2655 8 1.74e-16
c4405 2389 2645 1.58e-16
c4406 1 2381 7.03e-16
c4407 224 105 1.94e-16
c4408 403 402 6.77e-16
c4409 1691 203 2.8e-16
c4410 1695 197 7.23e-16
c4411 1693 199 7.76e-16
c4412 1226 227 7.23e-16
c4413 2161 239 7.91e-16
c4414 2199 203 2.5e-16
c4415 2462 2388 2.74e-16
c4416 2758 2770 8.24e-16
c4417 208 157 1.94e-16
c4418 0 553 2.623e-15
c4419 227 126 1.99e-16
c4420 2364 2407 1.58e-16
c4421 2312 2320 2.59e-16
c4422 879 237 7.23e-16
c4423 0 1494 2.623e-15
c4424 1 1067 1.6e-16
c4425 1629 230 2.14e-16
c4426 0 2004 2.585e-15
c4427 1834 211 7.23e-16
c4428 197 163 1.99e-16
c4429 195 168 1.99e-16
c4430 193 178 1.9e-16
c4431 184 174 3.24e-16
c4432 0 370 2.957e-15
c4433 0 880 2.957e-15
c4434 90 182 1.9e-16
c4435 101 69 1.58e-16
c4436 715 714 6.77e-16
c4437 1225 1224 6.77e-16
c4438 2176 182 7.77e-16
c4439 2177 183 7.91e-16
c4440 2178 180 7.23e-16
c4441 2179 181 7.91e-16
c4442 0 184 2.5772e-14
c4443 207 132 1.94e-16
c4444 121 191 1.94e-16
c4445 205 126 3.34e-16
c4446 111 186 3.34e-16
c4447 105 196 3.34e-16
c4448 473 472 6.77e-16
c4449 2687 2422 3.92e-16
c4450 2655 2425 1.96e-16
c4451 0 1192 2.957e-15
c4452 1 187 3.708e-15
c4453 0 2135 2.957e-15
c4454 202 132 3.34e-16
c4455 200 126 1.94e-16
c4456 1759 229 7.23e-16
c4457 1758 228 7.91e-16
c4458 1414 1415 6.77e-16
c4459 2709 2711 1.6e-16
c4460 2296 2460 1.58e-16
c4461 1044 200 2.13e-16
c4462 895 181 7.23e-16
c4463 1463 218 7.23e-16
c4464 1206 1207 6.77e-16
c4465 1960 209 7.77e-16
c4466 1 1459 1.6e-16
c4467 1651 1650 6.77e-16
c4468 2325 184 3.8e-16
c4469 2630 2555 2.22e-16
c4470 224 142 3.24e-16
c4471 785 784 6.77e-16
c4472 0 1930 2.957e-15
c4473 1 1326 1.6e-16
c4474 2630 2567 1.59e-16
c4475 2789 0 1.187e-15
c4476 122 119 2.32e-16
c4477 0 1158 2.623e-15
c4478 0 1765 2.926e-15
c4479 1 2798 3.53e-16
c4480 0 1603 2.623e-15
c4481 2102 219 7.91e-16
c4482 0 643 2.623e-15
c4483 1 1604 1.6e-16
c4484 2634 2592 5.41e-16
c4485 215 316 2.13e-16
c4486 2471 2503 1.622e-15
c4487 518 194 2.8e-16
c4488 147 207 3.24e-16
c4489 1963 1962 6.77e-16
c4490 1017 185 2.54e-16
c4491 1016 184 2.13e-16
c4492 1 644 1.6e-16
c4493 1439 197 7.23e-16
c4494 27 225 3.31e-16
c4495 1097 1096 6.77e-16
c4496 1904 238 7.77e-16
c4497 1905 239 7.91e-16
c4498 1906 236 7.23e-16
c4499 1907 237 7.91e-16
c4500 0 476 2.585e-15
c4501 147 202 1.99e-16
c4502 142 196 1.99e-16
c4503 136 197 3.34e-16
c4504 2299 2359 1.96e-16
c4505 2587 2522 3.15e-16
c4506 224 456 2.13e-16
c4507 2833 2471 1.124e-15
c4508 1104 222 7.77e-16
c4509 2038 2039 6.77e-16
c4510 1364 233 8.32e-16
c4511 2632 2572 2.59e-16
c4512 0 295 2.957e-15
c4513 2492 2515 3.92e-16
c4514 15 9 3.11e-16
c4515 2587 2517 1.5e-16
c4516 0 788 2.585e-15
c4517 2773 2779 2.47e-16
c4518 2675 2364 1.96e-16
c4519 2652 2358 5.88e-16
c4520 2654 2294 1.96e-16
c4521 2697 2645 1.96e-16
c4522 214 445 2.14e-16
c4523 1796 1797 6.77e-16
c4524 235 79 3.34e-16
c4525 420 421 6.77e-16
c4526 1147 186 7.91e-16
c4527 1150 180 7.91e-16
c4528 1148 182 8.32e-16
c4529 37 208 3.24e-16
c4530 69 212 1.99e-16
c4531 1 1302 1.6e-16
c4532 2218 0 2.957e-15
c4533 2807 80 1.6e-16
c4534 8 111 3.47e-16
c4535 0 607 2.957e-15
c4536 0 1100 2.585e-15
c4537 27 198 1.9e-16
c4538 1 2635 2.59e-15
c4539 0 1545 2.623e-15
c4540 1 229 3.749e-15
c4541 1561 201 2.54e-16
c4542 1560 200 2.13e-16
c4543 2394 2386 1.38e-16
c4544 239 174 1.94e-16
c4545 2635 2467 1.96e-16
c4546 90 237 1.99e-16
c4547 0 1362 2.957e-15
c4548 2108 2109 6.77e-16
c4549 732 733 6.77e-16
c4550 1704 209 7.77e-16
c4551 2424 200 2.264e-15
c4552 0 239 2.6005e-14
c4553 212 168 3.34e-16
c4554 2340 2313 9.05e-16
c4555 773 193 2.14e-16
c4556 2764 2766 3.54e-16
c4557 2709 2649 3.54e-16
c4558 2687 2364 3.54e-16
c4559 2655 2645 7.46e-16
c4560 145 147 3.92e-16
c4561 1284 192 2.13e-16
c4562 2409 2433 3.92e-16
c4563 2475 2474 1.149e-15
c4564 2305 2587 2.75e-16
c4565 2630 241 7.02e-16
c4566 80 34 2.44e-16
c4567 0 1509 2.926e-15
c4568 2312 2409 3.54e-16
c4569 2647 2572 1.58e-16
c4570 2643 2490 1.58e-16
c4571 2645 2574 3.54e-16
c4572 2364 2492 3.54e-16
c4573 0 387 2.623e-15
c4574 326 327 6.77e-16
c4575 0 897 2.623e-15
c4576 1 388 1.6e-16
c4577 0 1821 2.926e-15
c4578 1315 1314 6.77e-16
c4579 2380 190 1.114e-15
c4580 2540 222 3.99e-16
c4581 2755 2766 1.226e-15
c4582 235 347 2.8e-16
c4583 234 346 2.5e-16
c4584 0 1209 2.623e-15
c4585 848 222 7.77e-16
c4586 2251 2250 6.77e-16
c4587 0 2150 2.623e-15
c4588 1766 242 2.8e-16
c4589 2171 187 2.8e-16
c4590 2175 181 7.23e-16
c4591 2173 183 7.76e-16
c4592 1620 232 2.13e-16
c4593 14 220 1.99e-16
c4594 0 532 2.585e-15
c4595 701 215 7.76e-16
c4596 0 1026 2.957e-15
c4597 1972 217 8.32e-16
c4598 1973 216 7.76e-16
c4599 164 66 4.85e-16
c4600 544 198 7.77e-16
c4601 545 199 7.91e-16
c4602 546 196 7.23e-16
c4603 547 197 7.91e-16
c4604 0 844 2.585e-15
c4605 887 187 2.5e-16
c4606 2654 2825 3.866e-15
c4607 2675 2389 4.77e-16
c4608 1 531 1.6e-16
c4609 875 874 6.77e-16
c4610 0 1947 2.623e-15
c4611 2517 0 6.737e-15
c4612 2274 0 2.957e-15
c4613 0 344 2.957e-15
c4614 2632 2556 1.58e-16
c4615 688 207 2.13e-16
c4616 690 205 2.5e-16
c4617 2687 2696 1.3e-16
c4618 1 843 1.6e-16
c4619 0 1780 2.585e-15
c4620 1981 1980 6.77e-16
c4621 950 951 6.77e-16
c4622 2147 2146 6.77e-16
c4623 0 656 2.957e-15
c4624 1395 1394 6.77e-16
c4625 2409 205 5.64e-16
c4626 2318 2651 1.176e-15
c4627 2639 2635 5.88e-16
c4628 708 709 6.77e-16
c4629 1184 199 2.13e-16
c4630 1186 197 2.5e-16
c4631 0 1599 2.957e-15
c4632 1 1155 1.6e-16
c4633 0 2092 2.585e-15
c4634 2409 200 7.35e-16
c4635 2298 2632 2.52e-16
c4636 2495 216 3.8e-16
c4637 0 968 2.957e-15
c4638 2629 241 1.207e-15
c4639 223 465 7.91e-16
c4640 1 2469 1.79e-16
c4641 42 213 3.34e-16
c4642 1931 194 7.91e-16
c4643 1373 231 7.76e-16
c4644 73 233 1.9e-16
c4645 2548 2490 1.58e-16
c4646 0 310 2.623e-15
c4647 2318 2402 1.96e-16
c4648 315 218 7.91e-16
c4649 2389 2817 2.38e-16
c4650 242 79 3.34e-16
c4651 1707 1706 6.77e-16
c4652 2655 2407 1.58e-16
c4653 1 2734 7.06e-16
c4654 1020 1021 6.77e-16
c4655 69 221 1.99e-16
c4656 2235 0 2.623e-15
c4657 2305 0 9.2474e-14
c4658 0 622 2.623e-15
c4659 1 2236 1.6e-16
c4660 2343 2377 2.83e-16
c4661 2299 2462 3.94e-16
c4662 2389 2492 6.28e-16
c4663 1097 224 7.91e-16
c4664 1423 189 7.23e-16
c4665 1421 191 7.76e-16
c4666 1510 242 2.8e-16
c4667 2294 2420 2.75e-16
c4668 2021 241 2.14e-16
c4669 1 2057 1.6e-16
c4670 442 219 7.23e-16
c4671 235 157 1.99e-16
c4672 0 934 2.623e-15
c4673 591 221 7.23e-16
c4674 590 220 7.91e-16
c4675 0 1379 2.623e-15
c4676 69 218 3.34e-16
c4677 1915 187 2.8e-16
c4678 1 1380 1.6e-16
c4679 221 168 3.34e-16
c4680 2212 209 8.32e-16
c4681 2213 208 7.76e-16
c4682 223 178 3.24e-16
c4683 291 197 7.91e-16
c4684 290 196 7.23e-16
c4685 289 199 7.91e-16
c4686 288 198 7.77e-16
c4687 1777 1776 6.77e-16
c4688 0 1263 2.957e-15
c4689 226 90 3.34e-16
c4690 31 180 3.34e-16
c4691 1347 213 7.91e-16
c4692 0 1691 2.623e-15
c4693 2268 2269 6.77e-16
c4694 2199 0 2.957e-15
c4695 1856 214 7.77e-16
c4696 1 1692 1.6e-16
c4697 2842 8 7.84e-16
c4698 2760 2786 1.58e-16
c4699 2298 2647 1.58e-16
c4700 234 132 3.34e-16
c4701 1342 1343 6.77e-16
c4702 2151 242 7.23e-16
c4703 2150 243 7.91e-16
c4704 1 587 1.6e-16
c4705 0 1524 2.585e-15
c4706 1852 1853 6.77e-16
c4707 1231 220 2.5e-16
c4708 1545 193 2.54e-16
c4709 1544 192 2.13e-16
c4710 218 168 1.99e-16
c4711 206 174 1.9e-16
c4712 0 158 1.82e-16
c4713 2318 2585 1.96e-16
c4714 58 224 3.24e-16
c4715 0 400 2.957e-15
c4716 90 204 1.99e-16
c4717 2697 2675 2.563e-15
c4718 2654 2719 1.58e-16
c4719 2089 2088 6.77e-16
c4720 0 1836 2.585e-15
c4721 201 174 3.31e-16
c4722 1994 227 7.23e-16
c4723 0 383 2.957e-15
c4724 208 111 3.24e-16
c4725 211 115 1.99e-16
c4726 94 180 3.34e-16
c4727 90 199 1.94e-16
c4728 84 181 3.34e-16
c4729 79 192 3.24e-16
c4730 0 206 2.4398e-14
c4731 246 186 2.8e-16
c4732 0 893 2.926e-15
c4733 0 712 2.957e-15
c4734 2277 240 7.76e-16
c4735 1 210 3.839e-15
c4736 1647 237 7.23e-16
c4737 1645 239 7.76e-16
c4738 2183 194 7.23e-16
c4739 0 201 2.4546e-14
c4740 0 1205 2.926e-15
c4741 1 126 7.6e-16
c4742 0 1043 2.623e-15
c4743 708 224 2.13e-16
c4744 0 1648 2.957e-15
c4745 1 1044 1.6e-16
c4746 58 196 1.99e-16
c4747 52 187 1.99e-16
c4748 1059 1058 6.77e-16
c4749 307 306 6.77e-16
c4750 234 147 1.99e-16
c4751 2697 2687 6.99e-16
c4752 2675 2655 6.78e-16
c4753 987 234 7.91e-16
c4754 0 1960 2.957e-15
c4755 1 1470 1.6e-16
c4756 2291 0 2.623e-15
c4757 1 1801 1.6e-16
c4758 231 481 7.91e-16
c4759 164 100 3.31e-16
c4760 698 218 2.5e-16
c4761 1724 1725 6.77e-16
c4762 221 335 7.23e-16
c4763 837 225 2.14e-16
c4764 1 2835 7.82e-16
c4765 1812 200 2.13e-16
c4766 1659 187 2.8e-16
c4767 1663 181 7.23e-16
c4768 1661 183 7.76e-16
c4769 2561 2552 1.6e-16
c4770 2320 2346 3.92e-16
c4771 2322 2359 3.92e-16
c4772 0 673 2.623e-15
c4773 2258 221 2.5e-16
c4774 2259 220 2.8e-16
c4775 2743 2358 1.28e-16
c4776 2749 2305 7.8e-16
c4777 2652 2572 3.26e-16
c4778 1 2113 1.6e-16
c4779 1 59 5.29e-16
c4780 619 618 6.77e-16
c4781 0 1614 2.623e-15
c4782 1 2320 9.59e-16
c4783 37 235 3.34e-16
c4784 1600 214 7.77e-16
c4785 2296 2585 4.45e-16
c4786 2298 2550 2.11e-16
c4787 0 490 2.957e-15
c4788 528 190 7.77e-16
c4789 529 191 7.91e-16
c4790 530 188 7.23e-16
c4791 531 189 7.91e-16
c4792 2471 2552 2.39e-16
c4793 0 985 2.623e-15
c4794 230 608 7.77e-16
c4795 2655 2687 3.56e-16
c4796 42 222 3.31e-16
c4797 967 226 7.23e-16
c4798 966 227 7.91e-16
c4799 1380 240 2.13e-16
c4800 14 186 3.34e-16
c4801 2543 2522 4.45e-16
c4802 0 325 2.926e-15
c4803 223 461 7.76e-16
c4804 825 216 7.91e-16
c4805 2389 2850 2.38e-16
c4806 2634 2665 3.228e-15
c4807 0 1312 2.957e-15
c4808 1 822 1.6e-16
c4809 931 930 6.77e-16
c4810 2248 0 2.957e-15
c4811 2543 2517 7.1e-16
c4812 2086 210 2.8e-16
c4813 2655 2492 5.5e-16
c4814 2634 2638 1.6e-16
c4815 501 185 2.14e-16
c4816 689 688 6.77e-16
c4817 738 229 2.5e-16
c4818 739 228 2.8e-16
c4819 42 217 1.9e-16
c4820 1391 237 7.23e-16
c4821 1389 239 7.76e-16
c4822 1 1134 1.6e-16
c4823 2635 2427 1.96e-16
c4824 1630 1631 6.77e-16
c4825 242 157 1.99e-16
c4826 254 255 6.77e-16
c4827 0 949 2.926e-15
c4828 0 1392 2.957e-15
c4829 52 229 3.34e-16
c4830 236 84 3.34e-16
c4831 1 1891 1.6e-16
c4832 2425 2418 5.82e-16
c4833 164 20 3.31e-16
c4834 2764 2800 1.96e-16
c4835 2652 2340 9.65e-16
c4836 1 2424 7.03e-16
c4837 0 1278 2.623e-15
c4838 1 273 1.6e-16
c4840 1001 1000 6.77e-16
c4841 0 1704 2.957e-15
c4842 283 203 2.8e-16
c4843 143 9 3.31e-16
c4844 2422 2391 1.13e-16
c4845 241 132 3.31e-16
c4846 240 126 1.94e-16
c4847 215 79 1.94e-16
c4848 2637 2505 1.96e-16
c4849 2641 2508 1.96e-16
c4850 435 204 2.8e-16
c4851 433 206 2.54e-16
c4852 581 225 2.14e-16
c4853 1407 181 7.23e-16
c4854 1405 183 7.76e-16
c4855 1076 1077 6.77e-16
c4856 2305 2543 1.96e-16
c4857 2318 2503 2.66e-16
c4858 929 198 2.54e-16
c4859 931 196 2.8e-16
c4860 1521 1520 6.77e-16
c4861 0 1341 2.926e-15
c4862 69 185 3.31e-16
c4863 73 190 3.31e-16
c4864 63 187 1.99e-16
c4865 1074 1075 6.77e-16
c4866 2002 221 2.5e-16
c4867 2003 220 2.8e-16
c4868 0 398 2.623e-15
c4869 2654 0 4.1287e-14
c4870 561 560 6.77e-16
c4871 0 908 2.585e-15
c4872 922 203 7.23e-16
c4873 756 184 2.13e-16
c4874 2634 2343 3.54e-16
c4875 857 232 7.91e-16
c4876 1074 204 7.23e-16
c4877 8 14 5.18e-16
c4878 1502 1503 6.77e-16
c4879 2771 2758 1.96e-16
c4880 228 350 7.91e-16
c4881 229 351 7.23e-16
c4882 0 1220 2.585e-15
c4883 2012 2013 6.77e-16
c4884 636 637 6.77e-16
c4885 0 1665 2.623e-15
c4886 1529 185 2.54e-16
c4887 1528 184 2.13e-16
c4888 1833 1832 6.77e-16
c4889 0 1999 2.957e-15
c4890 192 157 1.94e-16
c4891 185 168 1.9e-16
c4892 182 178 3.31e-16
c4893 0 1039 2.957e-15
c4894 243 490 7.23e-16
c4895 241 147 1.9e-16
c4896 0 1482 2.957e-15
c4897 0 1977 2.623e-15
c4898 1 878 1.6e-16
c4899 2630 2609 2.72e-16
c4900 121 180 1.99e-16
c4901 105 187 1.99e-16
c4902 2675 2816 1.58e-16
c4903 143 69 3.26e-16
c4904 1 2820 3.53e-16
c4905 1671 194 7.23e-16
c4906 2287 0 2.957e-15
c4907 191 132 1.94e-16
c4908 189 126 3.34e-16
c4910 694 219 7.91e-16
c4911 2687 2707 1.86e-16
c4912 0 1629 2.926e-15
c4913 37 242 3.34e-16
c4914 1 1185 1.6e-16
c4915 1609 225 2.54e-16
c4916 2746 8 1.61e-16
c4917 2296 2503 7.83e-16
c4918 0 507 2.623e-15
c4919 1 2409 2.558e-15
c4920 1 508 1.6e-16
c4921 0 1924 2.585e-15
c4922 2467 2409 2.44e-16
c4923 1294 1295 6.77e-16
c4924 2587 2557 4.91e-16
c4925 2854 2634 1.58e-16
c4926 2820 2845 1.193e-15
c4927 69 231 1.94e-16
c4928 63 229 3.34e-16
c4929 1796 192 2.13e-16
c4930 1739 226 7.91e-16
c4931 2772 0 2.08e-16
c4932 143 108 3.31e-16
c4933 666 203 7.23e-16
c4934 2247 226 7.23e-16
c4935 2246 227 7.91e-16
c4936 2338 2340 1.96e-16
c4937 2665 2669 1.6e-16
c4938 1169 190 2.54e-16
c4939 1171 188 2.8e-16
c4940 232 601 7.91e-16
c4941 234 235 3.76e-16
c4942 1727 212 2.5e-16
c4943 1 1577 1.6e-16
c4944 2643 2379 1.96e-16
c4945 2294 2377 1.96e-16
c4946 0 471 2.957e-15
c4947 2463 206 1.114e-15
c4948 142 187 3.34e-16
c4949 147 191 3.24e-16
c4950 233 597 2.14e-16
c4951 0 1409 2.623e-15
c4952 1100 223 2.13e-16
c4953 2351 2594 1.96e-16
c4954 231 168 3.24e-16
c4955 228 163 1.99e-16
c4956 233 174 3.31e-16
c4957 296 209 7.77e-16
c4958 2587 2523 1.34e-16
c4959 0 783 2.957e-15
c4960 2793 38 9.71e-16
c4961 232 90 3.24e-16
c4962 0 1293 2.926e-15
c4963 1091 1090 6.77e-16
c4964 728 233 7.77e-16
c4965 1141 184 7.76e-16
c4966 1360 222 7.77e-16
c4967 1240 232 2.13e-16
c4968 2212 0 2.585e-15
c4969 0 266 2.957e-15
c4970 0 761 2.623e-15
c4971 2729 0 5.31e-16
c4972 792 201 7.77e-16
c4973 13 2802 1.44e-15
c4974 235 111 3.34e-16
c4975 229 105 3.34e-16
c4976 225 84 1.9e-16
c4977 0 233 2.4546e-14
c4978 0 1095 2.957e-15
c4979 727 234 7.23e-16
c4980 726 235 7.91e-16
c4981 42 184 1.94e-16
c4982 37 192 3.24e-16
c4983 31 197 3.34e-16
c4984 0 1538 2.957e-15
c4985 0 2033 2.623e-15
c4986 1166 1167 6.77e-16
c4987 237 178 3.34e-16
c4988 8 2505 5.14e-16
c4989 414 415 6.77e-16
c4990 0 1088 2.957e-15
c4991 1611 1610 6.77e-16
c4992 431 204 2.5e-16
c4993 428 207 2.13e-16
c4994 429 206 2.14e-16
c4995 430 205 2.8e-16
c4996 426 210 2.5e-16
c4997 0 1356 2.585e-15
c4998 1 419 1.6e-16
c4999 1399 187 2.5e-16
c5000 0 413 2.926e-15
c5001 143 146 1.34e-16
c5002 215 157 3.24e-16
c5003 2335 2300 3.84e-16
c5004 231 352 2.13e-16
c5005 1 82 2.79e-16
c5006 1 731 1.6e-16
c5007 1 1241 1.6e-16
c5008 3 219 3.48e-16
c5009 0 109 1.14e-16
c5010 94 197 3.34e-16
c5011 84 198 3.31e-16
c5012 2462 2394 5.75e-16
c5013 2490 2436 3.6e-16
c5014 0 725 2.926e-15
c5015 2298 2338 1.58e-16
c5016 1 2177 1.6e-16
c5017 726 727 6.77e-16
c5018 1 118 2.79e-16
c5019 1 564 1.6e-16
c5020 1236 1237 6.77e-16
c5021 52 210 1.99e-16
c5022 48 211 3.34e-16
c5023 2420 0 1.7906e-14
c5024 2639 2409 3.54e-16
c5025 1681 1680 6.77e-16
c5026 0 1054 2.623e-15
c5027 2574 242 5.7e-16
c5028 2299 2469 4.02e-16
c5029 1 2711 2.88e-16
c5030 913 190 2.54e-16
c5031 915 188 2.8e-16
c5032 1000 241 7.77e-16
c5033 2557 0 6.737e-15
c5034 1982 213 2.8e-16
c5035 2627 2608 1.58e-16
c5036 229 142 1.99e-16
c5037 228 136 3.34e-16
c5038 906 195 7.23e-16
c5039 2675 2842 1.9e-16
c5040 2719 2861 3.72e-16
c5041 2733 2755 5.05e-16
c5042 1 2308 1.424e-15
c5043 1 361 1.6e-16
c5044 233 341 2.14e-16
c5045 990 229 2.8e-16
c5046 844 223 2.13e-16
c5047 0 1811 2.623e-15
c5048 2625 2604 4.45e-16
c5049 2627 2617 1.13e-16
c5050 1 1812 1.6e-16
c5051 2264 233 7.77e-16
c5052 2734 2740 1.242e-15
c5053 2732 2358 1.707e-15
c5054 1 2302 6.76e-16
c5055 1 2843 1.309e-15
c5056 1993 1992 6.77e-16
c5057 1 707 1.6e-16
c5058 0 2123 2.623e-15
c5059 2294 2735 1.164e-15
c5060 0 520 2.957e-15
c5061 536 201 7.77e-16
c5062 1 2124 1.6e-16
c5063 1558 1559 6.77e-16
c5064 0 1446 2.623e-15
c5065 1 1019 1.6e-16
c5066 2068 2069 6.77e-16
c5067 59 52 2.17e-16
c5068 2108 215 2.13e-16
c5069 14 208 3.24e-16
c5070 0 832 2.957e-15
c5071 1 342 1.6e-16
c5072 0 1775 2.957e-15
c5073 2304 2293 1.38e-16
c5074 1 2267 1.6e-16
c5075 2318 2335 1.96e-16
c5076 2643 2384 1.96e-16
c5077 0 1144 2.957e-15
c5078 1137 238 2.54e-16
c5079 1139 236 2.8e-16
c5080 42 239 3.24e-16
c5081 1 654 1.6e-16
c5082 1111 235 2.5e-16
c5083 1734 227 7.91e-16
c5084 0 2087 2.957e-15
c5085 2298 2644 3.71e-16
c5086 2624 243 3.61e-16
c5087 37 215 1.94e-16
c5088 1 966 1.6e-16
c5089 1924 193 8.32e-16
c5090 1925 192 7.76e-16
c5091 1275 1274 6.77e-16
c5092 309 216 7.76e-16
c5093 308 217 8.32e-16
c5094 0 798 2.623e-15
c5095 523 522 6.77e-16
c5096 2233 217 2.54e-16
c5097 2232 216 2.13e-16
c5098 0 283 2.623e-15
c5099 2503 2480 4.67e-16
c5100 2462 2432 5.41e-16
c5101 122 17 8.48e-16
c5102 2460 2443 1.58e-16
c5103 1 1723 1.6e-16
c5104 19 13 3.672e-15
c5105 640 183 2.13e-16
c5106 642 181 2.5e-16
c5107 242 111 3.34e-16
c5108 0 1110 2.623e-15
c5109 0 1717 2.926e-15
c5110 1940 1941 6.77e-16
c5111 1 2649 1.764e-15
c5112 1354 1355 6.77e-16
c5113 2305 2460 7.13e-16
c5114 2645 2505 1.96e-16
c5115 2364 2508 1.96e-16
c5116 2312 2510 2.79e-16
c5117 2649 2467 1.96e-16
c5118 438 218 2.8e-16
c5119 937 209 2.54e-16
c5120 936 208 2.13e-16
c5121 0 75 1.82e-16
c5122 835 834 6.77e-16
c5123 69 207 1.94e-16
c5124 63 210 1.99e-16
c5125 1499 234 7.91e-16
c5126 0 1867 2.623e-15
c5127 2008 233 7.77e-16
c5128 220 153 1.99e-16
c5129 1 1868 1.6e-16
c5130 226 178 1.99e-16
c5131 213 578 2.5e-16
c5132 212 579 2.8e-16
c5133 0 922 2.957e-15
c5134 240 361 7.91e-16
c5135 69 202 3.34e-16
c5136 1340 214 8.32e-16
c5137 1 1353 1.6e-16
c5138 1852 215 2.13e-16
c5139 267 194 7.91e-16
c5140 2382 2359 2.86e-16
c5141 2634 2294 3.54e-16
c5142 2296 2335 8.92e-16
c5143 2299 2320 3.08e-16
c5144 860 231 2.13e-16
c5145 1079 218 7.23e-16
c5146 1697 198 2.54e-16
c5147 1699 196 2.8e-16
c5148 0 2170 2.957e-15
c5149 2202 202 2.5e-16
c5150 2206 197 2.8e-16
c5151 2205 198 2.14e-16
c5152 2204 199 2.13e-16
c5153 2207 196 2.5e-16
c5154 1147 1146 6.77e-16
c5155 2038 187 7.91e-16
c5156 0 559 2.957e-15
c5157 2138 234 2.5e-16
c5158 2139 235 2.8e-16
c5159 207 168 3.24e-16
c5160 204 178 3.34e-16
c5161 2343 2625 6.29e-16
c5162 2637 2627 1.96e-16
c5163 2641 2632 1.96e-16
c5164 395 394 6.77e-16
c5165 370 237 2.5e-16
c5166 368 239 2.13e-16
c5167 0 1069 2.926e-15
c5168 881 238 2.54e-16
c5169 883 236 2.8e-16
c5170 905 904 6.77e-16
c5171 1218 212 7.23e-16
c5172 0 1497 2.623e-15
c5173 1632 231 2.13e-16
c5174 1840 206 7.77e-16
c5175 1841 207 7.91e-16
c5176 1842 204 7.23e-16
c5177 1843 205 7.91e-16
c5178 202 168 1.99e-16
c5179 199 178 3.24e-16
c5180 190 174 1.9e-16
c5181 2351 2490 4.18e-16
c5182 1 2011 1.6e-16
c5183 210 105 1.99e-16
c5184 90 188 1.99e-16
c5185 79 181 1.99e-16
c5186 0 190 2.4398e-14
c5187 121 197 1.99e-16
c5188 111 192 3.24e-16
c5189 115 195 1.99e-16
c5190 2861 0 9.076e-15
c5191 1 194 3.839e-15
c5192 1204 216 2.13e-16
c5193 1680 191 2.13e-16
c5194 1682 189 2.5e-16
c5195 1217 1216 6.77e-16
c5196 0 2136 2.957e-15
c5197 1 1646 1.6e-16
c5198 58 187 3.34e-16
c5199 2679 0 1.65e-16
c5200 2119 227 2.5e-16
c5201 2471 2594 2.39e-16
c5202 386 181 2.5e-16
c5203 384 183 2.13e-16
c5204 897 182 2.54e-16
c5205 899 180 2.8e-16
c5206 0 1461 2.926e-15
c5207 2158 2159 6.77e-16
c5208 980 233 8.32e-16
c5209 1612 222 8.32e-16
c5210 2427 2409 2.44e-16
c5211 1 1958 1.6e-16
c5212 540 541 6.77e-16
c5214 0 1790 2.623e-15
c5215 1 1329 1.6e-16
c5216 2228 2229 6.77e-16
c5217 2792 0 9.02e-16
c5218 122 103 8.48e-16
c5219 2407 2350 1.58e-16
c5220 0 666 2.957e-15
c5221 678 210 2.8e-16
c5222 2637 2643 7.84e-16
c5223 2641 2647 5.88e-16
c5224 2639 2649 7.84e-16
c5225 227 330 7.23e-16
c5226 2389 2508 2.28e-16
c5227 777 776 6.77e-16
c5228 0 1161 2.623e-15
c5229 1 2760 3.53e-16
c5230 0 2102 2.623e-15
c5231 1742 221 2.8e-16
c5232 2107 218 7.91e-16
c5233 2665 2545 4.44e-16
c5234 0 484 2.585e-15
c5235 520 193 7.77e-16
c5236 142 210 3.34e-16
c5237 1174 202 2.8e-16
c5238 604 231 2.13e-16
c5239 0 978 2.957e-15
c5240 1 134 2.79e-16
c5241 852 853 6.77e-16
c5242 1441 198 2.54e-16
c5243 1443 196 2.8e-16
c5244 2049 2048 6.77e-16
c5245 2630 2627 1.06e-16
c5246 1882 234 2.5e-16
c5247 1883 235 2.8e-16
c5248 0 813 2.926e-15
c5249 0 1420 2.585e-15
c5250 1 2464 7.03e-16
c5251 1434 203 7.23e-16
c5252 1319 210 7.23e-16
c5253 744 240 2.13e-16
c5254 1369 232 7.91e-16
c5255 1584 206 7.77e-16
c5256 1585 207 7.91e-16
c5257 1586 204 7.23e-16
c5258 1587 205 7.91e-16
c5259 1 1310 1.6e-16
c5260 0 296 2.957e-15
c5261 2572 2516 1.414e-15
c5262 1372 1373 6.77e-16
c5263 650 194 2.5e-16
c5264 654 189 2.8e-16
c5265 653 190 2.14e-16
c5266 652 191 2.13e-16
c5267 655 188 2.5e-16
c5268 1 2246 1.6e-16
c5269 0 1125 2.926e-15
c5270 733 230 2.14e-16
c5271 1 795 1.6e-16
c5272 42 206 3.31e-16
c5273 27 211 3.34e-16
c5274 1245 231 7.76e-16
c5275 0 1553 2.623e-15
c5276 2080 198 7.77e-16
c5277 2081 199 7.91e-16
c5278 2082 196 7.23e-16
c5279 2083 197 7.91e-16
c5280 0 608 2.957e-15
c5281 2626 237 2.431e-15
c5282 3 230 2.38e-16
c5283 1 2067 1.6e-16
c5284 42 201 1.9e-16
c5285 948 216 2.13e-16
c5286 0 1551 2.957e-15
c5287 1 449 1.6e-16
c5288 1 1107 1.6e-16
c5289 0 2044 2.585e-15
c5290 0 1880 2.957e-15
c5291 1 1390 1.6e-16
c5292 58 229 1.99e-16
c5293 2017 230 2.54e-16
c5294 236 79 1.99e-16
c5295 1 430 1.6e-16
c5296 1089 214 2.54e-16
c5297 1684 1685 6.77e-16
c5298 1349 224 7.76e-16
c5299 0 245 2.926e-15
c5300 100 219 3.34e-16
c5301 2422 2392 4.96e-16
c5302 1 1702 1.6e-16
c5303 777 192 7.91e-16
c5304 2773 2772 4.83e-16
c5305 2764 2758 9.94e-16
c5306 2709 2312 5.67e-16
c5307 0 1251 2.623e-15
c5308 1 87 2.79e-16
c5309 1 742 1.6e-16
c5310 1921 1920 6.77e-16
c5311 1 1252 1.6e-16
c5312 0 2187 2.623e-15
c5313 2379 2368 1.25e-16
c5314 2420 2401 2.99e-16
c5315 2377 0 1.7803e-14
c5316 0 574 2.623e-15
c5317 2147 229 7.91e-16
c5318 215 111 1.94e-16
c5319 212 115 3.34e-16
c5320 1 2188 1.6e-16
c5321 2637 2548 1.96e-16
c5322 2641 2550 1.96e-16
c5323 2343 2545 1.96e-16
c5324 2643 2630 3.39e-16
c5325 2299 2409 2.14e-16
c5326 1 214 4.537e-15
c5327 1339 219 2.8e-16
c5328 0 51 1.14e-16
c5329 1851 218 7.91e-16
c5330 2358 2572 1.58e-16
c5331 8 2627 7.1e-16
c5332 0 903 2.957e-15
c5333 877 238 2.14e-16
c5334 876 239 2.13e-16
c5335 918 202 2.8e-16
c5336 1070 1071 6.77e-16
c5337 2590 2519 4.48e-16
c5338 14 235 3.34e-16
c5339 2273 231 7.91e-16
c5340 2755 2758 1.74e-16
c5341 551 211 2.5e-16
c5342 0 1215 2.957e-15
c5343 1063 210 7.23e-16
c5344 0 1658 2.957e-15
c5345 0 2153 2.623e-15
c5346 2269 230 2.14e-16
c5347 186 153 3.34e-16
c5348 181 157 3.34e-16
c5349 1 539 1.6e-16
c5350 0 1476 2.585e-15
c5351 0 1970 2.957e-15
c5352 378 187 7.23e-16
c5353 630 631 6.77e-16
c5354 890 186 2.5e-16
c5355 894 181 2.8e-16
c5356 893 182 2.14e-16
c5357 892 183 2.13e-16
c5358 2719 2634 1.58e-16
c5359 2654 2829 1.34e-16
c5360 1 851 1.6e-16
c5361 20 219 1.99e-16
c5362 21 0 1.82e-16
c5363 180 132 1.99e-16
c5364 1752 232 2.13e-16
c5365 0 683 2.623e-15
c5366 2655 2508 1.96e-16
c5367 833 214 2.54e-16
c5368 1188 208 2.13e-16
c5369 1 38 3.51e-16
c5370 1 684 1.6e-16
c5371 1902 1903 6.77e-16
c5372 1126 242 2.8e-16
c5373 2643 8 3.63e-16
c5374 2305 2651 1.176e-15
c5375 2647 2590 1.96e-16
c5376 164 161 2.32e-16
c5377 0 1157 2.926e-15
c5378 284 285 6.77e-16
c5379 0 995 2.623e-15
c5380 942 943 6.77e-16
c5381 2139 2138 6.77e-16
c5382 1 996 1.6e-16
c5383 0 1919 2.957e-15
c5384 1387 1386 6.77e-16
c5385 2505 2492 4.87e-16
c5386 963 213 7.91e-16
c5387 69 234 3.34e-16
c5388 1879 235 2.5e-16
c5389 2209 2208 6.77e-16
c5390 0 313 2.623e-15
c5391 2585 2522 1.12e-16
c5392 1 1753 1.6e-16
c5393 2757 0 8.1564e-14
c5394 1462 1463 6.77e-16
c5395 164 126 3.31e-16
c5396 122 125 1.34e-16
c5397 622 237 2.8e-16
c5398 621 238 2.14e-16
c5399 620 239 2.13e-16
c5400 623 236 2.5e-16
c5401 2634 2587 3.92e-16
c5402 1 2761 4.164e-15
c5403 740 241 8.32e-16
c5404 1161 193 2.54e-16
c5405 1160 192 2.13e-16
c5406 1252 240 2.13e-16
c5407 1579 211 2.8e-16
c5408 1583 205 7.23e-16
c5409 1581 207 7.76e-16
c5410 1 1734 1.6e-16
c5411 2735 0 1.5143e-14
c5412 0 625 2.623e-15
c5413 646 195 7.91e-16
c5414 1699 1698 6.77e-16
c5415 2649 2427 1.96e-16
c5416 2643 2425 1.96e-16
c5417 2647 2422 1.96e-16
c5418 147 180 3.34e-16
c5419 1425 190 2.54e-16
c5420 1427 188 2.8e-16
c5421 1512 241 7.77e-16
c5422 2024 240 2.13e-16
c5423 2320 2322 4.38e-15
c5424 2298 2475 1.96e-16
c5425 0 442 2.957e-15
c5426 8 153 3.47e-16
c5427 234 168 1.99e-16
c5428 0 937 2.623e-15
c5429 2299 2308 6.36e-16
c5430 232 178 1.94e-16
c5431 2652 2641 5.88e-16
c5432 1418 195 7.23e-16
c5433 0 64 1.82e-16
c5434 1263 237 7.23e-16
c5435 1261 239 7.76e-16
c5436 0 1878 2.623e-15
c5437 1502 229 2.8e-16
c5438 1356 223 2.13e-16
c5439 2013 230 2.14e-16
c5440 0 260 2.585e-15
c5441 1532 1533 6.77e-16
c5442 2299 2302 7.84e-16
c5443 0 754 2.957e-15
c5444 0 1264 2.957e-15
c5445 225 79 3.31e-16
c5446 37 181 1.99e-16
c5447 2200 0 2.957e-15
c5448 2064 190 7.77e-16
c5449 2065 191 7.91e-16
c5450 2066 188 7.23e-16
c5451 2067 189 7.91e-16
c5452 2298 2358 2.793e-15
c5453 0 589 2.926e-15
c5454 236 157 3.34e-16
c5455 221 115 3.34e-16
c5456 2766 2636 1.09e-16
c5457 421 209 2.14e-16
c5458 722 220 7.23e-16
c5459 1235 221 7.91e-16
c5460 1 1086 1.6e-16
c5461 1 1531 1.6e-16
c5462 2599 0 6.737e-15
c5463 0 167 1.14e-16
c5464 2143 229 7.23e-16
c5465 2142 228 7.91e-16
c5466 2645 2627 1.96e-16
c5467 2364 2632 1.116e-15
c5468 2294 2625 2.83e-16
c5469 2635 2592 2.82e-16
c5470 2305 2585 1.96e-16
c5471 8 2548 1.36e-16
c5472 1844 1845 6.77e-16
c5473 1275 187 2.8e-16
c5474 1279 181 7.23e-16
c5475 1277 183 7.76e-16
c5476 1847 218 7.23e-16
c5477 1 1843 1.6e-16
c5478 3 209 2.38e-16
c5479 0 114 1.14e-16
c5480 218 115 1.99e-16
c5481 79 198 1.9e-16
c5482 248 185 7.77e-16
c5483 108 111 3.92e-16
c5484 14 242 3.34e-16
c5485 1 2348 1.79e-16
c5486 0 1230 2.623e-15
c5487 1 216 3.792e-15
c5488 1649 238 2.54e-16
c5489 1651 236 2.8e-16
c5490 0 1675 2.623e-15
c5491 3 203 3.48e-16
c5492 58 210 3.34e-16
c5493 1 1676 1.6e-16
c5494 2422 198 1.7e-16
c5495 1 2510 7.39e-16
c5496 814 815 6.77e-16
c5497 996 240 2.13e-16
c5498 52 194 1.99e-16
c5499 48 195 3.34e-16
c5500 0 1987 2.623e-15
c5501 2288 238 7.77e-16
c5502 2291 237 7.91e-16
c5503 2290 236 7.23e-16
c5504 1 1988 1.6e-16
c5505 2318 2485 1.96e-16
c5506 2389 2392 1.96e-16
c5507 390 195 7.91e-16
c5508 902 194 2.8e-16
c5509 2697 2855 1.93e-16
c5510 1051 1050 6.77e-16
c5511 1819 203 2.8e-16
c5512 1823 197 7.23e-16
c5513 1821 199 7.76e-16
c5514 2337 185 1.207e-15
c5515 299 298 6.77e-16
c5516 2634 0 2.566e-14
c5517 0 696 2.957e-15
c5518 2260 232 2.13e-16
c5519 840 224 2.13e-16
c5520 1 2830 2.53e-16
c5521 1665 182 2.54e-16
c5522 1667 180 2.8e-16
c5523 1748 233 8.32e-16
c5524 1126 1127 6.77e-16
c5525 0 679 2.957e-15
c5526 2753 2294 5.57e-16
c5527 2647 2364 1.53e-15
c5528 2643 2645 5.88e-16
c5529 0 1172 2.585e-15
c5530 0 1008 2.957e-15
c5531 1031 195 2.5e-16
c5532 0 1617 2.623e-15
c5533 1 518 1.6e-16
c5534 1449 209 2.54e-16
c5535 1448 208 2.13e-16
c5536 42 233 1.9e-16
c5537 31 228 3.34e-16
c5538 0 1934 2.623e-15
c5539 101 48 1.58e-16
c5540 122 40 8.48e-16
c5541 0 991 2.957e-15
c5542 611 610 6.77e-16
c5543 0 1434 2.957e-15
c5544 1 150 2.79e-16
c5545 1945 201 2.54e-16
c5546 1944 200 2.13e-16
c5547 1 830 1.6e-16
c5548 69 241 3.31e-16
c5549 1887 229 7.23e-16
c5550 1886 228 7.91e-16
c5551 14 192 3.24e-16
c5552 2256 0 2.957e-15
c5553 213 318 2.8e-16
c5554 37 236 1.99e-16
c5555 1 825 1.6e-16
c5556 0 1746 2.957e-15
c5557 1883 1882 6.77e-16
c5558 1591 218 7.23e-16
c5559 1 1142 1.6e-16
c5560 2088 209 7.77e-16
c5561 1 1587 1.6e-16
c5562 2243 213 7.91e-16
c5563 230 100 1.9e-16
c5564 228 94 3.34e-16
c5565 2389 2632 6.66e-16
c5566 505 184 7.91e-16
c5567 1157 193 2.14e-16
c5568 0 30 1.14e-16
c5569 0 1564 2.585e-15
c5570 1393 238 2.54e-16
c5571 1395 236 2.8e-16
c5572 1 1137 1.6e-16
c5573 0 459 2.623e-15
c5574 1 2078 1.6e-16
c5575 241 168 1.9e-16
c5576 1 460 1.6e-16
c5577 0 1893 2.926e-15
c5578 73 224 1.94e-16
c5579 246 247 6.77e-16
c5580 2545 2477 2.88e-16
c5581 2460 2444 1.139e-15
c5582 2592 2469 3.14e-16
c5583 0 771 2.623e-15
c5584 1443 1442 6.77e-16
c5585 2654 2651 2.1e-16
c5586 0 1281 2.623e-15
c5587 1 772 1.6e-16
c5588 1716 216 2.13e-16
c5589 630 187 7.91e-16
c5590 2639 2510 1.96e-16
c5591 2343 2462 1.96e-16
c5592 2637 2465 1.96e-16
c5593 224 584 2.13e-16
c5594 1409 182 2.54e-16
c5595 1411 180 2.8e-16
c5596 2059 195 2.8e-16
c5597 2063 189 7.23e-16
c5598 2061 191 7.76e-16
c5599 1492 233 8.32e-16
c5600 2294 2545 1.96e-16
c5601 2305 2503 1.96e-16
c5602 2645 2548 1.96e-16
c5603 2364 2550 1.96e-16
c5604 2004 232 2.13e-16
c5605 225 157 1.9e-16
c5606 0 916 2.585e-15
c5607 573 214 2.14e-16
c5608 69 191 1.94e-16
c5609 73 196 3.34e-16
c5610 63 194 1.99e-16
c5611 48 212 1.99e-16
c5612 52 214 3.31e-16
c5613 2603 2594 1.6e-16
c5614 261 192 7.76e-16
c5615 260 193 8.32e-16
c5616 1513 1512 6.77e-16
c5617 2338 185 7.02e-16
c5618 2389 2647 1.58e-16
c5619 1271 187 2.5e-16
c5621 1689 201 2.54e-16
c5622 1688 200 2.13e-16
c5623 1225 225 2.54e-16
c5624 0 2164 2.585e-15
c5625 2197 201 2.14e-16
c5626 8 17 1.96e-16
c5627 20 230 3.31e-16
c5628 208 153 3.24e-16
c5629 2133 233 2.14e-16
c5630 2643 2407 1.58e-16
c5631 1588 1589 6.77e-16
c5632 1072 207 2.13e-16
c5633 0 1490 2.957e-15
c5634 0 2000 2.957e-15
c5635 198 157 3.31e-16
c5636 1832 209 7.77e-16
c5637 191 168 3.24e-16
c5638 188 178 3.34e-16
c5639 2731 2322 7.02e-16
c5640 1825 1824 6.77e-16
c5641 1 371 1.6e-16
c5642 59 65 1.34e-16
c5643 80 66 2.44e-16
c5644 1 881 1.6e-16
c5645 1474 212 7.23e-16
c5646 2287 237 7.23e-16
c5647 2285 239 7.76e-16
c5648 115 185 1.9e-16
c5649 111 181 1.99e-16
c5650 105 194 1.99e-16
c5651 2709 2714 1.6e-16
c5652 1 2709 5.202e-15
c5653 1 183 3.42e-15
c5654 0 1637 2.926e-15
c5655 1 1193 1.6e-16
c5656 197 132 1.99e-16
c5657 1757 231 7.76e-16
c5658 0 694 2.623e-15
c5659 14 215 1.94e-16
c5660 2445 2434 1.6e-16
c5661 2766 8 8.83e-16
c5662 1 2134 1.6e-16
c5663 1 2673 1.65e-16
c5664 1460 216 2.13e-16
c5665 0 1949 2.926e-15
c5666 0 1006 2.623e-15
c5667 234 474 2.5e-16
c5668 235 475 2.8e-16
c5669 164 82 4.85e-16
c5670 976 222 7.77e-16
c5671 1601 214 2.54e-16
c5672 1803 195 2.8e-16
c5673 1807 189 7.23e-16
c5674 1805 191 7.76e-16
c5675 1894 242 2.8e-16
c5676 1 1931 1.6e-16
c5677 2572 2556 3.92e-16
c5678 164 118 4.85e-16
c5679 122 123 1.34e-16
c5680 2343 2741 7.58e-16
c5681 0 1763 2.623e-15
c5682 1286 1287 6.77e-16
c5683 2100 217 8.32e-16
c5684 2101 216 7.76e-16
c5685 1 1764 1.6e-16
c5686 2322 2308 3.92e-16
c5687 143 115 3.26e-16
c5688 122 131 6.55e-16
c5689 672 198 7.77e-16
c5690 673 199 7.91e-16
c5691 674 196 7.23e-16
c5692 675 197 7.91e-16
c5693 2634 2543 5.67e-16
c5694 2389 2550 6.08e-16
c5695 1 2786 3.177e-15
c5696 1015 187 2.5e-16
c5697 37 225 3.31e-16
c5698 1731 213 7.91e-16
c5699 2322 2302 3.02e-16
c5700 2239 213 7.23e-16
c5701 2238 212 7.91e-16
c5702 2298 2572 1.58e-16
c5703 0 472 2.957e-15
c5704 142 194 3.34e-16
c5705 147 197 3.34e-16
c5706 227 455 2.5e-16
c5707 816 207 2.13e-16
c5708 818 205 2.5e-16
c5709 0 1415 2.957e-15
c5710 1430 202 2.8e-16
c5711 0 1908 2.585e-15
c5712 14 9 3.92e-16
c5713 8 176 1.96e-16
c5714 2632 2574 2.44e-16
c5715 0 784 2.957e-15
c5716 2813 38 4.11e-16
c5717 2697 2647 1.96e-16
c5718 2652 2364 5.88e-16
c5719 2675 2643 1.96e-16
c5720 11 15 1.74e-16
c5721 1 294 1.6e-16
c5722 1312 199 2.13e-16
c5723 1314 197 2.5e-16
c5724 63 214 3.31e-16
c5725 1177 1176 6.77e-16
c5726 8 103 1.96e-16
c5727 13 59 1.237e-15
c5728 228 121 1.99e-16
c5729 231 115 3.24e-16
c5730 1 2219 1.6e-16
c5731 0 1096 2.957e-15
c5732 42 190 3.31e-16
c5733 37 198 1.9e-16
c5734 27 195 3.34e-16
c5735 1 606 1.6e-16
c5736 1559 203 2.5e-16
c5737 0 2039 2.957e-15
c5738 2071 202 7.23e-16
c5739 2651 2420 1.96e-16
c5740 0 421 2.926e-15
c5741 225 580 8.32e-16
c5742 500 501 6.77e-16
c5743 1402 186 2.5e-16
c5744 1 1363 1.6e-16
c5745 48 221 1.99e-16
c5746 2421 197 2.431e-15
c5747 2386 0 6.764e-15
c5748 236 111 1.99e-16
c5749 100 209 3.31e-16
c5750 84 211 1.99e-16
c5751 213 163 1.99e-16
c5752 0 733 2.926e-15
c5753 2687 2643 3.54e-16
c5754 2655 2647 8.48e-16
c5755 2709 2639 3.54e-16
c5756 1 238 4.537e-15
c5757 0 3 9.2341e-14
c5758 100 203 3.34e-16
c5759 2409 2432 3.92e-16
c5760 2377 2365 2.32e-16
c5761 0 107 1.82e-16
c5762 1638 242 2.8e-16
c5763 2665 2635 7.04e-16
c5764 2298 2340 1.84e-16
c5765 570 219 7.23e-16
c5766 214 105 3.31e-16
c5767 101 27 1.58e-16
c5768 1221 225 2.14e-16
c5769 0 1507 2.623e-15
c5770 52 216 1.94e-16
c5771 48 218 3.34e-16
c5772 0 2017 2.623e-15
c5773 1 1508 1.6e-16
c5774 2318 2490 3.22e-16
c5775 2643 2492 3.54e-16
c5776 2647 2574 3.54e-16
c5777 0 1057 2.623e-15
c5778 2505 215 1.24e-16
c5779 1482 226 2.5e-16
c5780 1483 227 2.8e-16
c5781 0 1819 2.623e-15
c5782 1984 214 7.77e-16
c5783 1 1820 1.6e-16
c5784 0 874 2.957e-15
c5785 232 344 2.13e-16
c5786 0 1652 2.585e-15
c5787 1764 240 2.13e-16
c5788 0 2146 2.957e-15
c5789 2169 185 2.54e-16
c5790 2168 184 2.13e-16
c5791 0 709 2.926e-15
c5792 372 373 6.77e-16
c5793 1569 1568 6.77e-16
c5794 1058 197 2.5e-16
c5795 1 1027 1.6e-16
c5796 0 1964 2.585e-15
c5797 2625 0 2.7588e-14
c5798 2114 213 2.5e-16
c5799 2115 212 2.8e-16
c5800 2382 2320 1.58e-16
c5801 0 1021 2.926e-15
c5802 374 186 2.8e-16
c5803 885 185 2.14e-16
c5804 0 1449 2.623e-15
c5805 59 56 2.32e-16
c5806 1775 237 7.23e-16
c5807 1773 239 7.76e-16
c5808 20 209 1.9e-16
c5809 2585 2562 1.271e-15
c5810 2632 2555 1.58e-16
c5811 2320 2347 3.92e-16
c5812 214 142 1.9e-16
c5813 213 136 3.34e-16
c5814 2855 2842 1.96e-16
c5815 2506 215 2.186e-15
c5816 1 2275 1.6e-16
c5817 2687 2691 1.6e-16
c5818 1 345 1.6e-16
c5819 2060 2061 6.77e-16
c5820 1 2793 1.173e-15
c5821 0 1776 2.957e-15
c5822 2269 0 2.926e-15
c5823 20 203 1.99e-16
c5824 2632 2567 4.69e-16
c5825 2655 2550 1.96e-16
c5826 2637 2351 1.372e-15
c5827 1 657 1.6e-16
c5828 1115 234 7.91e-16
c5829 0 2088 2.957e-15
c5830 1 1598 1.6e-16
c5831 2322 194 5.7e-16
c5832 2296 2490 2.32e-16
c5833 27 212 1.99e-16
c5834 1 969 1.6e-16
c5835 1787 187 2.8e-16
c5836 1791 181 7.23e-16
c5837 1789 183 7.76e-16
c5838 2548 2492 1.58e-16
c5839 2299 2348 7.84e-16
c5840 0 306 2.957e-15
c5841 0 801 2.623e-15
c5842 810 211 7.23e-16
c5843 1 2433 1.999e-15
c5844 0 1725 2.926e-15
c5845 1267 1266 6.77e-16
c5846 80 20 1.59e-16
c5847 0 618 2.957e-15
c5848 3 243 3.48e-16
c5849 2299 2510 1.013e-15
c5850 0 1113 2.623e-15
c5851 1 2312 1.456e-15
c5852 2203 2202 6.77e-16
c5853 1095 226 7.23e-16
c5854 1094 227 7.91e-16
c5855 0 2054 2.623e-15
c5856 1508 240 2.13e-16
c5857 2645 2465 1.96e-16
c5858 2312 2467 1.96e-16
c5859 2294 2462 2.12e-16
c5860 0 436 2.585e-15
c5861 440 217 7.77e-16
c5862 235 153 3.34e-16
c5863 589 223 7.76e-16
c5864 590 591 6.77e-16
c5865 0 930 2.957e-15
c5866 1787 1786 6.77e-16
c5867 1414 194 2.8e-16
c5868 63 216 1.94e-16
c5869 1913 185 2.54e-16
c5870 1912 184 2.13e-16
c5871 2386 2396 1.6e-16
c5872 2305 2552 1.96e-16
c5873 222 163 1.9e-16
c5874 224 174 3.24e-16
c5875 0 255 2.957e-15
c5876 0 748 2.585e-15
c5877 874 243 7.23e-16
c5878 1296 191 2.13e-16
c5879 1298 189 2.5e-16
c5880 1345 215 7.91e-16
c5881 1 1262 1.6e-16
c5882 225 111 3.31e-16
c5883 2149 240 7.76e-16
c5884 1 2198 1.6e-16
c5885 0 224 2.5783e-14
c5886 0 1077 2.926e-15
c5887 164 134 4.85e-16
c5888 1228 222 8.32e-16
c5889 0 1520 2.957e-15
c5890 1543 195 2.5e-16
c5891 1 227 3.708e-15
c5892 2099 2098 6.77e-16
c5893 2043 186 7.91e-16
c5894 2046 180 7.91e-16
c5895 2044 182 8.32e-16
c5896 217 163 3.31e-16
c5897 0 560 2.957e-15
c5898 2351 2630 3.39e-16
c5899 2652 2697 1.96e-16
c5900 2827 2719 1.037e-15
c5901 2823 2675 1.188e-15
c5902 0 1503 2.957e-15
c5903 1 401 1.6e-16
c5904 0 2013 2.926e-15
c5905 0 1832 2.957e-15
c5906 2350 2342 1.38e-16
c5907 196 174 1.99e-16
c5908 1993 225 2.54e-16
c5909 413 199 7.76e-16
c5910 415 197 7.23e-16
c5911 411 203 2.8e-16
c5912 207 115 3.24e-16
c5913 105 216 1.94e-16
c5914 0 891 2.623e-15
c5915 1422 1423 6.77e-16
c5916 1 382 1.6e-16
c5917 1 205 3.749e-15
c5918 1 892 1.6e-16
c5919 1 713 1.6e-16
c5920 2180 192 2.13e-16
c5921 0 196 2.5429e-14
c5922 3 193 2.38e-16
c5923 219 126 1.99e-16
c5924 115 202 1.99e-16
c5925 111 198 1.9e-16
c5926 2333 2320 1.58e-16
c5927 0 1203 2.623e-15
c5928 1 200 3.792e-15
c5929 1 2694 2.88e-16
c5930 1 1204 1.6e-16
c5931 1 1649 1.6e-16
c5932 58 194 3.34e-16
c5933 48 185 3.31e-16
c5934 52 183 3.24e-16
c5935 2545 0 2.3868e-14
c5936 2434 2433 1.149e-15
c5937 1417 1416 6.77e-16
c5938 2123 226 7.91e-16
c5939 1050 203 7.23e-16
c5940 230 480 7.77e-16
c5941 2827 2849 4.87e-16
c5942 2652 2655 8.27e-16
c5943 985 232 7.91e-16
c5944 1617 223 7.91e-16
c5945 1 1961 1.6e-16
c5946 2592 2580 3.22e-16
c5947 122 90 1.58e-16
c5948 164 87 4.85e-16
c5949 229 479 7.23e-16
c5950 228 478 7.91e-16
c5951 222 136 3.31e-16
c5953 697 216 7.91e-16
c5954 2732 2641 1.58e-16
c5955 1337 217 2.54e-16
c5956 1336 216 2.13e-16
c5957 0 1793 2.623e-15
c5958 1657 185 2.54e-16
c5959 1656 184 2.13e-16
c5960 2802 0 1.96e-16
c5961 101 106 1.34e-16
c5962 2256 223 2.13e-16
c5963 2639 2312 1.58e-16
c5964 2652 2574 1.093e-15
c5965 0 1167 2.957e-15
c5966 353 352 6.77e-16
c5967 1 2805 5.08e-16
c5968 243 618 7.23e-16
c5969 0 1610 2.957e-15
c5970 2220 2221 6.77e-16
c5971 1744 222 7.77e-16
c5972 0 2105 2.623e-15
c5973 8 2351 6.46e-16
c5974 142 216 3.24e-16
c5975 136 217 1.9e-16
c5976 2465 2407 1.58e-16
c5977 1 491 1.6e-16
c5978 0 1428 2.585e-15
c5979 1804 1805 6.77e-16
c5980 27 221 1.99e-16
c5981 965 224 7.76e-16
c5982 143 48 3.26e-16
c5983 14 181 1.99e-16
c5984 0 323 2.623e-15
c5985 822 219 7.91e-16
c5986 2471 2837 1.71e-15
c5987 1 324 1.6e-16
c5988 2041 2040 6.77e-16
c5989 699 698 6.77e-16
c5990 0 1740 2.585e-15
c5991 1783 187 2.5e-16
c5992 1 1313 1.6e-16
c5993 1 2249 1.6e-16
c5994 0 43 1.82e-16
c5995 736 231 2.13e-16
c5996 27 218 3.34e-16
c5997 0 1559 2.957e-15
c5998 0 2069 2.926e-15
c5999 2116 2117 6.77e-16
c6000 1914 187 7.23e-16
c6001 1364 1365 6.77e-16
c6002 2351 2425 1.96e-16
c6003 2651 2377 1.96e-16
c6004 242 153 3.34e-16
c6005 0 947 2.623e-15
c6006 1 948 1.6e-16
c6007 8 40 1.96e-16
c6008 1011 1010 6.77e-16
c6009 1 1393 1.6e-16
c6010 48 231 1.94e-16
c6011 1867 226 7.91e-16
c6012 0 270 2.623e-15
c6013 794 203 7.23e-16
c6014 2793 2776 7.3e-16
c6015 2764 2789 1.96e-16
c6016 0 1274 2.957e-15
c6017 0 100 7.8194e-14
c6018 2490 2480 3.92e-16
c6019 2422 2390 4.79e-16
c6020 280 200 2.13e-16
c6021 281 201 2.54e-16
c6022 1 1705 1.6e-16
c6023 52 238 3.31e-16
c6024 0 577 2.623e-15
c6025 2649 2592 1.96e-16
c6026 2389 2429 1.96e-16
c6027 1600 1601 6.77e-16
c6028 571 570 6.77e-16
c6029 0 1518 2.623e-15
c6030 0 1339 2.623e-15
c6031 73 187 1.99e-16
c6032 69 180 1.99e-16
c6033 63 183 3.24e-16
c6034 0 2028 2.585e-15
c6035 1488 222 7.77e-16
c6036 0 1849 2.623e-15
c6037 1 1340 1.6e-16
c6038 2259 2258 6.77e-16
c6039 58 214 1.9e-16
c6040 2000 223 2.13e-16
c6041 0 394 2.957e-15
c6042 329 328 6.77e-16
c6043 2590 2516 1.58e-16
c6044 0 904 2.957e-15
c6045 2827 0 1.6269e-14
c6046 920 201 7.77e-16
c6047 2471 2637 1.58e-16
c6048 2655 2338 5.57e-16
c6049 855 234 7.23e-16
c6050 854 235 7.91e-16
c6051 1487 221 7.23e-16
c6052 1486 220 7.91e-16
c6053 0 1830 2.623e-15
c6054 2022 2023 6.77e-16
c6055 2544 220 1.206e-15
c6056 231 349 7.76e-16
c6057 554 210 2.5e-16
c6058 558 205 2.8e-16
c6059 557 206 2.14e-16
c6060 556 207 2.13e-16
c6061 559 204 2.5e-16
c6062 0 1216 2.957e-15
c6063 1527 187 2.5e-16
c6064 0 2159 2.957e-15
c6065 1626 235 7.23e-16
c6066 192 153 3.24e-16
c6067 0 541 2.926e-15
c6068 180 168 3.34e-16
c6069 184 163 3.24e-16
c6070 1 1998 1.6e-16
c6071 241 489 2.54e-16
c6072 1 1038 1.6e-16
c6073 122 61 8.48e-16
c6074 1 1483 1.6e-16
c6075 14 236 1.99e-16
c6076 2572 2598 3.92e-16
c6077 2490 222 5.06e-16
c6078 0 853 2.926e-15
c6079 105 183 3.24e-16
c6080 2654 2838 1.58e-16
c6081 2697 2847 2.21e-16
c6082 1195 211 2.8e-16
c6083 1199 205 7.23e-16
c6084 1197 207 7.76e-16
c6085 1668 192 2.13e-16
c6086 20 0 7.793e-14
c6087 19 0 9.2142e-14
c6088 692 217 8.32e-16
c6089 693 216 7.76e-16
c6090 1 2286 1.6e-16
c6091 2733 8 3.35e-16
c6092 2687 2465 3.92e-16
c6093 0 1182 2.623e-15
c6094 1043 188 2.8e-16
c6095 953 952 6.77e-16
c6096 0 1627 2.623e-15
c6097 1128 241 7.77e-16
c6098 1 1628 1.6e-16
c6099 2358 2590 2.46e-16
c6100 2645 2351 2.34e-15
c6101 2490 217 5.06e-16
c6102 1894 1895 6.77e-16
c6103 233 469 2.14e-16
c6104 1118 229 2.8e-16
c6105 0 1920 2.957e-15
c6106 1028 1029 6.77e-16
c6107 276 277 6.77e-16
c6108 2630 2561 1.34e-16
c6109 1473 1472 6.77e-16
c6110 2820 2665 7.33e-16
c6111 73 229 3.34e-16
c6112 1737 224 7.91e-16
c6113 2767 0 2.76e-16
c6114 0 633 2.623e-15
c6115 664 201 7.77e-16
c6116 243 100 3.34e-16
c6117 2245 224 7.76e-16
c6118 2471 2630 4.1e-16
c6119 599 234 7.23e-16
c6120 598 235 7.91e-16
c6121 232 233 2e-16
c6122 0 1574 2.623e-15
c6123 1724 214 8.32e-16
c6124 0 631 2.957e-15
c6125 2312 2427 1.96e-16
c6126 2358 2422 1.96e-16
c6127 2649 2382 1.96e-16
c6128 2318 2379 1.96e-16
c6129 142 183 1.94e-16
c6130 136 184 1.94e-16
c6131 1 470 1.6e-16
c6132 63 238 3.31e-16
c6133 0 1903 2.957e-15
c6134 2276 2277 6.77e-16
c6135 0 285 2.926e-15
c6136 0 943 2.957e-15
c6137 752 239 2.13e-16
c6138 754 237 2.5e-16
c6139 0 1386 2.957e-15
c6140 1265 238 2.54e-16
c6141 1267 236 2.8e-16
c6142 0 1291 2.623e-15
c6143 0 1881 2.623e-15
c6144 1 782 1.6e-16
c6145 1 1292 1.6e-16
c6146 2208 0 2.957e-15
c6147 2797 122 4.09e-16
c6148 234 115 1.99e-16
c6149 220 90 1.99e-16
c6150 1 267 1.6e-16
c6151 1302 203 7.91e-16
c6152 725 232 7.76e-16
c6153 0 1698 2.957e-15
c6154 27 185 3.31e-16
c6155 1 1094 1.6e-16
c6156 239 163 1.94e-16
c6157 1345 1344 6.77e-16
c6158 1 1539 1.6e-16
c6159 3 223 3.08e-16
c6160 228 132 1.99e-16
c6161 230 126 3.31e-16
c6162 425 208 7.91e-16
c6163 164 150 4.85e-16
c6164 0 1533 2.926e-15
c6165 1 1089 1.6e-16
c6166 1397 185 2.14e-16
c6167 52 227 1.99e-16
c6168 0 411 2.623e-15
c6169 215 153 1.94e-16
c6170 238 105 3.31e-16
c6171 79 211 3.34e-16
c6172 2333 2308 4.89e-16
c6173 768 183 2.13e-16
c6174 770 181 2.5e-16
c6175 1 412 1.6e-16
c6176 862 229 2.8e-16
c6177 1281 182 2.54e-16
c6178 1283 180 2.8e-16
c6179 0 1845 2.926e-15
c6180 1996 222 8.32e-16
c6181 0 104 1.14e-16
c6182 100 193 3.31e-16
c6183 84 195 1.99e-16
c6184 2477 2469 1.38e-16
c6185 0 723 2.623e-15
c6186 20 243 1.99e-16
c6187 2634 2651 1.96e-16
c6188 2471 8 7.45e-16
c6189 1 2346 1.424e-15
c6190 566 218 2.8e-16
c6191 0 1233 2.623e-15
c6192 1 2714 2.88e-16
c6193 1 724 1.6e-16
c6194 101 29 2.44e-16
c6195 58 216 3.24e-16
c6196 48 207 1.94e-16
c6197 52 205 3.34e-16
c6198 2462 0 2.1126e-14
c6199 2296 2379 1.58e-16
c6200 2343 2409 4.4e-16
c6201 2351 2407 2.44e-16
c6202 2641 2572 1.58e-16
c6203 0 1050 2.957e-15
c6204 1 2467 2.105e-15
c6205 143 27 3.26e-16
c6206 52 200 1.94e-16
c6207 48 202 3.34e-16
c6208 1477 225 2.14e-16
c6209 2126 221 2.8e-16
c6210 396 190 8.32e-16
c6211 398 188 7.91e-16
c6212 395 194 7.91e-16
c6213 0 358 2.623e-15
c6214 0 868 2.585e-15
c6215 228 147 3.34e-16
c6216 904 193 7.77e-16
c6217 2654 2822 3.15e-16
c6218 806 807 6.77e-16
c6219 988 231 2.13e-16
c6220 2003 2002 6.77e-16
c6221 1825 198 2.54e-16
c6222 1827 196 2.8e-16
c6223 2632 2609 3.47e-16
c6224 2407 2397 3.92e-16
c6225 101 84 1.58e-16
c6226 14 225 3.31e-16
c6227 2732 2364 1.881e-15
c6228 2299 2312 1.23e-15
c6229 1 2845 9.02e-16
c6230 1009 238 2.54e-16
c6231 1011 236 2.8e-16
c6232 1968 206 7.77e-16
c6233 1969 207 7.91e-16
c6234 1970 204 7.23e-16
c6235 1971 205 7.91e-16
c6236 2364 2358 7.84e-16
c6237 2312 2740 1.948e-15
c6238 2647 2746 1.58e-16
c6239 142 238 1.9e-16
c6240 136 239 3.24e-16
c6241 1034 194 2.5e-16
c6242 1038 189 2.8e-16
c6243 1037 190 2.14e-16
c6244 1036 191 2.13e-16
c6245 1039 188 2.5e-16
c6246 1 2648 2.88e-16
c6247 1 521 1.6e-16
c6248 0 1442 2.957e-15
c6249 27 231 1.94e-16
c6250 1118 1119 6.77e-16
c6251 0 1937 2.623e-15
c6252 180 181 6.86e-16
c6253 1 833 1.6e-16
c6254 1386 243 7.23e-16
c6255 20 193 1.9e-16
c6256 14 198 1.9e-16
c6257 0 334 2.623e-15
c6258 1 1774 1.6e-16
c6259 2649 2333 1.96e-16
c6260 2318 2384 1.96e-16
c6261 214 320 7.77e-16
c6262 1638 1639 6.77e-16
c6263 0 1589 2.926e-15
c6264 1108 233 8.32e-16
c6265 1 1145 1.6e-16
c6266 1733 224 7.76e-16
c6267 2322 183 7.64e-16
c6268 2634 2585 3.92e-16
c6269 1 2086 1.6e-16
c6270 1875 1874 6.77e-16
c6271 31 213 3.34e-16
c6272 1188 1189 6.77e-16
c6273 1633 1632 6.77e-16
c6274 0 958 2.623e-15
c6275 257 256 6.77e-16
c6276 213 450 2.5e-16
c6277 212 451 2.8e-16
c6278 0 794 2.957e-15
c6279 806 210 2.8e-16
c6280 1 2434 1.79e-16
c6281 0 1403 2.623e-15
c6282 1950 1951 6.77e-16
c6283 1723 219 2.8e-16
c6284 63 227 1.99e-16
c6285 1870 221 2.8e-16
c6286 2225 0 2.623e-15
c6287 2231 219 2.5e-16
c6288 2510 2432 2.24e-16
c6289 2779 122 7.59e-16
c6290 38 13 1.433e-15
c6291 2675 2351 1.96e-16
c6292 241 115 1.9e-16
c6293 0 1287 2.957e-15
c6294 1 2639 1.411e-15
c6295 0 1715 2.623e-15
c6296 1 240 3.792e-15
c6297 1569 198 2.54e-16
c6298 1571 196 2.8e-16
c6299 1 1716 1.6e-16
c6300 213 94 3.34e-16
c6301 212 84 3.34e-16
c6302 2643 2508 1.96e-16
c6303 2647 2505 1.96e-16
c6304 2639 2467 1.96e-16
c6305 935 211 2.5e-16
c6306 73 210 1.99e-16
c6307 63 205 3.34e-16
c6308 1497 232 7.91e-16
c6309 1 71 2.79e-16
c6310 215 576 2.13e-16
c6311 778 194 2.5e-16
c6312 782 189 2.8e-16
c6313 781 190 2.14e-16
c6314 780 191 2.13e-16
c6315 783 188 2.5e-16
c6316 243 358 7.91e-16
c6317 242 359 7.23e-16
c6318 0 1350 2.623e-15
c6319 69 197 1.99e-16
c6320 63 200 1.94e-16
c6321 1 923 1.6e-16
c6322 0 1860 2.585e-15
c6323 2687 2351 4.14e-16
c6324 2298 2641 1.58e-16
c6325 2665 2649 4.69e-16
c6326 2471 2645 1.92e-16
c6327 2389 2358 1.167e-15
c6328 2296 2384 1.58e-16
c6329 227 105 1.99e-16
c6330 1076 216 2.13e-16
c6331 2201 200 7.91e-16
c6332 2462 2396 2.31e-16
c6333 2036 185 8.32e-16
c6334 2037 184 7.76e-16
c6335 211 157 1.99e-16
c6336 2136 232 2.13e-16
c6337 206 163 1.9e-16
c6338 1 2171 1.6e-16
c6339 2635 2587 1.96e-16
c6340 0 1067 2.623e-15
c6341 1 558 1.6e-16
c6342 1217 214 2.54e-16
c6343 1 1068 1.6e-16
c6344 1631 228 2.5e-16
c6345 197 168 3.34e-16
c6346 201 163 3.31e-16
c6347 187 174 3.34e-16
c6348 2351 2492 6.03e-16
c6349 2590 2572 1.58e-16
c6350 0 373 2.926e-15
c6351 1580 1581 6.77e-16
c6352 2545 223 3.57e-16
c6353 205 105 3.34e-16
c6354 90 186 3.34e-16
c6355 122 76 7.01e-16
c6356 2289 238 2.54e-16
c6357 209 126 1.9e-16
c6358 115 191 3.24e-16
c6359 105 200 1.94e-16
c6360 1227 1226 6.77e-16
c6361 0 187 2.5224e-14
c6362 3 182 2.38e-16
c6363 475 474 6.77e-16
c6364 1 189 3.749e-15
c6365 5 4 1.198e-15
c6366 203 126 1.99e-16
c6367 58 183 1.94e-16
c6368 2758 8 2.36e-16
c6369 2116 225 8.32e-16
c6370 1 2137 1.6e-16
c6371 1006 237 2.8e-16
c6372 1005 238 2.14e-16
c6373 1004 239 2.13e-16
c6374 1007 236 2.5e-16
c6375 1046 202 2.8e-16
c6376 0 1459 2.623e-15
c6377 1963 211 2.8e-16
c6378 1 1460 1.6e-16
c6379 227 142 3.34e-16
c6380 0 1326 2.623e-15
c6381 787 786 6.77e-16
c6382 0 1786 2.957e-15
c6383 1809 190 2.54e-16
c6384 1811 188 2.8e-16
c6385 1297 1296 6.77e-16
c6386 1896 241 7.77e-16
c6387 2798 0 1.2082e-14
c6388 2296 2837 2.88e-16
c6389 2637 2318 2.007e-15
c6390 225 329 2.54e-16
c6391 1 2776 1.15e-15
c6392 1 667 1.6e-16
c6393 0 1604 2.585e-15
c6394 862 863 6.77e-16
c6395 0 2098 2.957e-15
c6396 1740 223 2.13e-16
c6397 0 644 2.585e-15
c6398 0 480 2.957e-15
c6399 142 205 1.99e-16
c6400 136 206 3.31e-16
c6401 1018 186 2.5e-16
c6402 1022 181 2.8e-16
c6403 1021 182 2.14e-16
c6404 1020 183 2.13e-16
c6405 1023 180 2.5e-16
c6406 0 1423 2.957e-15
c6407 42 224 1.94e-16
c6408 31 222 3.31e-16
c6409 1 979 1.6e-16
c6410 1099 1098 6.77e-16
c6411 142 200 3.24e-16
c6412 136 201 1.9e-16
c6413 1880 232 2.13e-16
c6414 226 459 7.91e-16
c6415 2389 2834 2.38e-16
c6416 2825 2835 1.342e-15
c6417 1106 220 7.23e-16
c6418 0 1416 2.957e-15
c6419 1432 201 7.77e-16
c6420 1316 208 2.13e-16
c6421 1 812 1.6e-16
c6422 1367 234 7.23e-16
c6423 1366 235 7.91e-16
c6424 0 1735 2.957e-15
c6425 1 1915 1.6e-16
c6426 2490 2522 1.96e-16
c6427 229 174 1.99e-16
c6428 2572 2515 2.14e-16
c6429 2574 2516 1.58e-16
c6430 212 447 2.5e-16
c6431 2697 2358 1.96e-16
c6432 8 90 3.47e-16
c6433 1798 1799 6.77e-16
c6434 649 192 7.91e-16
c6435 0 1302 2.623e-15
c6436 422 423 6.77e-16
c6437 1 297 1.6e-16
c6438 37 211 3.34e-16
c6439 27 207 1.94e-16
c6440 31 217 1.9e-16
c6441 2221 0 2.926e-15
c6442 2572 2527 6.05e-16
c6443 1 1124 1.6e-16
c6444 2635 0 3.1714e-14
c6445 80 59 1.96e-16
c6446 0 229 2.3925e-14
c6447 223 100 1.94e-16
c6448 222 94 3.31e-16
c6449 221 84 3.34e-16
c6450 42 196 3.34e-16
c6451 27 202 3.34e-16
c6452 1 609 1.6e-16
c6453 1562 202 2.5e-16
c6454 1566 197 2.8e-16
c6455 1565 198 2.14e-16
c6456 1564 199 2.13e-16
c6457 1567 196 2.5e-16
c6458 1169 1168 6.77e-16
c6459 0 2040 2.957e-15
c6460 1 1550 1.6e-16
c6461 48 234 3.34e-16
c6462 2590 2556 6.99e-16
c6463 0 1365 2.926e-15
c6464 2110 2111 6.77e-16
c6465 734 735 6.77e-16
c6466 1707 211 2.8e-16
c6467 1711 205 7.23e-16
c6468 1709 207 7.76e-16
c6469 1244 1245 6.77e-16
c6470 94 217 1.9e-16
c6471 84 218 1.99e-16
c6472 3 237 6.13e-16
c6473 2576 231 3.12e-16
c6474 492 493 6.77e-16
c6475 774 195 7.91e-16
c6476 2655 2358 1.348e-15
c6477 2296 2637 1.376e-15
c6478 1 244 1.6e-16
c6479 1286 194 2.8e-16
c6480 2180 2181 6.77e-16
c6481 2377 2354 4.5e-16
c6482 2382 2348 5.66e-16
c6483 2490 2443 2.77e-16
c6484 2379 2360 1.88e-16
c6485 1640 241 7.77e-16
c6486 58 238 1.9e-16
c6487 2298 2590 2.44e-16
c6488 0 570 2.957e-15
c6489 213 121 1.99e-16
c6490 2145 231 7.91e-16
c6491 2318 2630 3.47e-16
c6492 1 2427 1.053e-15
c6493 0 2023 2.957e-15
c6494 2347 2348 1.149e-15
c6495 2305 2490 1.58e-16
c6496 2364 2572 1.58e-16
c6497 2358 2574 3.54e-16
c6498 2294 2409 3.54e-16
c6499 0 388 2.585e-15
c6500 1 52 7.6e-16
c6501 1 902 1.6e-16
c6502 2381 193 1.207e-15
c6503 2757 2771 1.58e-16
c6504 549 209 2.14e-16
c6505 850 220 7.23e-16
c6506 1060 208 2.13e-16
c6507 1 1214 1.6e-16
c6508 1 1659 1.6e-16
c6509 20 223 3.24e-16
c6510 181 153 1.99e-16
c6511 2298 2422 1.58e-16
c6512 0 1029 2.926e-15
c6513 702 213 2.8e-16
c6514 0 1472 2.957e-15
c6515 1975 218 7.23e-16
c6516 0 531 2.623e-15
c6517 364 365 6.77e-16
c6518 1561 1560 6.77e-16
c6519 1 1971 1.6e-16
c6520 376 185 7.77e-16
c6521 889 184 7.91e-16
c6522 1040 1041 6.77e-16
c6523 1777 238 2.54e-16
c6524 1779 236 2.8e-16
c6525 2277 0 2.926e-15
c6526 2815 0 2.08e-16
c6527 0 843 2.623e-15
c6528 2822 2861 1.96e-16
c6529 1 6 2.644e-15
c6530 1124 240 2.13e-16
c6531 1455 205 7.23e-16
c6532 2318 8 2.53e-16
c6533 2296 2630 2.11e-16
c6534 710 711 6.77e-16
c6535 0 1155 2.623e-15
c6536 1 1156 1.6e-16
c6537 1 1601 1.6e-16
c6538 1951 197 7.23e-16
c6539 1949 199 7.76e-16
c6540 2469 0 6.764e-15
c6541 1 1918 1.6e-16
c6543 2820 2825 1.58e-16
c6544 961 215 7.91e-16
c6545 8 61 1.96e-16
c6546 1374 229 2.8e-16
c6547 1793 182 2.54e-16
c6548 1795 180 2.8e-16
c6549 2288 2289 6.77e-16
c6550 1876 233 8.32e-16
c6551 2734 0 1.306e-14
c6552 0 807 2.957e-15
c6553 2389 2831 2.38e-16
c6554 957 214 2.14e-16
c6555 1159 195 2.5e-16
c6556 1 2299 5.93e-16
c6557 1022 1023 6.77e-16
c6558 1577 209 2.54e-16
c6559 1576 208 2.13e-16
c6560 2236 0 2.585e-15
c6561 644 193 8.32e-16
c6562 645 192 7.76e-16
c6563 2639 2427 1.96e-16
c6564 2318 2425 1.96e-16
c6565 2299 2467 4.11e-16
c6566 2389 2572 1.58e-16
c6567 0 1119 2.957e-15
c6568 1 2740 7.06e-16
c6569 0 2057 2.623e-15
c6570 2530 2517 4.77e-16
c6571 52 240 1.94e-16
c6572 48 241 3.31e-16
c6573 2023 243 2.5e-16
c6574 233 163 3.31e-16
c6575 0 1380 2.585e-15
c6576 1416 193 7.77e-16
c6577 1 443 1.6e-16
c6578 0 1874 2.957e-15
c6579 1500 231 2.13e-16
c6580 1 63 7.6e-16
c6581 2215 210 7.23e-16
c6582 220 178 3.34e-16
c6583 0 256 2.957e-15
c6584 2384 2360 1.58e-16
c6585 1779 1778 6.77e-16
c6586 2759 2760 3.5e-16
c6587 2794 101 5.51e-16
c6588 31 184 1.94e-16
c6589 1 755 1.6e-16
c6590 0 1692 2.585e-15
c6591 2270 2271 6.77e-16
c6592 913 912 6.77e-16
c6593 1 1265 1.6e-16
c6594 1521 238 2.54e-16
c6595 1523 236 2.8e-16
c6596 1858 212 7.23e-16
c6597 236 153 1.99e-16
c6598 2298 2364 8.32e-16
c6599 2296 8 1.58e-16
c6600 0 587 2.623e-15
c6601 222 121 1.9e-16
c6602 1 2201 1.6e-16
c6603 3 226 6.13e-16
c6604 721 222 2.54e-16
c6605 38 41 1.34e-16
c6606 1 588 1.6e-16
c6607 1854 1855 6.77e-16
c6608 1233 223 7.91e-16
c6609 1546 194 2.5e-16
c6610 1550 189 2.8e-16
c6611 1549 190 2.14e-16
c6612 1548 191 2.13e-16
c6613 1551 188 2.5e-16
c6614 210 174 3.34e-16
c6615 0 161 1.14e-16
c6616 2141 231 7.76e-16
c6617 2651 2545 1.96e-16
c6618 2643 2632 1.96e-16
c6619 2635 2543 1.96e-16
c6620 2647 2627 3.24e-16
c6621 58 227 3.34e-16
c6622 143 148 1.34e-16
c6623 90 208 3.24e-16
c6624 2091 2090 6.77e-16
c6625 1273 185 2.54e-16
c6626 1272 184 2.13e-16
c6627 1844 216 2.13e-16
c6628 217 121 3.31e-16
c6629 211 111 3.34e-16
c6630 100 182 1.9e-16
c6631 94 184 1.94e-16
c6632 84 185 1.9e-16
c6633 79 195 3.34e-16
c6634 0 210 2.3912e-14
c6635 3 204 3.48e-16
c6636 2278 242 2.8e-16
c6637 0 1226 2.957e-15
c6638 1 105 7.6e-16
c6639 0 126 7.793e-14
c6640 3 199 3.08e-16
c6641 58 205 1.99e-16
c6642 2510 219 9.65e-16
c6643 2377 188 8.84e-16
c6644 2709 2382 3.92e-16
c6645 2296 2425 1.58e-16
c6646 0 1044 2.585e-15
c6647 143 29 3.31e-16
c6648 548 549 6.77e-16
c6649 895 894 6.77e-16
c6650 58 200 3.24e-16
c6651 48 191 1.94e-16
c6652 52 189 3.34e-16
c6653 2299 2434 7.84e-16
c6654 389 192 7.76e-16
c6655 388 193 8.32e-16
c6656 1056 198 7.77e-16
c6657 1057 199 7.91e-16
c6658 233 136 1.9e-16
c6659 0 863 2.957e-15
c6660 2675 2848 1.114e-15
c6661 2823 2855 1.96e-16
c6662 0 1470 2.623e-15
c6663 0 1801 2.623e-15
c6664 1817 201 2.54e-16
c6665 1816 200 2.13e-16
c6666 101 79 1.58e-16
c6667 80 82 2.17e-16
c6668 1726 1727 6.77e-16
c6669 839 227 2.5e-16
c6670 0 1799 2.957e-15
c6671 1814 202 2.8e-16
c6672 1 697 1.6e-16
c6673 0 2113 2.623e-15
c6674 1484 1485 6.77e-16
c6675 59 0 1.9487e-14
c6676 143 84 3.26e-16
c6677 2320 0 2.88e-14
c6678 2318 2645 1.459e-15
c6679 2665 2510 1.5e-15
c6680 2643 2647 5.88e-16
c6681 222 332 8.32e-16
c6682 0 1168 2.957e-15
c6683 1 678 1.6e-16
c6684 1029 193 2.14e-16
c6685 1447 211 2.5e-16
c6686 27 234 3.34e-16
c6687 0 2111 2.957e-15
c6688 1 1009 1.6e-16
c6689 1602 212 7.23e-16
c6690 122 55 7.01e-16
c6691 0 493 2.926e-15
c6692 228 610 7.23e-16
c6693 1 142 7.6e-16
c6694 1 990 1.6e-16
c6695 1943 203 2.5e-16
c6696 63 240 1.94e-16
c6697 1 1435 1.6e-16
c6698 1885 231 7.76e-16
c6699 20 182 3.31e-16
c6700 2545 2534 1.25e-16
c6701 0 822 2.623e-15
c6702 221 462 2.8e-16
c6703 827 218 7.91e-16
c6704 2389 2298 1.262e-15
c6705 2634 2838 1.58e-16
c6706 2825 2843 5.18e-16
c6707 1 2257 1.6e-16
c6708 31 239 3.24e-16
c6709 1588 216 2.13e-16
c6710 1 1747 1.6e-16
c6711 231 84 3.24e-16
c6712 2241 215 7.91e-16
c6713 2634 2646 1.6e-16
c6714 2655 2572 1.82e-16
c6715 502 187 7.91e-16
c6716 0 1134 2.623e-15
c6717 691 690 6.77e-16
c6718 0 1560 2.957e-15
c6719 1920 182 7.77e-16
c6720 1921 183 7.91e-16
c6721 1922 180 7.23e-16
c6722 1923 181 7.91e-16
c6723 307 205 7.91e-16
c6724 306 204 7.23e-16
c6725 305 207 7.91e-16
c6726 304 206 7.77e-16
c6727 954 219 7.23e-16
c6728 0 1891 2.623e-15
c6729 2574 2572 2.923e-15
c6730 237 100 1.99e-16
c6731 239 94 3.24e-16
c6732 1 1892 1.6e-16
c6733 0 273 2.623e-15
c6734 2543 2469 4.56e-16
c6735 2588 231 2.186e-15
c6736 800 198 7.77e-16
c6737 801 199 7.91e-16
c6738 802 196 7.23e-16
c6739 803 197 7.91e-16
c6740 2764 2792 1.96e-16
c6741 2787 101 1.443e-15
c6742 240 105 1.94e-16
c6743 1003 1002 6.77e-16
c6744 2296 2645 1.58e-16
c6745 628 185 8.32e-16
c6746 629 184 7.76e-16
c6747 243 126 1.99e-16
c6748 212 79 1.99e-16
c6749 2343 2510 2.95e-16
c6750 583 227 2.5e-16
c6751 1518 237 2.8e-16
c6752 1517 238 2.14e-16
c6753 1516 239 2.13e-16
c6754 1519 236 2.5e-16
c6755 2057 193 2.54e-16
c6756 2056 192 2.13e-16
c6757 1078 1079 6.77e-16
c6758 2312 2592 2.83e-16
c6759 2643 2550 1.96e-16
c6760 2647 2548 1.96e-16
c6761 225 153 3.31e-16
c6762 0 912 2.957e-15
c6763 1523 1522 6.77e-16
c6764 73 194 1.99e-16
c6765 63 189 3.34e-16
c6766 0 1855 2.957e-15
c6767 563 562 6.77e-16
c6768 758 186 2.8e-16
c6769 2759 2761 1.58e-16
c6770 2709 2333 3.92e-16
c6771 2655 2340 3.54e-16
c6772 1269 185 2.14e-16
c6773 1073 1072 6.77e-16
c6774 1687 203 2.5e-16
c6775 2159 237 7.23e-16
c6776 2157 239 7.76e-16
c6777 0 549 2.926e-15
c6778 2318 2407 1.58e-16
c6779 638 639 6.77e-16
c6780 1530 186 2.5e-16
c6781 1534 181 2.8e-16
c6782 1533 182 2.14e-16
c6783 1532 183 2.13e-16
c6784 1535 180 2.5e-16
c6785 1835 1834 6.77e-16
c6786 195 157 1.99e-16
c6787 198 153 1.9e-16
c6788 1 1491 1.6e-16
c6789 190 163 1.9e-16
c6790 186 178 1.99e-16
c6791 1 2001 1.6e-16
c6792 2548 225 7.02e-16
c6793 240 142 3.24e-16
c6794 0 878 2.623e-15
c6795 0 1485 2.926e-15
c6796 1 1041 1.6e-16
c6797 1473 214 2.54e-16
c6798 20 237 3.34e-16
c6799 121 184 3.24e-16
c6800 115 180 3.34e-16
c6801 105 189 3.34e-16
c6802 2820 0 1.8877e-14
c6803 2719 2843 1.675e-15
c6804 1201 206 2.54e-16
c6805 1203 204 2.8e-16
c6806 1668 1669 6.77e-16
c6807 1 129 2.79e-16
c6808 10 0 1.99e-16
c6809 193 126 1.9e-16
c6810 1 1636 1.6e-16
c6811 2663 0 1.65e-16
c6812 0 690 2.957e-15
c6813 1 2289 1.6e-16
c6814 0 1185 2.623e-15
c6815 1905 1904 6.77e-16
c6816 1 2668 2.88e-16
c6817 27 241 3.31e-16
c6818 2322 2346 3.92e-16
c6819 1610 226 2.5e-16
c6820 1611 227 2.8e-16
c6821 2409 0 4.2053e-14
c6822 2429 2435 4.77e-16
c6823 0 508 2.585e-15
c6824 164 172 3.02e-16
c6825 1 1948 1.6e-16
c6826 0 1002 2.957e-15
c6827 1 2322 1.69e-15
c6828 232 472 2.13e-16
c6829 1120 230 7.77e-16
c6830 1801 193 2.54e-16
c6831 1800 192 2.13e-16
c6832 1892 240 2.13e-16
c6833 2574 2556 3.92e-16
c6834 2572 2555 3.92e-16
c6835 2630 2568 1.34e-16
c6836 2655 2298 8.98e-16
c6837 8 76 1.96e-16
c6838 1 164 2.0237e-14
c6839 69 228 1.99e-16
c6840 1798 194 2.8e-16
c6841 1465 1464 6.77e-16
c6842 2774 0 1.96e-16
c6843 0 639 2.957e-15
c6844 2320 193 5.06e-16
c6845 2299 2427 2.4e-16
c6846 2296 2407 1.58e-16
c6847 1013 185 2.14e-16
c6848 0 1577 2.623e-15
c6849 1729 215 7.91e-16
c6850 1903 237 7.23e-16
c6851 1901 239 7.76e-16
c6852 1934 188 7.91e-16
c6853 1932 190 8.32e-16
c6854 2237 215 7.76e-16
c6855 2312 2382 1.96e-16
c6856 2305 2379 1.96e-16
c6857 2298 2574 8.38e-16
c6858 2464 209 1.207e-15
c6859 142 189 1.99e-16
c6860 136 190 3.31e-16
c6861 1540 1541 6.77e-16
c6862 225 452 8.32e-16
c6863 1 473 1.6e-16
c6864 0 1904 2.957e-15
c6865 1332 1333 6.77e-16
c6866 1 1414 1.6e-16
c6867 8 178 2.3e-16
c6868 228 168 3.34e-16
c6869 299 211 2.8e-16
c6870 15 22 1.34e-16
c6871 2787 15 1.326e-15
c6872 2652 2643 5.88e-16
c6873 2675 2318 1.96e-16
c6874 235 90 3.34e-16
c6875 730 235 7.23e-16
c6876 1 785 1.6e-16
c6877 1143 186 7.23e-16
c6878 31 206 3.31e-16
c6879 1362 220 7.23e-16
c6880 73 214 3.31e-16
c6881 1243 234 7.91e-16
c6882 2351 2342 1.96e-16
c6883 795 203 2.8e-16
c6884 226 100 3.34e-16
c6885 221 79 1.99e-16
c6886 3 232 3.08e-16
c6887 42 187 1.99e-16
c6888 37 195 3.34e-16
c6889 27 191 1.94e-16
c6890 31 201 1.9e-16
c6891 945 206 2.54e-16
c6892 947 204 2.8e-16
c6893 0 1541 2.926e-15
c6894 1557 201 2.14e-16
c6895 1 1097 1.6e-16
c6896 2068 200 2.13e-16
c6897 2635 2460 1.96e-16
c6898 2351 2508 3.53e-16
c6899 2651 2462 1.96e-16
c6900 0 419 2.623e-15
c6901 1 2038 1.6e-16
c6902 581 580 6.77e-16
c6903 1 420 1.6e-16
c6904 1401 184 7.91e-16
c6905 212 157 3.34e-16
c6906 239 121 1.94e-16
c6907 100 204 1.99e-16
c6908 94 206 3.31e-16
c6909 84 207 3.24e-16
c6910 79 218 3.34e-16
c6911 2338 2301 6.99e-16
c6912 0 731 2.623e-15
c6913 2709 2343 3.54e-16
c6914 2687 2318 4.14e-16
c6915 229 355 7.91e-16
c6916 864 230 7.77e-16
c6917 0 1241 2.623e-15
c6918 1 732 1.6e-16
c6919 0 2177 2.623e-15
c6920 100 199 1.94e-16
c6921 94 201 1.9e-16
c6922 84 202 1.99e-16
c6923 2467 2394 4.32e-16
c6924 2490 2444 4.07e-16
c6925 1636 240 2.13e-16
c6926 0 564 2.585e-15
c6927 568 217 7.77e-16
c6928 0 1239 2.957e-15
c6929 2649 2587 1.96e-16
c6930 0 1682 2.957e-15
c6931 122 34 7.01e-16
c6932 101 37 1.58e-16
c6933 1238 1239 6.77e-16
c6934 213 132 1.99e-16
c6935 1683 1682 6.77e-16
c6936 2318 2492 5.71e-16
c6937 1 58 7.6e-16
c6938 2572 241 5.06e-16
c6939 817 816 6.77e-16
c6940 1002 243 7.23e-16
c6941 0 1994 2.957e-15
c6942 1480 224 2.13e-16
c6943 0 361 2.623e-15
c6944 2675 2296 1.58e-16
c6945 2755 2757 3.59e-16
c6946 235 343 2.5e-16
c6947 1 875 1.6e-16
c6948 1469 214 2.14e-16
c6949 0 1812 2.585e-15
c6950 2302 0 6.737e-15
c6951 2167 187 2.5e-16
c6952 2843 0 5.1197e-14
c6953 0 707 2.623e-15
c6954 20 226 1.99e-16
c6955 2266 235 7.23e-16
c6956 2732 2746 8.3e-16
c6957 2755 2735 3.31e-16
c6958 1 2147 1.6e-16
c6959 1995 1994 6.77e-16
c6960 1 708 1.6e-16
c6961 0 2124 2.585e-15
c6962 164 71 4.85e-16
c6963 1129 1128 6.77e-16
c6964 1619 221 7.91e-16
c6965 2658 0 1.65e-16
c6966 2358 2746 1.401e-15
c6967 2112 215 2.13e-16
c6968 539 203 2.8e-16
c6969 543 197 7.23e-16
c6970 541 199 7.76e-16
c6971 0 1019 2.623e-15
c6972 42 229 3.34e-16
c6973 1 1020 1.6e-16
c6974 0 1943 2.957e-15
c6975 2070 2071 6.77e-16
c6976 2300 2293 1.154e-15
c6977 14 211 3.34e-16
c6978 20 204 3.34e-16
c6979 0 342 2.623e-15
c6980 213 147 3.34e-16
c6981 452 453 6.77e-16
c6982 682 211 7.23e-16
c6983 20 199 3.24e-16
c6984 2267 0 2.623e-15
c6985 2625 2552 2.6e-16
c6986 1 1777 1.6e-16
c6987 0 654 2.623e-15
c6988 1 2268 1.6e-16
c6989 2641 2590 1.96e-16
c6990 2305 2384 1.96e-16
c6991 2312 2333 1.96e-16
c6992 1178 203 7.23e-16
c6993 1113 232 7.91e-16
c6994 2322 189 5.64e-16
c6995 2296 2492 2.37e-16
c6996 1 2089 1.6e-16
c6997 0 966 2.623e-15
c6999 37 212 1.99e-16
c7000 764 765 6.77e-16
c7001 1927 194 7.23e-16
c7002 1785 185 2.54e-16
c7003 1784 184 2.13e-16
c7004 311 218 7.23e-16
c7005 2505 2475 6.47e-16
c7006 808 209 7.77e-16
c7007 1 2432 1.424e-15
c7008 242 90 3.34e-16
c7009 1 307 1.6e-16
c7010 0 1723 2.623e-15
c7011 1872 222 7.77e-16
c7012 2231 0 2.957e-15
c7013 2234 218 2.5e-16
c7014 2460 2456 6.13e-16
c7015 249 248 6.77e-16
c7016 1 1724 1.6e-16
c7017 2649 0 4.2787e-14
c7018 2641 2422 1.96e-16
c7019 1942 1943 6.77e-16
c7020 1 619 1.6e-16
c7021 1093 224 7.76e-16
c7022 0 2050 2.957e-15
c7023 2520 2512 1.6e-16
c7024 2358 2505 1.96e-16
c7025 2294 2510 2.67e-16
c7026 2647 2465 1.96e-16
c7027 58 240 3.24e-16
c7028 0 432 2.957e-15
c7029 938 210 2.5e-16
c7030 942 205 2.8e-16
c7031 941 206 2.14e-16
c7032 940 207 2.13e-16
c7033 943 204 2.5e-16
c7034 0 1375 2.957e-15
c7035 73 216 1.94e-16
c7036 1 931 1.6e-16
c7037 0 1868 2.585e-15
c7038 1911 187 2.5e-16
c7039 2010 235 7.23e-16
c7040 221 157 3.34e-16
c7041 0 925 2.926e-15
c7042 285 199 7.76e-16
c7043 287 197 7.23e-16
c7044 0 744 2.957e-15
c7045 2788 2800 1.96e-16
c7046 0 1353 2.623e-15
c7047 1 254 1.6e-16
c7048 873 241 2.54e-16
c7049 0 1687 2.957e-15
c7050 1343 213 7.23e-16
c7051 1342 212 7.91e-16
c7052 2208 199 2.13e-16
c7053 2210 197 2.5e-16
c7054 2759 2786 1.58e-16
c7055 2665 2312 3.54e-16
c7056 1541 193 2.14e-16
c7057 0 2173 2.926e-15
c7058 1 1076 1.6e-16
c7059 218 157 1.99e-16
c7060 1 1521 1.6e-16
c7061 208 178 1.94e-16
c7062 222 132 1.9e-16
c7063 223 126 3.24e-16
c7064 1 561 1.6e-16
c7065 907 906 6.77e-16
c7066 0 2011 2.623e-15
c7067 1635 229 7.91e-16
c7068 1 1502 1.6e-16
c7069 194 174 3.34e-16
c7070 1 2012 1.6e-16
c7071 408 200 2.13e-16
c7072 409 201 2.54e-16
c7073 206 121 1.9e-16
c7074 90 192 3.24e-16
c7075 79 185 3.31e-16
c7076 1 1833 1.6e-16
c7077 59 68 6.55e-16
c7078 0 194 2.3948e-14
c7079 3 188 3.48e-16
c7080 217 132 3.31e-16
c7081 121 201 3.31e-16
c7082 111 195 3.34e-16
c7083 115 197 3.34e-16
c7084 1206 218 2.8e-16
c7085 1 2689 2.88e-16
c7086 0 1646 2.623e-15
c7087 1219 1218 6.77e-16
c7088 2409 2401 4.53e-16
c7089 58 189 1.99e-16
c7090 48 180 1.99e-16
c7091 2681 0 1.65e-16
c7092 2121 224 7.91e-16
c7093 1048 201 7.77e-16
c7094 1 2592 2.136e-15
c7095 1466 219 7.23e-16
c7096 983 234 7.23e-16
c7097 982 235 7.91e-16
c7098 1615 221 7.23e-16
c7099 1614 220 7.91e-16
c7100 0 1958 2.623e-15
c7101 2492 213 5.64e-16
c7102 231 477 7.76e-16
c7103 542 543 6.77e-16
c7104 222 147 3.31e-16
c7106 0 1329 2.623e-15
c7107 1335 219 2.5e-16
c7108 1655 187 2.5e-16
c7109 2230 2231 6.77e-16
c7110 2296 2293 2.39e-16
c7111 2760 0 1.5101e-14
c7112 2500 214 3.99e-16
c7113 143 79 3.26e-16
c7114 0 669 2.926e-15
c7115 2641 2364 2.17e-15
c7116 2343 2312 2.544e-15
c7117 2637 2305 1.372e-15
c7118 1 13 1.884e-15
c7119 241 617 2.54e-16
c7120 1 1166 1.6e-16
c7121 31 233 1.9e-16
c7122 1 1611 1.6e-16
c7123 164 52 3.31e-16
c7124 2651 2635 5.88e-16
c7125 2665 2685 1.56e-16
c7126 523 195 2.8e-16
c7127 527 189 7.23e-16
c7128 525 191 7.76e-16
c7129 147 217 1.9e-16
c7130 0 981 2.926e-15
c7131 0 1424 2.957e-15
c7132 854 855 6.77e-16
c7133 37 221 1.99e-16
c7134 2051 2050 6.77e-16
c7135 820 217 8.32e-16
c7136 821 216 7.76e-16
c7137 2719 2761 1.03e-16
c7139 433 432 6.77e-16
c7140 0 1310 2.623e-15
c7141 747 242 7.91e-16
c7142 0 1736 2.957e-15
c7143 1781 185 2.14e-16
c7144 1256 241 7.77e-16
c7145 2246 0 2.623e-15
c7146 0 795 2.623e-15
c7147 1374 1375 6.77e-16
c7148 232 100 3.24e-16
c7149 233 94 1.9e-16
c7150 234 84 1.99e-16
c7151 231 79 1.94e-16
c7152 735 228 2.5e-16
c7153 1152 183 2.13e-16
c7154 1154 181 2.5e-16
c7155 42 210 1.99e-16
c7156 37 218 3.34e-16
c7157 0 32 1.82e-16
c7158 1246 229 2.8e-16
c7159 0 2067 2.623e-15
c7160 1 1558 1.6e-16
c7161 0 449 2.623e-15
c7162 1 2068 1.6e-16
c7163 0 1107 2.623e-15
c7164 950 218 2.8e-16
c7165 924 925 6.77e-16
c7166 0 1390 2.623e-15
c7167 745 744 6.77e-16
c7168 8 55 1.96e-16
c7169 2018 229 2.5e-16
c7170 2019 228 2.8e-16
c7171 0 430 2.623e-15
c7172 1865 224 7.91e-16
c7173 2589 233 1.207e-15
c7174 2581 228 1.54e-16
c7175 1090 213 2.5e-16
c7176 1091 212 2.8e-16
c7177 1686 1687 6.77e-16
c7178 1350 226 2.8e-16
c7179 0 1702 2.623e-15
c7180 1713 206 2.54e-16
c7181 1715 204 2.8e-16
c7182 1 1275 1.6e-16
c7183 1861 225 2.14e-16
c7184 2492 2480 3.92e-16
c7185 214 174 1.9e-16
c7186 279 203 2.5e-16
c7187 0 742 2.623e-15
c7188 2773 2774 9.37e-16
c7189 2709 2294 3.54e-16
c7190 0 1252 2.585e-15
c7191 215 90 1.94e-16
c7192 1923 1922 6.77e-16
c7193 0 2188 2.585e-15
c7194 0 214 2.4398e-14
c7195 212 111 1.99e-16
c7196 2639 2592 1.96e-16
c7197 2305 2630 3.53e-16
c7198 2649 2543 1.96e-16
c7199 1 2382 7.39e-16
c7200 59 42 2.17e-16
c7201 0 1514 2.957e-15
c7202 2172 2173 6.77e-16
c7203 73 183 3.24e-16
c7204 0 2024 2.957e-15
c7205 2351 2632 4.52e-16
c7206 2635 2585 1.96e-16
c7207 1999 220 2.5e-16
c7208 2590 2515 1.58e-16
c7209 259 181 7.91e-16
c7210 258 180 7.23e-16
c7211 257 183 7.91e-16
c7212 256 182 7.77e-16
c7213 1 2591 7.03e-16
c7214 2389 2641 1.58e-16
c7215 1 2347 1.999e-15
c7216 1756 1757 6.77e-16
c7217 1 395 1.6e-16
c7218 853 232 7.76e-16
c7219 1 905 1.6e-16
c7220 0 1826 2.957e-15
c7221 1485 223 7.76e-16
c7222 2351 2519 1.96e-16
c7223 2192 191 2.13e-16
c7224 2194 189 2.5e-16
c7225 20 232 1.94e-16
c7226 2762 2758 1.96e-16
c7227 553 208 7.91e-16
c7228 0 1661 2.926e-15
c7229 1 1217 1.6e-16
c7230 1525 185 2.14e-16
c7231 1625 233 2.54e-16
c7232 2271 228 2.5e-16
c7233 185 157 1.9e-16
c7234 0 539 2.623e-15
c7235 1 2158 1.6e-16
c7236 704 214 7.77e-16
c7237 1 540 1.6e-16
c7238 0 1973 2.926e-15
c7239 164 63 3.31e-16
c7240 2574 2598 3.92e-16
c7241 2630 2610 1.34e-16
c7242 0 851 2.623e-15
c7243 2697 2841 1.014e-15
c7244 1 852 1.6e-16
c7245 1193 209 2.54e-16
c7246 1192 208 2.13e-16
c7247 184 132 3.24e-16
c7248 182 126 3.31e-16
c7249 1755 234 7.91e-16
c7250 38 0 1.6115e-14
c7251 2852 2296 1.233e-15
c7252 0 684 2.585e-15
c7253 0 1178 2.957e-15
c7254 834 213 2.5e-16
c7255 835 212 2.8e-16
c7256 1190 210 2.8e-16
c7257 1457 206 2.54e-16
c7258 1459 204 2.8e-16
c7259 1605 225 2.14e-16
c7260 38 44 1.34e-16
c7261 2305 8 1.78e-16
c7262 2364 2590 2.83e-16
c7263 2647 2351 1.529e-15
c7264 0 503 2.957e-15
c7265 164 165 1.34e-16
c7266 0 996 2.585e-15
c7267 286 287 6.77e-16
c7268 241 613 2.14e-16
c7269 1116 231 2.13e-16
c7270 1323 210 7.91e-16
c7271 1326 204 7.91e-16
c7272 1324 206 8.32e-16
c7273 1953 198 2.54e-16
c7274 1955 196 2.8e-16
c7275 1 1921 1.6e-16
c7276 2299 2394 1.496e-15
c7277 164 105 3.31e-16
c7278 0 1753 2.623e-15
c7279 1376 230 7.77e-16
c7280 1881 232 7.91e-16
c7281 2211 2210 6.77e-16
c7282 1735 226 7.23e-16
c7283 2096 206 7.77e-16
c7284 2097 207 7.91e-16
c7285 2098 204 7.23e-16
c7286 2099 205 7.91e-16
c7287 2761 0 1.4192e-14
c7288 0 808 2.957e-15
c7289 2320 182 5.06e-16
c7290 241 84 1.9e-16
c7291 743 242 7.23e-16
c7292 742 243 7.91e-16
c7293 1162 194 2.5e-16
c7294 1166 189 2.8e-16
c7295 1165 190 2.14e-16
c7296 1164 191 2.13e-16
c7297 1167 188 2.5e-16
c7298 0 1734 2.623e-15
c7299 598 599 6.77e-16
c7300 0 1570 2.957e-15
c7301 2639 2382 1.96e-16
c7302 2305 2425 1.96e-16
c7303 2364 2422 1.96e-16
c7304 147 184 1.94e-16
c7305 0 1120 2.957e-15
c7306 1 630 1.6e-16
c7307 0 1405 2.926e-15
c7308 73 238 3.31e-16
c7309 0 2063 2.957e-15
c7310 1514 243 7.23e-16
c7311 0 445 2.926e-15
c7312 2027 242 7.91e-16
c7313 231 157 3.24e-16
c7314 1 1902 1.6e-16
c7315 235 178 1.99e-16
c7316 593 592 6.77e-16
c7317 2697 2641 1.96e-16
c7318 2654 2637 1.96e-16
c7319 1 284 1.6e-16
c7320 1 942 1.6e-16
c7321 1 1387 1.6e-16
c7322 1534 1535 6.77e-16
c7323 0 757 2.926e-15
c7324 233 121 3.31e-16
c7325 1 2209 1.6e-16
c7326 1300 201 8.32e-16
c7327 1301 200 7.76e-16
c7328 668 669 6.77e-16
c7329 37 185 3.31e-16
c7330 27 180 1.99e-16
c7331 31 190 3.31e-16
c7332 1 2333 9.69e-16
c7333 1 1699 1.6e-16
c7334 221 111 1.99e-16
c7335 422 211 7.91e-16
c7336 0 1086 2.623e-15
c7337 164 142 3.31e-16
c7338 0 1531 2.623e-15
c7339 1 1532 1.6e-16
c7340 216 174 3.24e-16
c7341 0 179 4.83e-16
c7342 2635 2503 1.96e-16
c7343 2351 2550 4.24e-16
c7344 2358 2627 2.29e-16
c7345 143 145 2.17e-16
c7346 79 207 1.94e-16
c7347 268 190 8.32e-16
c7348 270 188 7.91e-16
c7349 1846 1847 6.77e-16
c7350 1 2604 1.424e-15
c7351 2655 2641 7.6e-16
c7352 0 1843 2.623e-15
c7353 980 981 6.77e-16
c7354 2348 0 6.737e-15
c7355 2364 2527 1.96e-16
c7356 239 132 1.94e-16
c7357 237 126 3.34e-16
c7358 218 111 3.34e-16
c7359 100 188 1.99e-16
c7360 94 190 3.31e-16
c7361 84 191 3.24e-16
c7362 79 202 3.34e-16
c7363 1 1844 1.6e-16
c7364 0 216 2.5833e-14
c7365 251 187 2.8e-16
c7366 2492 2446 1.16e-16
c7367 1425 1424 6.77e-16
c7368 2280 241 7.77e-16
c7369 2389 2590 1.82e-15
c7370 1 219 3.708e-15
c7371 0 1676 2.585e-15
c7372 2186 195 7.23e-16
c7373 2510 0 2.1121e-14
c7374 2425 201 7.02e-16
c7375 2379 190 1.7e-16
c7376 2651 2320 1.58e-16
c7377 2641 2574 3.54e-16
c7378 143 37 3.26e-16
c7379 1 1051 1.6e-16
c7380 48 197 1.99e-16
c7381 0 1988 2.585e-15
c7382 2124 223 2.13e-16
c7383 0 354 2.957e-15
c7384 0 864 2.957e-15
c7385 2823 2864 1.29e-16
c7386 1737 1736 6.77e-16
c7387 0 1807 2.957e-15
c7388 2339 187 1.083e-15
c7389 2733 2647 1.58e-16
c7390 2732 2643 1.58e-16
c7391 2389 2422 1.58e-16
c7392 843 226 7.91e-16
c7393 1 2665 4.672e-15
c7394 0 2119 2.957e-15
c7395 1751 234 7.23e-16
c7396 1750 235 7.91e-16
c7397 2570 2557 4.77e-16
c7398 2312 2294 9.42e-16
c7399 2305 2645 1.716e-15
c7400 2298 2505 2.11e-16
c7401 494 236 7.91e-16
c7402 492 238 8.32e-16
c7403 0 518 2.623e-15
c7404 147 239 3.24e-16
c7405 1033 192 7.91e-16
c7406 1 2638 2.88e-16
c7407 8 34 1.96e-16
c7408 1450 210 2.5e-16
c7409 1454 205 2.8e-16
c7410 1453 206 2.14e-16
c7411 1452 207 2.13e-16
c7412 37 231 1.94e-16
c7413 1 1443 1.6e-16
c7414 0 830 2.623e-15
c7415 0 1437 2.926e-15
c7416 1946 202 2.5e-16
c7417 1385 241 2.54e-16
c7418 14 195 3.34e-16
c7419 20 188 3.34e-16
c7420 0 330 2.957e-15
c7421 2548 2516 6.99e-16
c7422 2545 2526 6.67e-16
c7423 0 825 2.623e-15
c7424 2665 2845 5.75e-16
c7425 1134 237 2.8e-16
c7426 1133 238 2.14e-16
c7427 1132 239 2.13e-16
c7428 1135 236 2.5e-16
c7429 0 1142 2.623e-15
c7430 0 1749 2.926e-15
c7431 0 1587 2.623e-15
c7432 2091 211 2.8e-16
c7433 2095 205 7.23e-16
c7434 2093 207 7.76e-16
c7435 1 1588 1.6e-16
c7436 2471 2632 2.69e-15
c7437 507 186 7.91e-16
c7438 510 180 7.91e-16
c7439 508 182 8.32e-16
c7440 0 1137 2.623e-15
c7441 0 2078 2.623e-15
c7442 0 460 2.585e-15
c7443 2456 204 1.54e-16
c7444 0 954 2.957e-15
c7445 242 178 1.99e-16
c7446 215 448 2.13e-16
c7447 164 129 4.85e-16
c7448 73 227 1.99e-16
c7449 1721 217 2.54e-16
c7450 1720 216 2.13e-16
c7451 1868 223 2.13e-16
c7452 2229 217 2.14e-16
c7453 0 279 2.957e-15
c7454 101 14 1.58e-16
c7455 0 772 2.585e-15
c7456 2654 8 1.17e-16
c7457 2793 80 2.75e-16
c7458 2764 2802 1.96e-16
c7459 2652 2351 5.88e-16
c7460 634 187 7.23e-16
c7461 1 1286 1.6e-16
c7462 2637 2420 1.96e-16
c7463 2649 2460 1.96e-16
c7464 2343 2467 1.96e-16
c7465 2318 2508 2.66e-16
c7466 2299 2592 4.93e-16
c7467 337 336 6.77e-16
c7468 226 587 7.91e-16
c7469 933 209 2.14e-16
c7470 73 205 3.34e-16
c7471 1495 234 7.23e-16
c7472 1494 235 7.91e-16
c7473 2358 2548 1.96e-16
c7474 224 163 3.24e-16
c7475 575 212 2.5e-16
c7476 0 1346 2.957e-15
c7477 240 357 7.76e-16
c7478 73 200 1.94e-16
c7479 0 1856 2.957e-15
c7480 2407 2443 3.92e-16
c7481 263 194 7.23e-16
c7482 1515 1514 6.77e-16
c7483 2788 2758 8.01e-16
c7484 2665 2639 4.24e-16
c7485 2655 2590 6.31e-16
c7486 2389 2364 1.772e-15
c7487 2471 2647 1.421e-15
c7488 1 2380 7.03e-16
c7489 2025 2024 6.77e-16
c7490 649 648 6.77e-16
c7491 1690 202 2.5e-16
c7492 1694 197 2.8e-16
c7493 1693 198 2.14e-16
c7494 1692 199 2.13e-16
c7495 1695 196 2.5e-16
c7496 1226 226 2.5e-16
c7497 1227 227 2.8e-16
c7498 2161 238 2.54e-16
c7499 2198 203 7.91e-16
c7500 2469 2479 1.6e-16
c7501 211 153 3.34e-16
c7502 207 157 3.24e-16
c7504 226 126 1.99e-16
c7505 2135 235 2.5e-16
c7506 2305 2407 1.58e-16
c7507 1590 1591 6.77e-16
c7508 878 237 2.8e-16
c7509 879 236 2.5e-16
c7510 0 1493 2.926e-15
c7511 1628 230 8.32e-16
c7512 202 157 1.99e-16
c7513 1835 211 2.8e-16
c7514 1839 205 7.23e-16
c7515 1837 207 7.76e-16
c7516 196 163 1.99e-16
c7517 192 178 1.94e-16
c7518 183 174 1.94e-16
c7519 2651 2409 3.54e-16
c7520 2590 2574 1.58e-16
c7521 0 371 2.623e-15
c7522 2574 231 7.64e-16
c7523 90 181 1.99e-16
c7524 0 881 2.623e-15
c7525 1827 1826 6.77e-16
c7526 1 372 1.6e-16
c7527 961 960 6.77e-16
c7528 2366 189 4.83e-16
c7529 2296 2342 2.39e-16
c7530 206 132 1.9e-16
c7531 121 190 1.9e-16
c7532 204 126 3.34e-16
c7533 111 185 3.31e-16
c7534 1768 241 7.77e-16
c7535 2177 182 2.54e-16
c7536 2179 180 2.8e-16
c7537 2709 0 1.0195e-14
c7538 0 183 2.6039e-14
c7539 2655 2422 1.96e-16
c7540 0 1193 2.623e-15
c7541 1 2854 2.949e-15
c7542 1674 195 7.23e-16
c7543 1758 229 2.8e-16
c7544 0 2134 2.623e-15
c7545 201 132 3.31e-16
c7546 199 126 3.24e-16
c7547 14 212 1.99e-16
c7548 2436 2429 1.38e-16
c7549 2709 2710 1.6e-16
c7550 2296 2508 2.28e-16
c7551 0 1191 2.957e-15
c7552 1660 1661 6.77e-16
c7553 895 180 2.5e-16
c7554 1462 218 2.8e-16
c7555 1961 209 2.54e-16
c7556 1960 208 2.13e-16
c7557 1897 1896 6.77e-16
c7558 224 136 1.94e-16
c7559 1 515 1.6e-16
c7560 0 1322 2.957e-15
c7561 978 220 7.23e-16
c7562 0 1931 2.623e-15
c7563 2630 2557 4.09e-16
c7564 1 1787 1.6e-16
c7565 2791 0 2.08e-16
c7566 2842 2841 1.96e-16
c7567 2407 206 5.06e-16
c7568 2343 2639 2.86e-16
c7569 1 2759 9.23e-16
c7570 0 1764 2.585e-15
c7571 1972 1973 6.77e-16
c7572 0 1600 2.957e-15
c7573 2103 218 7.23e-16
c7574 2786 0 1.0438e-14
c7575 143 111 3.26e-16
c7576 164 58 3.31e-16
c7577 0 640 2.957e-15
c7578 2665 2678 2.22e-16
c7579 2407 201 5.06e-16
c7580 2299 2382 2.42e-16
c7581 2471 2550 2.3e-16
c7582 147 206 3.31e-16
c7583 1 2099 1.6e-16
c7584 1017 184 7.91e-16
c7585 0 1583 2.957e-15
c7586 1438 197 2.8e-16
c7587 1439 196 2.5e-16
c7588 1905 238 2.54e-16
c7589 1907 236 2.8e-16
c7590 1 1422 1.6e-16
c7591 147 201 1.9e-16
c7592 136 196 3.34e-16
c7593 224 457 7.91e-16
c7594 1105 222 2.54e-16
c7595 1365 232 7.76e-16
c7596 1 1417 1.6e-16
c7597 2627 2572 5.17e-16
c7598 2492 2522 1.96e-16
c7599 0 294 2.623e-15
c7600 2574 2515 8.34e-16
c7601 2814 15 6.01e-16
c7602 2773 38 5.5e-16
c7603 11 25 1.0435e-14
c7604 2654 2645 1.96e-16
c7605 2675 2305 1.96e-16
c7606 2697 2364 1.96e-16
c7607 214 444 8.32e-16
c7608 234 79 3.34e-16
c7609 0 1298 2.957e-15
c7610 37 207 1.94e-16
c7611 69 213 1.99e-16
c7612 2219 0 2.623e-15
c7613 2574 2527 4.17e-16
c7614 1179 1178 6.77e-16
c7615 0 606 2.623e-15
c7616 231 111 1.94e-16
c7617 228 115 3.34e-16
c7618 1 2220 1.6e-16
c7619 42 194 1.99e-16
c7620 37 202 3.34e-16
c7621 27 197 1.99e-16
c7622 1561 200 7.91e-16
c7623 1 230 4.537e-15
c7624 238 174 1.9e-16
c7625 1 2041 1.6e-16
c7626 90 236 1.99e-16
c7627 1 2631 7.03e-16
c7628 2584 235 3.61e-16
c7629 502 503 6.77e-16
c7630 0 1363 2.623e-15
c7631 1085 214 2.14e-16
c7632 1705 209 2.54e-16
c7633 1704 208 2.13e-16
c7634 1 1364 1.6e-16
c7635 2590 2567 4.08e-16
c7636 213 168 3.34e-16
c7637 0 238 2.4398e-14
c7638 215 178 3.24e-16
c7639 772 193 8.32e-16
c7640 773 192 7.76e-16
c7641 2764 2767 1.96e-16
c7642 2687 2305 3.54e-16
c7643 2655 2364 1.334e-15
c7644 0 1247 2.957e-15
c7645 0 2183 2.957e-15
c7646 2720 0 1.73e-16
c7647 2312 2587 1.96e-16
c7648 1 571 1.6e-16
c7649 1223 227 2.5e-16
c7650 0 1508 2.585e-15
c7651 52 219 1.99e-16
c7652 2643 2572 1.58e-16
c7653 2305 2492 3.54e-16
c7654 2364 2574 5.75e-16
c7655 0 384 2.957e-15
c7656 1 2022 1.6e-16
c7657 0 1820 2.585e-15
c7658 1831 211 2.5e-16
c7659 1986 212 7.23e-16
c7660 0 367 2.957e-15
c7661 0 877 2.926e-15
c7662 2765 2761 5.52e-16
c7663 2732 2766 1.21e-16
c7664 234 347 7.91e-16
c7665 809 808 6.77e-16
c7666 849 222 2.54e-16
c7667 0 2149 2.926e-15
c7668 2170 186 2.5e-16
c7669 2174 181 2.8e-16
c7670 2173 182 2.14e-16
c7671 2172 183 2.13e-16
c7672 2175 180 2.5e-16
c7673 14 221 1.99e-16
c7674 374 375 6.77e-16
c7675 0 1027 2.623e-15
c7676 1571 1570 6.77e-16
c7677 700 215 2.13e-16
c7678 884 885 6.77e-16
c7679 1 1028 1.6e-16
c7680 1972 216 2.13e-16
c7681 1 1473 1.6e-16
c7682 545 198 2.54e-16
c7683 547 196 2.8e-16
c7684 886 187 7.91e-16
c7685 2697 2389 1.32e-15
c7686 0 1944 2.957e-15
c7687 1121 1120 6.77e-16
c7688 1 1454 1.6e-16
c7689 2275 0 2.623e-15
c7690 14 218 3.34e-16
c7691 2351 2429 1.96e-16
c7692 0 345 2.623e-15
c7693 2627 2556 1.58e-16
c7694 2793 0 8.07e-15
c7695 688 206 7.77e-16
c7696 689 207 7.91e-16
c7697 690 204 7.23e-16
c7698 691 205 7.91e-16
c7699 1404 1405 6.77e-16
c7700 1 2276 1.6e-16
c7701 2687 2695 1.34e-16
c7702 2299 2333 7.86e-16
c7703 2062 2063 6.77e-16
c7704 829 214 2.14e-16
c7705 1196 1197 6.77e-16
c7706 0 657 2.623e-15
c7707 2649 2651 5.88e-16
c7708 2687 2686 2.66e-16
c7709 444 445 6.77e-16
c7710 1641 1640 6.77e-16
c7711 1184 198 7.77e-16
c7712 1185 199 7.91e-16
c7713 1186 196 7.23e-16
c7714 1187 197 7.91e-16
c7715 0 1598 2.623e-15
c7716 2409 199 7.64e-16
c7717 2298 2627 3.9e-16
c7718 2299 2604 6.36e-16
c7719 0 969 2.623e-15
c7720 2655 2389 7.84e-16
c7721 42 214 3.31e-16
c7722 1372 231 2.13e-16
c7723 2545 2490 5.17e-16
c7724 2505 2473 4.15e-16
c7725 2318 2392 2.39e-16
c7726 0 309 2.926e-15
c7727 122 124 2.17e-16
c7728 241 79 3.31e-16
c7729 756 757 6.77e-16
c7730 1 806 1.6e-16
c7731 1953 1952 6.77e-16
c7732 69 222 1.9e-16
c7733 1575 211 2.5e-16
c7734 2232 0 2.957e-15
c7735 2465 2458 5.82e-16
c7736 2312 0 8.2729e-14
c7737 0 621 2.926e-15
c7738 2343 2427 1.96e-16
c7739 2637 2377 1.96e-16
c7740 2389 2574 1.58e-16
c7741 1 2294 1.358e-15
c7742 1 1118 1.6e-16
c7743 1422 189 2.8e-16
c7744 1421 190 2.14e-16
c7745 1423 188 2.5e-16
c7746 2358 2465 7.57e-16
c7747 2294 2467 2.75e-16
c7748 2645 2420 1.96e-16
c7749 2020 241 8.32e-16
c7750 443 219 2.8e-16
c7751 234 157 1.99e-16
c7752 590 221 2.8e-16
c7753 0 933 2.926e-15
c7754 0 1376 2.957e-15
c7755 69 217 3.31e-16
c7756 63 219 1.99e-16
c7757 1 73 7.6e-16
c7758 2212 208 2.13e-16
c7759 222 168 3.31e-16
c7760 1 1875 1.6e-16
c7761 227 174 3.34e-16
c7762 291 196 2.8e-16
c7763 289 198 2.54e-16
c7764 164 13 1.237e-15
c7765 225 90 3.31e-16
c7766 0 1262 2.623e-15
c7767 1 257 1.6e-16
c7768 0 1688 2.957e-15
c7769 1857 214 2.54e-16
c7770 2198 0 2.623e-15
c7771 2594 2597 1.154e-15
c7772 2305 2293 1.96e-16
c7773 2298 2643 1.58e-16
c7774 2150 242 2.8e-16
c7775 0 227 2.5224e-14
c7776 233 132 3.31e-16
c7777 232 126 1.94e-16
c7778 1082 219 7.23e-16
c7779 1231 221 7.23e-16
c7780 1230 220 7.91e-16
c7781 1545 192 7.91e-16
c7782 0 156 1.14e-16
c7783 217 168 1.9e-16
c7784 205 174 1.99e-16
c7785 2649 2585 1.96e-16
c7786 2318 2632 4.52e-16
c7787 0 401 2.623e-15
c7788 2654 2675 1.58e-16
c7789 483 482 6.77e-16
c7790 200 174 3.24e-16
c7791 1994 226 2.5e-16
c7792 1995 227 2.8e-16
c7793 2296 2392 1.96e-16
c7794 0 382 2.623e-15
c7795 0 205 2.3925e-14
c7796 0 892 2.585e-15
c7797 207 111 1.94e-16
c7798 105 219 1.99e-16
c7799 90 198 1.9e-16
c7800 84 180 3.34e-16
c7801 79 191 1.94e-16
c7802 0 713 2.623e-15
c7803 2276 240 2.13e-16
c7804 1 209 4.406e-15
c7805 0 1671 2.957e-15
c7806 1646 237 2.8e-16
c7807 1645 238 2.14e-16
c7808 1644 239 2.13e-16
c7809 1647 236 2.5e-16
c7810 1 1227 1.6e-16
c7811 2182 194 2.8e-16
c7812 0 200 2.5777e-14
c7813 111 202 3.34e-16
c7814 1421 1420 6.77e-16
c7815 2508 217 7.02e-16
c7816 0 1204 2.585e-15
c7817 1 203 3.708e-15
c7818 2335 2320 1.58e-16
c7819 0 1040 2.957e-15
c7820 0 1649 2.623e-15
c7821 0 1983 2.957e-15
c7822 2685 0 1.65e-16
c7823 1419 1418 6.77e-16
c7824 1305 1304 6.77e-16
c7825 228 482 7.23e-16
c7826 233 147 1.9e-16
c7827 0 1466 2.957e-15
c7828 2697 2655 1.96e-16
c7829 0 1961 2.623e-15
c7830 1 862 1.6e-16
c7831 2241 2240 6.77e-16
c7832 2288 0 2.957e-15
c7833 2382 2322 1.58e-16
c7834 699 218 7.91e-16
c7835 2299 2343 1.426e-15
c7836 0 1335 2.957e-15
c7837 836 225 8.32e-16
c7838 1 2825 6.6e-16
c7839 1658 186 2.5e-16
c7840 1662 181 2.8e-16
c7841 1661 182 2.14e-16
c7842 1660 183 2.13e-16
c7843 1663 180 2.5e-16
c7844 1 1798 1.6e-16
c7845 2805 0 8.943e-15
c7846 2560 2552 1.6e-16
c7847 2320 2354 1.96e-16
c7848 2322 2347 3.92e-16
c7849 2259 221 7.91e-16
c7850 2318 2647 2.027e-15
c7851 2748 2305 1.79e-16
c7852 2639 2294 1.58e-16
c7853 355 354 6.77e-16
c7854 1 80 2.84e-16
c7855 0 1613 2.926e-15
c7856 2222 2223 6.77e-16
c7857 865 864 6.77e-16
c7858 1 1169 1.6e-16
c7859 1445 209 2.14e-16
c7860 37 234 3.34e-16
c7861 1746 220 7.23e-16
c7862 2351 2736 7.58e-16
c7863 2296 2632 1.65e-16
c7864 2298 2548 3.9e-16
c7865 0 491 2.623e-15
c7866 2507 217 1.207e-15
c7867 529 190 2.54e-16
c7868 531 188 2.8e-16
c7869 142 219 3.34e-16
c7870 1 2110 1.6e-16
c7871 2420 2407 1.58e-16
c7872 230 609 2.54e-16
c7873 1 492 1.6e-16
c7874 1806 1807 6.77e-16
c7875 966 226 2.8e-16
c7876 1941 201 2.14e-16
c7877 73 240 1.94e-16
c7878 14 185 3.31e-16
c7879 0 324 2.585e-15
c7880 0 818 2.957e-15
c7881 223 460 2.13e-16
c7882 2389 2816 3.92e-16
c7883 2828 2824 2.78e-16
c7884 2835 2838 1.41e-16
c7885 0 1313 2.623e-15
c7886 2043 2042 6.77e-16
c7887 2249 0 2.623e-15
c7888 2543 2531 2.32e-16
c7889 2634 2636 1.6e-16
c7890 2655 2574 1.618e-15
c7891 425 424 6.77e-16
c7892 71 73 3.92e-16
c7893 500 185 8.32e-16
c7894 501 184 7.76e-16
c7895 0 1130 2.957e-15
c7896 739 229 7.91e-16
c7897 42 216 1.94e-16
c7898 1248 230 7.77e-16
c7899 1390 237 2.8e-16
c7900 1389 238 2.14e-16
c7901 1388 239 2.13e-16
c7902 1391 236 2.5e-16
c7903 2118 2119 6.77e-16
c7904 1366 1367 6.77e-16
c7905 1 1561 1.6e-16
c7906 0 455 2.957e-15
c7907 2449 205 4.83e-16
c7908 241 157 1.9e-16
c7909 0 948 2.585e-15
c7910 952 217 7.77e-16
c7911 0 1393 2.623e-15
c7912 48 228 1.99e-16
c7913 52 230 3.31e-16
c7914 97 100 3.92e-16
c7915 0 767 2.957e-15
c7916 2764 2798 1.96e-16
c7917 1 2423 7.03e-16
c7918 737 736 6.77e-16
c7919 0 1277 2.926e-15
c7922 0 1705 2.623e-15
c7923 1352 225 7.77e-16
c7924 0 250 2.957e-15
c7925 282 202 2.5e-16
c7926 143 14 3.26e-16
c7927 2296 2647 1.58e-16
c7928 2641 2505 1.96e-16
c7929 1406 181 2.8e-16
c7930 1405 182 2.14e-16
c7931 1404 183 2.13e-16
c7932 1407 180 2.5e-16
c7933 2055 195 2.5e-16
c7934 1436 1437 6.77e-16
c7935 2649 2503 1.96e-16
c7936 2318 2550 2.29e-16
c7937 2312 2543 2.83e-16
c7938 0 1340 2.585e-15
c7939 69 184 3.24e-16
c7940 73 189 3.34e-16
c7941 1 913 1.6e-16
c7942 1490 220 7.23e-16
c7943 2003 221 7.91e-16
c7944 0 397 2.926e-15
c7945 331 330 6.77e-16
c7946 1 1854 1.6e-16
c7947 923 203 2.8e-16
c7948 927 197 7.23e-16
c7949 925 199 7.76e-16
c7950 2634 2637 3.91e-16
c7951 1 2719 6.664e-15
c7952 1685 201 2.14e-16
c7953 14 231 1.94e-16
c7954 2769 2758 1.96e-16
c7955 229 350 2.8e-16
c7956 1748 1749 6.77e-16
c7957 1066 211 7.23e-16
c7958 1914 1915 6.77e-16
c7959 1 548 1.6e-16
c7960 1529 184 7.91e-16
c7961 0 1998 2.623e-15
c7962 195 153 3.34e-16
c7963 191 157 3.24e-16
c7964 187 163 3.34e-16
c7965 184 168 1.94e-16
c7966 181 178 3.34e-16
c7967 1 2161 1.6e-16
c7968 2333 2322 1.58e-16
c7969 0 1038 2.623e-15
c7970 2574 234 5.7e-16
c7971 242 490 2.5e-16
c7972 243 491 2.8e-16
c7973 0 1483 2.623e-15
c7974 992 230 7.77e-16
c7975 80 71 2.44e-16
c7976 122 66 7.01e-16
c7977 1 1484 1.6e-16
c7978 2630 2599 7.8e-16
c7979 1670 194 2.8e-16
c7980 2286 0 2.623e-15
c7981 190 132 1.9e-16
c7982 188 126 3.34e-16
c7984 695 218 7.23e-16
c7985 2757 8 5e-16
c7986 2732 2351 1.086e-15
c7987 2687 2420 3.92e-16
c7988 1 2587 7.39e-16
c7989 1 691 1.6e-16
c7990 955 954 6.77e-16
c7991 0 1628 2.585e-15
c7992 1130 243 7.23e-16
c7993 37 241 3.31e-16
c7994 2409 2354 1.054e-15
c7995 1608 224 2.13e-16
c7996 2735 8 1.61e-16
c7997 2358 2351 9.8e-16
c7998 2296 2550 1.733e-15
c7999 0 504 2.957e-15
c8000 235 471 2.5e-16
c8001 1 1003 1.6e-16
c8002 1597 214 2.14e-16
c8003 1030 1031 6.77e-16
c8004 2574 2555 3.92e-16
c8005 278 279 6.77e-16
c8006 1475 1474 6.77e-16
c8007 2820 2838 1.58e-16
c8008 0 1759 2.957e-15
c8009 63 230 3.31e-16
c8010 2246 226 2.8e-16
c8011 667 203 2.8e-16
c8012 671 197 7.23e-16
c8013 669 199 7.76e-16
c8014 2634 2630 3.92e-16
c8015 2665 2668 1.6e-16
c8016 1 638 1.6e-16
c8017 31 224 1.94e-16
c8018 1727 213 7.23e-16
c8019 1726 212 7.91e-16
c8020 2645 2377 1.96e-16
c8021 2294 2427 1.96e-16
c8022 0 470 2.623e-15
c8023 147 190 3.31e-16
c8024 136 187 1.99e-16
c8025 233 596 8.32e-16
c8026 69 239 1.94e-16
c8027 2278 2279 6.77e-16
c8028 2351 2601 1.96e-16
c8029 348 349 6.77e-16
c8030 8 2599 2.74e-16
c8031 229 163 1.99e-16
c8032 1 1905 1.6e-16
c8033 296 208 2.13e-16
c8034 297 209 2.54e-16
c8035 514 515 6.77e-16
c8036 0 782 2.623e-15
c8037 2793 2773 6.14e-16
c8038 2652 2318 5.88e-16
c8039 0 1292 2.585e-15
c8040 1306 203 7.23e-16
c8041 729 233 2.54e-16
c8042 1361 222 2.54e-16
c8043 1241 232 7.91e-16
c8044 0 267 2.623e-15
c8045 793 201 2.54e-16
c8046 792 200 2.13e-16
c8047 2298 2766 9.69e-16
c8048 2760 2799 1.19e-15
c8049 234 111 3.34e-16
c8050 230 105 3.31e-16
c8051 224 94 1.94e-16
c8052 726 234 2.8e-16
c8053 0 1094 2.623e-15
c8054 1620 1621 6.77e-16
c8055 42 183 3.24e-16
c8056 37 191 1.94e-16
c8057 31 196 3.34e-16
c8058 0 1539 2.623e-15
c8059 1237 233 2.14e-16
c8060 239 168 3.24e-16
c8061 0 594 2.957e-15
c8062 1347 1346 6.77e-16
c8063 1 1540 1.6e-16
c8064 2614 237 4.83e-16
c8065 236 178 3.34e-16
c8066 3 220 3.48e-16
c8067 2651 2510 1.96e-16
c8068 428 206 8.32e-16
c8069 430 204 7.91e-16
c8070 427 210 7.91e-16
c8071 660 661 6.77e-16
c8072 0 1089 2.623e-15
c8073 1857 1856 6.77e-16
c8074 1398 187 7.91e-16
c8075 0 172 1.14e-16
c8076 0 412 2.585e-15
c8077 212 153 1.99e-16
c8078 1 174 7.6e-16
c8079 2335 2308 1.58e-16
c8080 231 353 7.91e-16
c8081 0 117 1.82e-16
c8082 94 196 3.34e-16
c8083 84 197 3.34e-16
c8084 2338 2314 1.58e-16
c8085 2714 0 4.47e-16
c8086 0 724 2.585e-15
c8087 2634 8 9.32e-16
c8088 1 0 3.43206e-13
c8089 2639 2587 2.67e-16
c8090 1 113 2.79e-16
c8091 972 973 6.77e-16
c8092 1 1238 1.6e-16
c8093 58 219 3.34e-16
c8094 52 209 1.9e-16
c8095 1 1683 1.6e-16
c8096 2467 0 1.9783e-14
c8097 2427 203 9.65e-16
c8098 2299 2477 1.496e-15
c8099 0 1053 2.926e-15
c8100 1 2710 2.88e-16
c8101 1001 241 2.54e-16
c8102 52 203 1.99e-16
c8103 1479 227 2.5e-16
c8104 1 1995 1.6e-16
c8105 8 139 1.96e-16
c8106 2625 2608 7.03e-16
c8107 1492 1493 6.77e-16
c8108 2532 221 4.83e-16
c8109 230 142 1.9e-16
c8110 229 136 3.34e-16
c8111 907 195 2.8e-16
c8112 911 189 7.23e-16
c8113 909 191 7.76e-16
c8114 2675 2861 5.34e-16
c8115 2697 2842 2.29e-16
c8116 2733 2732 3.92e-16
c8117 2734 2755 5.05e-16
c8118 233 340 8.32e-16
c8119 0 1808 2.957e-15
c8120 2627 2616 1.25e-16
c8121 2165 185 2.14e-16
c8122 2845 0 7.602e-15
c8123 122 100 1.58e-16
c8124 2265 233 2.54e-16
c8125 1729 1728 6.77e-16
c8126 2755 2754 7.33e-16
c8127 2299 2294 1.544e-15
c8128 0 2120 2.957e-15
c8129 2364 2746 3.92e-16
c8130 2294 2740 8.44e-16
c8131 2298 2465 1.58e-16
c8132 0 521 2.623e-15
c8133 537 201 2.54e-16
c8134 536 200 2.13e-16
c8135 0 1445 2.926e-15
c8136 27 228 1.99e-16
c8137 80 52 1.59e-16
c8138 59 50 2.44e-16
c8139 14 207 1.94e-16
c8140 0 338 2.957e-15
c8141 1 1942 1.6e-16
c8142 0 833 2.623e-15
c8143 680 209 7.77e-16
c8144 0 1774 2.623e-15
c8145 14 202 3.34e-16
c8146 2550 2542 6.67e-16
c8147 2838 2843 1.547e-15
c8148 0 650 2.957e-15
c8149 2318 2338 4.79e-16
c8150 2649 2335 1.96e-16
c8151 212 322 7.23e-16
c8152 0 1145 2.623e-15
c8153 1176 201 7.77e-16
c8154 42 238 3.31e-16
c8155 1594 219 7.23e-16
c8156 1111 234 7.23e-16
c8157 1110 235 7.91e-16
c8158 0 2086 2.623e-15
c8159 1734 226 2.8e-16
c8160 663 203 2.5e-16
c8161 0 962 2.957e-15
c8162 1190 1191 6.77e-16
c8163 1924 192 2.13e-16
c8164 2434 0 6.737e-15
c8165 2364 2609 1.96e-16
c8166 240 174 3.24e-16
c8167 308 216 2.13e-16
c8168 259 258 6.77e-16
c8169 0 797 2.926e-15
c8170 2233 216 7.91e-16
c8171 0 280 2.957e-15
c8172 122 20 1.58e-16
c8173 101 17 2.44e-16
c8174 2548 2473 1.873e-15
c8175 2460 2433 1.58e-16
c8176 2632 2513 1.28e-16
c8177 2639 0 5.005e-14
c8178 0 240 2.5772e-14
c8179 640 182 7.77e-16
c8180 641 183 7.91e-16
c8181 642 180 7.23e-16
c8182 643 181 7.91e-16
c8183 241 111 3.31e-16
c8184 1 2230 1.6e-16
c8185 0 1109 2.926e-15
c8186 0 1716 2.585e-15
c8187 1 243 3.708e-15
c8188 2364 2505 1.96e-16
c8189 2312 2460 1.96e-16
c8190 2305 2508 1.96e-16
c8191 1323 1322 6.77e-16
c8192 1 2051 1.6e-16
c8193 2471 2475 1.96e-16
c8194 937 208 7.91e-16
c8195 69 206 1.9e-16
c8196 63 209 1.9e-16
c8197 1 433 1.6e-16
c8198 0 1864 2.957e-15
c8199 1081 1080 6.77e-16
c8200 1909 185 2.14e-16
c8201 1 1374 1.6e-16
c8202 2009 233 2.54e-16
c8203 221 153 1.99e-16
c8204 0 923 2.623e-15
c8205 225 178 1.9e-16
c8206 213 579 7.91e-16
c8207 2788 2789 3.96e-16
c8208 69 201 3.31e-16
c8209 63 203 1.99e-16
c8210 1 924 1.6e-16
c8211 1290 195 7.23e-16
c8212 1 745 1.6e-16
c8213 1341 215 7.76e-16
c8214 2612 2599 4.77e-16
c8215 2382 2347 6.99e-16
c8216 2379 2359 1.58e-16
c8217 1 1686 1.6e-16
c8218 8 124 1.96e-16
c8219 2760 2771 1.96e-16
c8220 2471 2358 1.188e-15
c8221 2709 2651 1.58e-16
c8222 2634 2645 8.18e-16
c8223 2296 2338 1.58e-16
c8224 224 121 3.24e-16
c8225 404 405 6.77e-16
c8226 1078 218 2.8e-16
c8227 0 2171 2.623e-15
c8228 2203 202 7.91e-16
c8229 2206 196 7.91e-16
c8230 2204 198 8.32e-16
c8231 2039 186 7.23e-16
c8232 218 153 3.34e-16
c8233 206 168 3.31e-16
c8234 210 163 3.34e-16
c8235 0 558 2.623e-15
c8236 2139 234 7.91e-16
c8237 1 2172 1.6e-16
c8238 2637 2625 1.96e-16
c8239 2641 2627 1.96e-16
c8240 0 1068 2.585e-15
c8241 371 237 7.91e-16
c8242 370 236 7.23e-16
c8243 369 239 7.91e-16
c8244 368 238 7.77e-16
c8245 641 640 6.77e-16
c8246 1218 213 2.5e-16
c8247 1219 212 2.8e-16
c8248 1633 231 7.91e-16
c8249 1841 206 2.54e-16
c8250 1843 204 2.8e-16
c8251 201 168 1.9e-16
c8252 198 178 3.31e-16
c8253 189 174 1.99e-16
c8254 2635 2490 1.58e-16
c8255 2351 2572 1.58e-16
c8256 1989 225 2.14e-16
c8257 1582 1583 6.77e-16
c8258 407 203 2.5e-16
c8259 209 105 1.9e-16
c8260 79 180 1.99e-16
c8261 0 887 2.957e-15
c8262 80 63 1.59e-16
c8263 716 717 6.77e-16
c8264 121 196 1.99e-16
c8265 111 191 1.94e-16
c8266 105 203 1.99e-16
c8267 0 189 2.3939e-14
c8268 3 186 6.13e-16
c8269 0 1199 2.957e-15
c8270 1 193 4.406e-15
c8271 0 1642 2.957e-15
c8272 1680 190 7.77e-16
c8273 1681 191 7.91e-16
c8274 1682 188 7.23e-16
c8275 1683 189 7.91e-16
c8276 0 2137 2.623e-15
c8277 1760 230 7.77e-16
c8278 2678 0 1.23e-16
c8279 2119 226 7.23e-16
c8280 2118 227 7.91e-16
c8281 387 181 7.91e-16
c8282 386 180 7.23e-16
c8283 385 183 7.91e-16
c8284 384 182 7.77e-16
c8285 1 2543 5.36e-16
c8286 0 1460 2.585e-15
c8287 1464 217 7.77e-16
c8288 981 232 7.76e-16
c8289 1613 223 7.76e-16
c8290 0 1954 2.957e-15
c8291 2329 180 1.54e-16
c8293 1333 217 2.14e-16
c8294 0 1789 2.926e-15
c8295 1653 185 2.14e-16
c8296 1299 1298 6.77e-16
c8297 2776 0 1.0813e-14
c8298 101 103 2.17e-16
c8299 0 667 2.623e-15
c8300 2641 2643 1.356e-15
c8301 227 331 2.8e-16
c8302 226 330 2.5e-16
c8303 2389 2505 2.11e-16
c8304 1 668 1.6e-16
c8305 1024 183 2.13e-16
c8306 1026 181 2.5e-16
c8307 0 2101 2.926e-15
c8308 521 193 2.54e-16
c8309 520 192 2.13e-16
c8310 142 209 3.31e-16
c8311 136 210 1.99e-16
c8312 0 149 1.82e-16
c8313 0 979 2.623e-15
c8314 42 227 1.99e-16
c8315 1 980 1.6e-16
c8316 1 1425 1.6e-16
c8317 142 203 3.34e-16
c8318 1883 234 7.91e-16
c8319 0 319 2.957e-15
c8320 0 812 2.585e-15
c8321 1 2463 7.03e-16
c8322 1435 203 2.8e-16
c8323 1437 199 7.76e-16
c8324 0 1306 2.957e-15
c8325 1318 210 2.8e-16
c8326 0 1915 2.623e-15
c8327 745 240 7.91e-16
c8328 1585 206 2.54e-16
c8329 1587 204 2.8e-16
c8330 2242 0 2.957e-15
c8331 0 297 2.623e-15
c8332 15 17 3.34e-16
c8333 1455 1454 6.77e-16
c8334 1 1737 1.6e-16
c8335 651 194 7.91e-16
c8336 654 188 7.91e-16
c8337 652 190 8.32e-16
c8338 732 230 8.32e-16
c8339 0 1124 2.585e-15
c8340 42 205 3.34e-16
c8341 1244 231 2.13e-16
c8342 2081 198 2.54e-16
c8343 2083 196 2.8e-16
c8344 0 609 2.623e-15
c8345 220 100 1.99e-16
c8346 2626 236 1.206e-15
c8347 42 200 1.94e-16
c8348 0 1550 2.623e-15
c8349 1171 1170 6.77e-16
c8350 2074 203 7.23e-16
c8351 1504 230 7.77e-16
c8352 58 230 1.9e-16
c8353 2016 231 2.13e-16
c8354 0 426 2.957e-15
c8355 2296 2429 2.39e-16
c8356 2384 2359 9.05e-16
c8357 1088 215 2.13e-16
c8358 1348 224 2.13e-16
c8359 1246 1247 6.77e-16
c8360 277 201 2.14e-16
c8361 0 244 2.585e-15
c8362 0 738 2.957e-15
c8363 494 495 6.77e-16
c8364 2784 143 1.022e-15
c8365 2764 2774 1.96e-16
c8366 1 2401 1.947e-15
c8367 2299 2587 5.08e-16
c8368 0 1248 2.957e-15
c8369 2182 2183 6.77e-16
c8370 0 2184 2.957e-15
c8371 2420 2391 1.035e-15
c8372 1642 243 7.23e-16
c8373 2427 0 1.7262e-14
c8374 2298 2351 5.5e-16
c8375 0 573 2.926e-15
c8376 213 115 3.34e-16
c8377 2637 2545 1.96e-16
c8378 2641 2548 1.96e-16
c8379 2639 2543 1.96e-16
c8380 2343 2592 1.96e-16
c8381 1338 218 2.5e-16
c8382 0 52 7.793e-14
c8383 1 1515 1.6e-16
c8384 8 2625 6.32e-16
c8385 1 2025 1.6e-16
c8386 365 239 7.76e-16
c8387 367 237 7.23e-16
c8388 876 238 8.32e-16
c8389 0 902 2.623e-15
c8390 1316 1317 6.77e-16
c8391 2383 195 1.083e-15
c8392 1 1827 1.6e-16
c8393 14 234 3.34e-16
c8394 550 211 7.91e-16
c8395 385 384 6.77e-16
c8396 0 1214 2.623e-15
c8397 1062 210 2.8e-16
c8398 0 1659 2.623e-15
c8399 2252 2253 6.77e-16
c8400 1 1660 1.6e-16
c8401 20 220 3.34e-16
c8402 2268 230 8.32e-16
c8403 185 153 3.31e-16
c8404 180 157 3.34e-16
c8405 241 485 2.14e-16
c8406 0 1971 2.623e-15
c8407 164 73 3.31e-16
c8408 366 367 6.77e-16
c8409 1563 1562 6.77e-16
c8410 1 1972 1.6e-16
c8411 381 183 7.76e-16
c8412 383 181 7.23e-16
c8413 379 187 2.8e-16
c8414 891 186 7.91e-16
c8415 894 180 7.91e-16
c8416 892 182 8.32e-16
c8417 2675 2634 5.27e-16
c8418 2823 2841 1.96e-16
c8419 876 877 6.77e-16
c8420 2073 2072 6.77e-16
c8421 6 0 1.5628e-14
c8422 0 351 2.957e-15
c8423 1753 232 7.91e-16
c8424 0 680 2.957e-15
c8425 2655 2505 1.96e-16
c8426 832 215 2.13e-16
c8427 1 2773 6.27e-16
c8428 0 1623 2.957e-15
c8429 1 1179 1.6e-16
c8430 2148 2149 6.77e-16
c8431 0 663 2.957e-15
c8432 1396 1397 6.77e-16
c8433 2312 2651 1.176e-15
c8434 2643 2590 1.96e-16
c8435 0 1156 2.585e-15
c8436 0 992 2.957e-15
c8437 0 1601 2.623e-15
c8438 1 502 1.6e-16
c8439 0 1918 2.623e-15
c8440 0 975 2.957e-15
c8441 8 66 1.96e-16
c8442 69 233 3.31e-16
c8443 1879 234 7.23e-16
c8444 1878 235 7.91e-16
c8445 2510 2484 9.05e-16
c8446 2299 0 1.87586e-13
c8447 2471 2831 6.33e-16
c8448 622 236 7.91e-16
c8449 620 238 8.32e-16
c8450 1708 1709 6.77e-16
c8451 959 212 2.5e-16
c8452 741 240 7.76e-16
c8453 1161 192 7.91e-16
c8454 1 809 1.6e-16
c8455 0 1730 2.957e-15
c8456 1578 210 2.5e-16
c8457 1582 205 2.8e-16
c8458 1581 206 2.14e-16
c8459 1580 207 2.13e-16
c8460 1583 204 2.5e-16
c8461 59 23 2.44e-16
c8462 2740 0 1.3625e-14
c8463 1 1571 1.6e-16
c8464 647 194 7.23e-16
c8465 2643 2422 1.96e-16
c8466 2471 2572 1.58e-16
c8467 1945 1944 6.77e-16
c8468 1 1121 1.6e-16
c8469 1513 241 2.54e-16
c8470 1 1404 1.6e-16
c8471 52 243 1.99e-16
c8472 2025 240 7.91e-16
c8473 0 443 2.623e-15
c8474 1 2062 1.6e-16
c8475 233 168 1.9e-16
c8476 231 153 1.94e-16
c8477 222 592 7.77e-16
c8478 0 63 7.793e-14
c8479 2784 2787 1.031e-15
c8480 1 444 1.6e-16
c8481 1419 195 2.8e-16
c8482 1262 237 2.8e-16
c8483 1261 238 2.14e-16
c8484 1260 239 2.13e-16
c8485 1263 236 2.5e-16
c8486 0 1877 2.926e-15
c8487 2012 230 8.32e-16
c8488 0 755 2.623e-15
c8489 0 1265 2.623e-15
c8490 1 756 1.6e-16
c8491 37 180 1.99e-16
c8492 31 187 1.99e-16
c8493 915 914 6.77e-16
c8494 1552 191 2.13e-16
c8495 1554 189 2.5e-16
c8496 2201 0 2.623e-15
c8497 2065 190 2.54e-16
c8498 2067 188 2.8e-16
c8499 0 588 2.585e-15
c8500 222 115 3.31e-16
c8501 2152 241 7.77e-16
c8502 2766 2633 1.34e-16
c8503 0 1082 2.957e-15
c8504 421 208 7.76e-16
c8505 420 209 8.32e-16
c8506 722 221 2.5e-16
c8507 723 220 2.8e-16
c8508 1 223 3.42e-15
c8509 2142 229 2.8e-16
c8510 2645 2625 1.96e-16
c8511 2364 2627 2.83e-16
c8512 2312 2585 1.96e-16
c8513 2305 2632 4.52e-16
c8514 8 2545 5.64e-16
c8515 0 407 2.957e-15
c8516 143 152 6.55e-16
c8517 90 211 3.34e-16
c8518 762 187 7.23e-16
c8519 1274 186 2.5e-16
c8520 1278 181 2.8e-16
c8521 1277 182 2.14e-16
c8522 1276 183 2.13e-16
c8523 1279 180 2.5e-16
c8524 1846 218 2.8e-16
c8525 2408 197 4.83e-16
c8526 217 115 1.9e-16
c8527 100 186 3.34e-16
c8528 0 105 7.793e-14
c8529 94 187 1.99e-16
c8530 79 197 1.99e-16
c8531 248 184 2.13e-16
c8532 249 185 2.54e-16
c8533 3 208 3.08e-16
c8534 0 719 2.957e-15
c8535 14 241 3.31e-16
c8536 0 1229 2.926e-15
c8537 0 1672 2.957e-15
c8538 2184 193 7.77e-16
c8539 58 209 3.31e-16
c8540 1 2460 7.52e-16
c8541 550 551 6.77e-16
c8542 0 1984 2.957e-15
c8543 58 203 3.34e-16
c8544 52 193 1.9e-16
c8545 1060 1061 6.77e-16
c8546 2318 2475 2.39e-16
c8547 2291 236 2.8e-16
c8548 391 194 7.23e-16
c8549 308 309 6.77e-16
c8550 2697 2860 5.57e-16
c8551 1 355 1.6e-16
c8552 1 865 1.6e-16
c8553 1818 202 2.5e-16
c8554 1822 197 2.8e-16
c8555 1821 198 2.14e-16
c8556 1820 199 2.13e-16
c8557 1823 196 2.5e-16
c8558 2337 184 2.264e-15
c8559 1 1806 1.6e-16
c8560 545 544 6.77e-16
c8561 0 697 2.623e-15
c8562 2732 2318 1.58e-16
c8563 222 336 7.77e-16
c8564 0 1336 2.957e-15
c8565 841 224 7.91e-16
c8566 1 2829 5.88e-16
c8567 2233 2232 6.77e-16
c8568 1749 232 7.76e-16
c8569 1486 1487 6.77e-16
c8570 1967 205 7.23e-16
c8571 1965 207 7.76e-16
c8572 0 678 2.623e-15
c8573 2752 2294 2.03e-16
c8574 2318 2358 1.18e-15
c8575 2647 2305 1.53e-15
c8576 2643 2364 1.296e-15
c8577 2719 2322 1.526e-15
c8578 220 334 7.91e-16
c8579 0 514 2.957e-15
c8580 1 2118 1.6e-16
c8581 620 621 6.77e-16
c8582 0 1009 2.623e-15
c8583 1030 195 7.91e-16
c8584 1449 208 7.91e-16
c8585 31 229 3.34e-16
c8586 0 1933 2.926e-15
c8587 59 45 2.44e-16
c8588 80 58 1.59e-16
c8589 101 40 2.44e-16
c8590 0 142 7.8194e-14
c8591 0 990 2.623e-15
c8592 0 1435 2.623e-15
c8593 1 2509 7.03e-16
c8594 857 856 6.77e-16
c8595 968 225 7.77e-16
c8596 1945 200 7.91e-16
c8597 63 243 1.99e-16
c8598 1 1436 1.6e-16
c8599 2307 2293 1.6e-16
c8600 2257 0 2.623e-15
c8601 1886 229 2.8e-16
c8602 20 186 1.99e-16
c8603 14 191 1.94e-16
c8604 2471 2298 1.912e-15
c8606 0 1319 2.957e-15
c8607 1 331 1.6e-16
c8608 0 1747 2.623e-15
c8609 932 933 6.77e-16
c8610 1590 218 2.8e-16
c8611 2255 0 2.957e-15
c8612 2548 2527 1.52e-16
c8613 2089 209 2.54e-16
c8614 2088 208 2.13e-16
c8615 2129 2128 6.77e-16
c8616 1 1748 1.6e-16
c8617 8 100 3.47e-16
c8618 1377 1376 6.77e-16
c8619 229 94 3.34e-16
c8620 228 84 3.34e-16
c8621 2389 2627 1.321e-15
c8622 0 33 1.82e-16
c8623 1156 193 8.32e-16
c8624 1157 192 7.76e-16
c8625 0 2074 2.957e-15
c8626 1 42 7.6e-16
c8627 0 456 2.957e-15
c8628 0 1399 2.957e-15
c8629 1 955 1.6e-16
c8630 0 1892 2.585e-15
c8631 1719 219 2.5e-16
c8632 0 768 2.957e-15
c8633 2773 2776 6.14e-16
c8634 2764 2760 1.529e-15
c8635 632 185 7.77e-16
c8636 243 105 1.99e-16
c8637 1689 1688 6.77e-16
c8638 1 278 1.6e-16
c8639 0 1711 2.957e-15
c8640 2427 2401 2.58e-16
c8641 143 17 3.31e-16
c8642 2296 2358 1.537e-15
c8643 631 186 7.23e-16
c8644 2641 2465 1.96e-16
c8645 2639 2460 1.96e-16
c8646 2637 2462 1.96e-16
c8647 2299 2543 3.47e-16
c8648 224 585 7.91e-16
c8649 226 227 3.76e-16
c8650 2058 194 2.5e-16
c8651 2062 189 2.8e-16
c8652 2061 190 2.14e-16
c8653 2060 191 2.13e-16
c8654 2063 188 2.5e-16
c8655 1493 232 7.76e-16
c8656 2294 2592 1.96e-16
c8657 2305 2550 1.96e-16
c8658 2645 2545 1.96e-16
c8659 2364 2548 1.96e-16
c8660 2312 2503 2.66e-16
c8661 572 214 8.32e-16
c8662 69 190 1.9e-16
c8663 63 193 1.9e-16
c8664 1 1347 1.6e-16
c8665 48 213 1.99e-16
c8666 1 1857 1.6e-16
c8667 2602 2594 1.6e-16
c8668 260 192 2.13e-16
c8669 2760 2755 1.74e-16
c8670 2665 2343 3.54e-16
c8671 2389 2643 1.58e-16
c8672 2709 2335 3.92e-16
c8673 1270 187 7.91e-16
c8674 712 225 7.77e-16
c8675 1689 200 7.91e-16
c8676 1224 224 2.13e-16
c8677 1536 183 2.13e-16
c8678 1538 181 2.5e-16
c8679 2196 201 8.32e-16
c8680 2197 200 7.76e-16
c8681 8 20 3.14e-16
c8682 2771 2786 5.09e-16
c8683 207 153 1.94e-16
c8684 2132 233 8.32e-16
c8685 224 132 3.24e-16
c8686 0 1063 2.957e-15
c8687 1072 206 7.77e-16
c8688 1073 207 7.91e-16
c8689 1075 205 7.91e-16
c8690 1213 214 2.14e-16
c8691 0 1491 2.623e-15
c8692 0 2001 2.623e-15
c8693 1833 209 2.54e-16
c8694 1832 208 2.13e-16
c8695 202 153 3.34e-16
c8696 0 546 2.957e-15
c8697 197 157 3.34e-16
c8698 1 1492 1.6e-16
c8699 190 168 3.31e-16
c8700 194 163 3.34e-16
c8701 0 1041 2.623e-15
c8702 2549 227 1.083e-15
c8703 204 205 6.86e-16
c8704 243 142 3.34e-16
c8705 59 67 3.02e-16
c8706 1474 213 2.5e-16
c8707 1475 212 2.8e-16
c8708 2286 237 2.8e-16
c8709 2287 236 2.5e-16
c8710 2284 239 2.13e-16
c8711 2285 238 2.14e-16
c8712 0 858 2.957e-15
c8713 121 187 3.34e-16
c8714 115 184 1.94e-16
c8715 111 180 1.99e-16
c8716 105 193 1.9e-16
c8717 2709 2713 1.6e-16
c8718 1670 1671 6.77e-16
c8719 1 182 4.537e-15
c8720 0 1636 2.585e-15
c8721 1672 193 7.77e-16
c8722 2289 0 2.623e-15
c8723 1756 231 2.13e-16
c8724 0 2130 2.957e-15
c8725 196 132 1.99e-16
c8726 0 693 2.926e-15
c8727 1 2672 2.88e-16
c8728 1907 1906 6.77e-16
c8729 0 1455 2.957e-15
c8730 1 1190 1.6e-16
c8731 42 240 1.94e-16
c8732 0 1948 2.585e-15
c8733 1 1635 1.6e-16
c8734 1959 211 2.5e-16
c8735 2322 0 4.0479e-14
c8736 289 288 6.77e-16
c8737 0 1005 2.926e-15
c8738 234 475 7.91e-16
c8739 224 147 1.94e-16
c8740 1122 228 7.23e-16
c8741 977 222 2.54e-16
c8742 1982 1983 6.77e-16
c8743 1802 194 2.5e-16
c8744 1806 189 2.8e-16
c8745 1805 190 2.14e-16
c8746 1804 191 2.13e-16
c8747 1807 188 2.5e-16
c8748 1 1323 1.6e-16
c8749 2299 2401 1.96e-16
c8750 164 0 1.3731e-14
c8751 164 113 4.85e-16
c8752 2854 2665 1.58e-16
c8753 2296 2834 5.88e-16
c8754 225 325 2.14e-16
c8755 0 1760 2.957e-15
c8756 2100 216 2.13e-16
c8757 1467 1466 6.77e-16
c8758 143 103 3.31e-16
c8759 673 198 2.54e-16
c8760 675 196 2.8e-16
c8761 2248 225 7.77e-16
c8762 2389 2548 1.158e-15
c8763 601 600 6.77e-16
c8764 1014 187 7.91e-16
c8765 1 641 1.6e-16
c8766 1 1582 1.6e-16
c8767 2238 213 2.8e-16
c8768 2294 2382 2.1e-16
c8769 0 473 2.623e-15
c8770 2466 211 1.083e-15
c8771 142 193 3.31e-16
c8772 147 196 3.34e-16
c8773 136 194 1.99e-16
c8774 1542 1543 6.77e-16
c8775 226 455 7.23e-16
c8776 227 454 7.91e-16
c8777 816 206 7.77e-16
c8778 817 207 7.91e-16
c8779 818 204 7.23e-16
c8780 819 205 7.91e-16
c8781 0 1414 2.623e-15
c8782 1334 1335 6.77e-16
c8783 2627 2574 4.21e-16
c8784 8 2597 4.35e-16
c8785 0 290 2.957e-15
c8786 0 785 2.623e-15
c8787 2652 2305 5.88e-16
c8788 2654 2647 1.96e-16
c8789 2697 2643 1.96e-16
c8790 1312 198 7.77e-16
c8791 1313 199 7.91e-16
c8792 1314 196 7.23e-16
c8793 1315 197 7.91e-16
c8794 31 210 1.99e-16
c8795 1 1299 1.6e-16
c8796 2799 2805 8.04e-16
c8797 13 80 1.237e-15
c8798 0 602 2.957e-15
c8799 2622 238 3.99e-16
c8800 3 235 3.48e-16
c8801 229 121 1.99e-16
c8802 0 1097 2.623e-15
c8803 1140 185 8.32e-16
c8804 42 189 3.34e-16
c8805 37 197 1.99e-16
c8806 1 2651 3.805e-15
c8807 1558 203 7.91e-16
c8808 0 2038 2.623e-15
c8809 2070 202 2.8e-16
c8810 2651 2467 1.96e-16
c8811 8 2462 5.14e-16
c8812 0 420 2.585e-15
c8813 1612 1613 6.77e-16
c8814 1403 186 7.91e-16
c8815 1703 211 2.5e-16
c8816 52 223 3.24e-16
c8817 48 222 1.9e-16
c8818 2421 196 1.206e-15
c8819 0 95 1.82e-16
c8820 239 115 3.24e-16
c8821 100 208 3.24e-16
c8822 94 210 1.99e-16
c8823 214 163 1.9e-16
c8824 0 732 2.585e-15
c8825 2764 2761 1.599e-15
c8826 2655 2643 7.46e-16
c8827 134 136 3.92e-16
c8828 1 237 3.749e-15
c8829 866 228 7.23e-16
c8830 1 1246 1.6e-16
c8831 2409 2439 1.96e-16
c8832 2420 2392 2.07e-16
c8833 2377 2342 4.09e-16
c8834 2340 2314 1.58e-16
c8835 571 219 2.8e-16
c8836 1 2182 1.6e-16
c8837 59 31 2.17e-16
c8838 0 1504 2.957e-15
c8839 1220 225 8.32e-16
c8840 0 58 7.8194e-14
c8841 48 217 3.31e-16
c8842 2643 2574 3.62e-16
c8843 2649 2490 1.58e-16
c8844 2318 2572 2.44e-16
c8845 819 818 6.77e-16
c8846 1 385 1.6e-16
c8847 0 1997 2.926e-15
c8848 0 1816 2.957e-15
c8849 1483 226 7.91e-16
c8850 1829 209 2.14e-16
c8851 1985 214 2.54e-16
c8852 2632 2624 6.67e-16
c8853 0 875 2.623e-15
c8854 2757 2762 8.3e-16
c8855 232 345 7.91e-16
c8856 1 366 1.6e-16
c8857 1 876 1.6e-16
c8858 1210 219 7.23e-16
c8859 1471 212 2.5e-16
c8860 0 2147 2.623e-15
c8861 2169 184 7.91e-16
c8862 0 708 2.585e-15
c8863 1 2148 1.6e-16
c8864 1058 196 7.23e-16
c8865 1059 197 7.91e-16
c8866 1131 1130 6.77e-16
c8867 2662 0 1.65e-16
c8868 0 527 2.957e-15
c8869 2115 213 7.91e-16
c8870 2379 2320 3.76e-16
c8871 0 1020 2.585e-15
c8872 1 2585 9.69e-16
c8873 2492 224 7.35e-16
c8874 884 185 8.32e-16
c8875 885 184 7.76e-16
c8876 1774 237 2.8e-16
c8877 1773 238 2.14e-16
c8878 1772 239 2.13e-16
c8879 1775 236 2.5e-16
c8880 20 208 1.94e-16
c8881 1 1945 1.6e-16
c8882 2632 2562 1.9e-16
c8883 2627 2555 1.58e-16
c8884 0 839 2.957e-15
c8885 186 187 3.76e-16
c8886 214 136 3.31e-16
c8887 2863 2866 2.78e-16
c8888 1 2512 1.79e-16
c8889 454 455 6.77e-16
c8890 2687 2690 1.6e-16
c8891 973 222 2.14e-16
c8892 0 1777 2.623e-15
c8893 2268 0 2.585e-15
c8894 2585 2571 2.32e-16
c8895 2641 2351 1.372e-15
c8896 2312 2335 1.96e-16
c8897 2637 2635 5.88e-16
c8898 2294 2333 1.96e-16
c8899 2639 2651 5.88e-16
c8900 2655 2548 1.96e-16
c8901 0 1151 2.957e-15
c8902 0 1594 2.957e-15
c8903 0 2089 2.623e-15
c8904 2296 2572 1.58e-16
c8905 27 213 1.99e-16
c8906 766 767 6.77e-16
c8907 1786 186 2.5e-16
c8908 1790 181 2.8e-16
c8909 1789 182 2.14e-16
c8910 1788 183 2.13e-16
c8911 1791 180 2.5e-16
c8912 2545 2492 4.21e-16
c8913 1276 1277 6.77e-16
c8914 0 307 2.623e-15
c8915 2510 2485 1.58e-16
c8916 524 525 6.77e-16
c8917 811 211 2.8e-16
c8918 1 308 1.6e-16
c8919 0 1724 2.585e-15
c8920 63 223 3.24e-16
c8921 1573 209 2.14e-16
c8922 1874 220 7.23e-16
c8923 251 250 6.77e-16
c8924 0 619 2.623e-15
c8925 3 242 6.13e-16
c8926 1 2233 1.6e-16
c8927 2299 2460 6.26e-16
c8928 1 620 1.6e-16
c8929 1094 226 2.8e-16
c8930 0 2053 2.926e-15
c8931 2647 2420 1.96e-16
c8932 2645 2462 1.96e-16
c8933 2364 2465 3.54e-16
c8934 58 243 3.34e-16
c8935 440 216 2.13e-16
c8936 441 217 2.54e-16
c8937 234 153 3.34e-16
c8938 0 931 2.623e-15
c8939 588 223 2.13e-16
c8940 836 837 6.77e-16
c8941 73 219 1.99e-16
c8942 0 65 1.82e-16
c8943 1 932 1.6e-16
c8944 1913 184 7.91e-16
c8945 2386 2395 1.6e-16
c8946 1 1377 1.6e-16
c8947 2305 2559 1.96e-16
c8948 0 254 2.623e-15
c8949 2384 2361 1.08e-16
c8950 2389 2766 1.96e-16
c8951 0 1258 2.957e-15
c8952 874 242 2.5e-16
c8953 875 243 2.8e-16
c8954 1296 190 7.77e-16
c8955 1297 191 7.91e-16
c8956 1298 188 7.23e-16
c8957 1299 189 7.91e-16
c8958 2194 0 2.957e-15
c8959 1 1689 1.6e-16
c8960 2298 2318 5.5e-16
c8961 2665 2294 4.26e-16
c8962 2296 2340 4.7e-16
c8963 0 583 2.957e-15
c8964 2148 240 2.13e-16
c8965 223 105 3.24e-16
c8966 717 222 2.14e-16
c8967 0 1076 2.585e-15
c8968 1080 217 7.77e-16
c8969 0 1521 2.623e-15
c8970 1 226 3.839e-15
c8971 1229 223 7.76e-16
c8972 1542 195 7.91e-16
c8973 1148 1149 6.77e-16
c8974 0 561 2.623e-15
c8975 216 163 3.24e-16
c8976 211 178 1.99e-16
c8977 220 126 3.34e-16
c8978 2639 2585 2.91e-16
c8979 2635 2630 1.96e-16
c8980 396 397 6.77e-16
c8981 1593 1592 6.77e-16
c8982 0 1502 2.623e-15
c8983 2652 2654 3.803e-15
c8984 2827 2675 1.58e-16
c8985 2823 2697 1.357e-15
c8986 1 1075 1.6e-16
c8987 0 2012 2.585e-15
c8988 0 1833 2.623e-15
c8989 1992 224 2.13e-16
c8990 0 378 2.957e-15
c8991 415 196 2.5e-16
c8992 412 199 2.13e-16
c8993 413 198 2.14e-16
c8994 414 197 2.8e-16
c8995 410 202 2.5e-16
c8996 0 888 2.957e-15
c8997 210 121 3.34e-16
c8998 206 115 3.31e-16
c8999 90 195 3.34e-16
c9000 1 204 3.719e-15
c9001 2015 2014 6.77e-16
c9002 115 201 1.9e-16
c9003 111 197 1.99e-16
c9004 3 192 3.08e-16
c9005 0 130 1.14e-16
c9006 1 1670 1.6e-16
c9007 0 1200 2.957e-15
c9008 1 199 3.42e-15
c9009 2384 2320 2.59e-16
c9010 1 2693 2.88e-16
c9011 0 2143 2.957e-15
c9012 58 193 3.31e-16
c9013 48 184 3.24e-16
c9014 52 182 3.31e-16
c9015 2592 0 2.3259e-14
c9016 1 1982 1.6e-16
c9017 1051 203 2.8e-16
c9018 1055 197 7.23e-16
c9019 1053 199 7.76e-16
c9020 1 2503 8.02e-16
c9021 1 2549 7.03e-16
c9022 1 1467 1.6e-16
c9023 2490 214 5.06e-16
c9024 229 478 2.8e-16
c9025 223 142 1.94e-16
c9026 101 90 1.58e-16
c9027 122 82 8.48e-16
c9028 1337 216 7.91e-16
c9029 1 2833 3.53e-16
c9030 1657 184 7.91e-16
c9031 1 1334 1.6e-16
c9032 13 0 8.3341e-14
c9033 2296 2298 3.466e-15
c9034 101 110 6.55e-16
c9035 122 118 1.225e-15
c9036 2257 223 7.91e-16
c9037 2343 2294 2.391e-15
c9038 2389 2465 1.58e-16
c9039 0 1166 2.623e-15
c9040 242 618 2.5e-16
c9041 243 619 2.8e-16
c9042 0 1611 2.623e-15
c9043 1745 222 2.54e-16
c9044 1 1612 1.6e-16
c9045 2253 222 2.14e-16
c9046 8 2635 4.03e-16
c9047 2590 2351 1.96e-16
c9048 136 216 1.94e-16
c9049 0 140 1.14e-16
c9050 2462 2407 1.58e-16
c9051 27 222 1.9e-16
c9052 964 224 2.13e-16
c9053 143 40 3.31e-16
c9054 14 180 1.99e-16
c9055 0 320 2.957e-15
c9056 823 218 7.23e-16
c9057 435 434 6.77e-16
c9058 1 819 1.6e-16
c9059 1782 187 7.91e-16
c9060 1258 243 7.23e-16
c9061 15 18 5.01e-16
c9062 38 23 1.74e-16
c9063 2510 2486 1.08e-16
c9064 235 100 3.34e-16
c9065 228 79 1.99e-16
c9066 737 231 7.91e-16
c9067 27 217 3.31e-16
c9068 0 1558 2.623e-15
c9069 1 1131 1.6e-16
c9070 0 2068 2.585e-15
c9071 1919 181 7.23e-16
c9072 1917 183 7.76e-16
c9073 2635 2425 1.96e-16
c9074 2351 2422 1.96e-16
c9075 2651 2427 1.96e-16
c9076 241 153 3.31e-16
c9077 0 944 2.957e-15
c9078 301 207 7.76e-16
c9079 303 205 7.23e-16
c9080 926 927 6.77e-16
c9081 1 454 1.6e-16
c9082 747 746 6.77e-16
c9083 0 1887 2.957e-15
c9084 1257 1256 6.77e-16
c9085 2224 207 2.13e-16
c9086 2226 205 2.5e-16
c9087 0 269 2.926e-15
c9088 505 504 6.77e-16
c9089 799 197 7.23e-16
c9090 797 199 7.76e-16
c9091 0 1370 2.957e-15
c9092 0 1275 2.623e-15
c9093 1 766 1.6e-16
c9094 1 1276 1.6e-16
c9095 2193 2192 6.77e-16
c9096 1863 227 2.5e-16
c9097 281 200 7.91e-16
c9098 2572 2480 1.52e-16
c9099 2764 2786 1.104e-15
c9100 212 90 1.99e-16
c9101 1 251 1.6e-16
c9102 48 239 1.94e-16
c9103 52 237 3.34e-16
c9104 2053 193 2.14e-16
c9105 2382 0 1.7608e-14
c9106 2639 2503 1.96e-16
c9107 3 215 3.08e-16
c9108 0 1517 2.926e-15
c9109 2174 2175 6.77e-16
c9110 63 182 3.31e-16
c9111 0 56 1.14e-16
c9112 1489 222 2.54e-16
c9113 2001 223 7.91e-16
c9114 0 395 2.623e-15
c9115 0 905 2.623e-15
c9116 921 201 2.54e-16
c9117 920 200 2.13e-16
c9118 2788 2757 1.58e-16
c9119 2471 2641 1.74e-16
c9120 1758 1759 6.77e-16
c9121 1 396 1.6e-16
c9122 854 234 2.8e-16
c9123 0 1829 2.926e-15
c9124 1486 221 2.8e-16
c9125 2544 221 2.431e-15
c9126 20 235 1.99e-16
c9127 1 2339 7.03e-16
c9128 231 348 2.13e-16
c9129 555 210 7.91e-16
c9130 558 204 7.91e-16
c9131 556 206 8.32e-16
c9132 0 1217 2.623e-15
c9133 1064 209 7.77e-16
c9134 1526 187 7.91e-16
c9135 0 2158 2.623e-15
c9136 1626 234 2.5e-16
c9137 1627 235 2.8e-16
c9138 191 153 1.94e-16
c9139 183 163 1.94e-16
c9140 0 540 2.585e-15
c9141 2128 222 7.77e-16
c9142 377 376 6.77e-16
c9143 0 1034 2.957e-15
c9144 706 212 7.23e-16
c9145 240 488 2.13e-16
c9146 1978 219 7.23e-16
c9147 101 61 2.44e-16
c9148 105 182 3.31e-16
c9149 0 852 2.585e-15
c9150 2719 2665 4.78e-16
c9151 1194 210 2.5e-16
c9152 1198 205 2.8e-16
c9153 1197 206 2.14e-16
c9154 1196 207 2.13e-16
c9155 1199 204 2.5e-16
c9156 2282 0 2.957e-15
c9157 187 132 3.34e-16
c9158 186 126 1.99e-16
c9159 692 216 2.13e-16
c9160 2734 8 3.35e-16
c9161 2655 2465 1.96e-16
c9162 2687 2462 3.92e-16
c9163 0 1181 2.926e-15
c9164 0 1624 2.957e-15
c9165 1129 241 2.54e-16
c9166 1607 227 2.5e-16
c9167 2645 2635 5.88e-16
c9168 2364 2351 9.8e-16
c9169 233 468 8.32e-16
c9170 1 505 1.6e-16
c9171 2140 2141 6.77e-16
c9172 0 1921 2.623e-15
c9173 2510 2490 2.59e-16
c9174 2299 2402 1.196e-15
c9175 2630 2560 1.34e-16
c9176 1 2484 1.947e-15
c9177 1378 228 7.23e-16
c9178 73 230 3.31e-16
c9179 1 1758 1.6e-16
c9180 2244 224 2.13e-16
c9181 665 201 2.54e-16
c9182 664 200 2.13e-16
c9183 242 100 3.34e-16
c9184 1 2771 3.53e-16
c9185 598 234 2.8e-16
c9186 0 1573 2.926e-15
c9187 1725 215 7.76e-16
c9188 2516 2517 1.149e-15
c9189 0 630 2.623e-15
c9190 2649 2379 1.96e-16
c9191 2647 2377 1.96e-16
c9192 0 466 2.957e-15
c9193 147 187 1.99e-16
c9194 142 182 1.9e-16
c9195 136 183 3.24e-16
c9196 63 237 3.34e-16
c9197 0 1902 2.623e-15
c9198 228 157 3.34e-16
c9199 295 211 2.5e-16
c9200 0 284 2.585e-15
c9201 0 942 2.623e-15
c9202 595 594 6.77e-16
c9204 752 238 7.77e-16
c9205 753 239 7.91e-16
c9206 754 236 7.23e-16
c9207 755 237 7.91e-16
c9208 0 778 2.957e-15
c9209 0 1387 2.623e-15
c9210 0 1288 2.957e-15
c9211 1304 201 7.77e-16
c9212 2209 0 2.623e-15
c9213 2218 211 7.23e-16
c9214 2333 0 1.6414e-14
c9215 791 203 2.5e-16
c9216 233 115 1.9e-16
c9217 221 90 1.99e-16
c9218 0 1271 2.957e-15
c9219 1303 202 7.23e-16
c9220 670 671 6.77e-16
c9221 724 232 2.13e-16
c9222 27 184 3.24e-16
c9223 31 194 1.99e-16
c9224 1 2335 7.39e-16
c9225 0 1699 2.623e-15
c9226 1 232 3.792e-15
c9227 2207 0 2.957e-15
c9228 1 1700 1.6e-16
c9229 8 126 2.3e-16
c9230 238 163 1.9e-16
c9231 229 132 1.99e-16
c9232 2299 2585 2.07e-15
c9233 1 595 1.6e-16
c9234 0 1532 2.585e-15
c9235 1396 185 8.32e-16
c9236 1397 184 7.76e-16
c9237 219 174 3.34e-16
c9238 58 223 1.94e-16
c9239 52 226 1.99e-16
c9240 2417 198 3.99e-16
c9241 0 408 2.957e-15
c9242 2299 2512 4.02e-16
c9243 237 105 3.34e-16
c9244 90 218 3.34e-16
c9246 768 182 7.77e-16
c9247 769 183 7.91e-16
c9248 770 180 7.23e-16
c9249 771 181 7.91e-16
c9250 0 1844 2.585e-15
c9251 982 983 6.77e-16
c9252 1997 223 7.76e-16
c9253 100 192 3.24e-16
c9254 94 194 1.99e-16
c9255 0 219 2.5247e-14
c9256 2333 2319 2.32e-16
c9257 121 118 3.92e-16
c9258 0 720 2.957e-15
c9259 1427 1426 6.77e-16
c9260 20 242 1.99e-16
c9261 2282 243 7.23e-16
c9262 2389 2351 1.063e-15
c9263 1 2354 1.424e-15
c9264 2471 2590 2.44e-16
c9265 2343 2587 1.96e-16
c9266 1 2713 2.88e-16
c9267 164 42 3.31e-16
c9268 48 206 1.9e-16
c9269 52 204 3.34e-16
c9270 2704 0 1.65e-16
c9271 2382 193 7.02e-16
c9272 59 8 5.09e-16
c9273 2635 2407 1.58e-16
c9274 2637 2409 3.54e-16
c9275 0 1051 2.623e-15
c9276 1 1052 1.6e-16
c9277 48 201 3.31e-16
c9278 52 199 3.24e-16
c9279 1476 225 8.32e-16
c9280 2373 188 1.54e-16
c9281 0 357 2.926e-15
c9282 229 147 3.34e-16
c9283 905 193 2.54e-16
c9284 904 192 2.13e-16
c9285 1 2552 1.79e-16
c9286 1739 1738 6.77e-16
c9287 1052 1053 6.77e-16
c9288 2627 2609 2.8e-16
c9289 1 1809 1.6e-16
c9290 2665 0 2.002e-14
c9291 122 87 7.01e-16
c9292 0 703 2.957e-15
c9293 2733 2364 1.96e-16
c9294 2732 2305 3.15e-16
c9295 1 2838 1.293e-15
c9296 1969 206 2.54e-16
c9297 1971 204 2.8e-16
c9298 2305 2358 7.84e-16
c9299 2647 2735 7.67e-16
c9300 2643 2746 1.58e-16
c9301 535 203 2.5e-16
c9302 142 237 1.99e-16
c9303 136 238 3.31e-16
c9304 1 2121 1.6e-16
c9305 0 1015 2.957e-15
c9306 1035 194 7.91e-16
c9307 1038 188 7.91e-16
c9308 1036 190 8.32e-16
c9309 1 2646 2.88e-16
c9310 0 1443 2.623e-15
c9311 37 228 1.99e-16
c9312 1 1444 1.6e-16
c9313 612 613 6.77e-16
c9314 1809 1808 6.77e-16
c9315 1 339 1.6e-16
c9316 1386 242 2.5e-16
c9317 1387 243 2.8e-16
c9318 0 1770 2.957e-15
c9319 2263 0 2.957e-15
c9320 1888 230 7.77e-16
c9321 20 192 1.94e-16
c9322 14 197 1.99e-16
c9323 0 333 2.926e-15
c9324 2625 2565 1.34e-16
c9325 2838 2845 6.14e-16
c9326 2649 2384 1.96e-16
c9327 214 321 2.54e-16
c9328 27 239 1.94e-16
c9329 1 651 1.6e-16
c9330 0 1588 2.585e-15
c9331 1884 1885 6.77e-16
c9332 1592 217 7.77e-16
c9333 1109 232 7.76e-16
c9334 1732 224 2.13e-16
c9335 0 2082 2.957e-15
c9336 661 201 2.14e-16
c9337 2634 2632 3.92e-16
c9338 66 69 3.92e-16
c9339 0 41 1.14e-16
c9340 31 214 3.31e-16
c9341 2121 2120 6.77e-16
c9342 1 963 1.6e-16
c9343 1369 1368 6.77e-16
c9344 0 957 2.926e-15
c9345 213 451 7.91e-16
c9346 0 1400 2.957e-15
c9347 1 796 1.6e-16
c9348 69 224 3.24e-16
c9349 0 1719 2.957e-15
c9350 1722 218 2.5e-16
c9351 63 226 1.99e-16
c9352 2230 219 7.91e-16
c9353 2460 2432 1.58e-16
c9354 1444 1445 6.77e-16
c9355 2343 0 8.4572e-14
c9356 2764 2805 5.39e-16
c9357 2779 101 5.76e-16
c9358 2675 2635 1.96e-16
c9359 2697 2351 1.96e-16
c9360 0 1286 2.623e-15
c9361 1 281 1.6e-16
c9362 0 1712 2.957e-15
c9363 1 1108 1.6e-16
c9364 215 100 1.94e-16
c9365 214 94 3.31e-16
c9366 213 84 3.34e-16
c9367 2643 2505 1.96e-16
c9368 2299 2503 1.73e-16
c9369 339 338 6.77e-16
c9370 934 211 7.91e-16
c9371 73 209 1.9e-16
c9372 63 204 3.34e-16
c9373 224 168 1.94e-16
c9374 227 163 3.34e-16
c9375 1 1865 1.6e-16
c9376 215 577 7.91e-16
c9377 213 212 6.86e-16
c9378 779 194 7.91e-16
c9379 782 188 7.91e-16
c9380 780 190 8.32e-16
c9381 0 1349 2.926e-15
c9382 242 358 2.8e-16
c9383 73 203 1.99e-16
c9384 69 196 1.99e-16
c9385 63 199 3.24e-16
c9386 869 241 2.14e-16
c9387 1288 193 7.77e-16
c9388 2820 8 2.98e-16
c9389 2634 2647 4.49e-16
c9390 2471 2364 5.74e-16
c9391 2687 2635 6.53e-16
c9392 2655 2351 1.334e-15
c9393 226 105 1.99e-16
c9394 2027 2026 6.77e-16
c9395 651 650 6.77e-16
c9396 2036 184 2.13e-16
c9397 205 163 1.99e-16
c9398 0 554 2.957e-15
c9399 2137 232 7.91e-16
c9400 0 1064 2.957e-15
c9401 2587 230 1.7e-16
c9402 1216 215 2.13e-16
c9403 0 2007 2.957e-15
c9404 1631 229 7.23e-16
c9405 1630 228 7.91e-16
c9406 2353 2342 1.6e-16
c9407 196 168 3.34e-16
c9408 200 163 3.24e-16
c9409 195 178 1.99e-16
c9410 2635 2492 3.54e-16
c9411 2651 2322 9.55e-16
c9412 2351 2574 3.54e-16
c9413 0 372 2.585e-15
c9414 405 201 2.14e-16
c9415 204 105 3.34e-16
c9416 90 185 3.31e-16
c9417 101 76 2.44e-16
c9418 80 73 1.59e-16
c9419 1 886 1.6e-16
c9420 963 962 6.77e-16
c9421 2368 191 3.12e-16
c9422 2354 189 2.07e-16
c9423 1770 243 7.23e-16
c9424 3 181 6.13e-16
c9425 210 132 3.34e-16
c9426 121 194 3.34e-16
c9427 208 126 1.94e-16
c9428 115 190 3.31e-16
c9429 105 199 3.24e-16
c9430 2854 0 1.744e-14
c9431 1 2822 3.31e-15
c9432 1 188 3.719e-15
c9433 1 1198 1.6e-16
c9434 1 1643 1.6e-16
c9435 58 182 1.9e-16
c9436 20 215 3.24e-16
c9437 2117 224 7.76e-16
c9438 1662 1663 6.77e-16
c9439 1006 236 7.91e-16
c9440 1004 238 8.32e-16
c9441 0 1456 2.957e-15
c9442 796 797 6.77e-16
c9443 1962 210 2.5e-16
c9444 0 515 2.623e-15
c9445 2425 2409 3.31e-16
c9446 1 1955 1.6e-16
c9447 226 142 3.34e-16
c9448 227 136 1.99e-16
c9449 0 1325 2.926e-15
c9450 1033 1032 6.77e-16
c9451 0 1787 2.623e-15
c9452 1897 241 2.54e-16
c9453 281 280 6.77e-16
c9454 1 1788 1.6e-16
c9455 2759 0 1.3275e-14
c9456 143 90 3.26e-16
c9457 2822 2845 1.96e-16
c9458 2641 2318 2.027e-15
c9459 2637 2649 8.55e-16
c9460 224 328 2.13e-16
c9461 1974 1975 6.77e-16
c9462 0 2099 2.623e-15
c9463 1108 1109 6.77e-16
c9464 2665 2543 3.97e-16
c9465 214 317 2.14e-16
c9466 519 195 2.5e-16
c9467 147 210 1.99e-16
c9468 142 204 1.99e-16
c9469 136 205 3.34e-16
c9470 1 2100 1.6e-16
c9471 1019 186 7.91e-16
c9472 1022 180 7.91e-16
c9473 1020 182 8.32e-16
c9474 0 1422 2.623e-15
c9475 1936 191 2.13e-16
c9476 1938 189 2.5e-16
c9477 0 479 2.957e-15
c9478 142 199 1.94e-16
c9479 136 200 1.94e-16
c9480 0 1417 2.623e-15
c9481 2389 2471 1.262e-15
c9482 1106 221 2.5e-16
c9483 1107 220 2.8e-16
c9484 1433 201 2.54e-16
c9485 1432 200 2.13e-16
c9486 1 318 1.6e-16
c9487 1366 234 2.8e-16
c9488 2281 2280 6.77e-16
c9489 1 1307 1.6e-16
c9490 230 174 1.9e-16
c9491 2572 2522 2.76e-16
c9492 0 791 2.957e-15
c9493 8 82 1.96e-16
c9494 2779 15 7.14e-16
c9495 2654 2358 1.96e-16
c9496 212 446 7.91e-16
c9497 213 447 7.23e-16
c9498 231 90 1.94e-16
c9499 1 2243 1.6e-16
c9500 0 1301 2.926e-15
c9501 1146 187 7.23e-16
c9502 27 206 1.9e-16
c9503 31 216 1.94e-16
c9504 1865 1864 6.77e-16
c9505 2220 0 2.585e-15
c9506 2572 2517 1.09e-16
c9507 8 118 1.96e-16
c9508 228 111 1.99e-16
c9509 222 84 3.31e-16
c9510 0 230 2.4398e-14
c9511 0 1103 2.957e-15
c9512 27 201 3.31e-16
c9513 0 1546 2.957e-15
c9514 1563 202 7.91e-16
c9515 1566 196 7.91e-16
c9516 1564 198 8.32e-16
c9517 0 2041 2.623e-15
c9518 2072 201 7.77e-16
c9519 52 232 1.94e-16
c9520 48 233 3.31e-16
c9521 2015 228 2.5e-16
c9522 0 1364 2.585e-15
c9523 1 427 1.6e-16
c9524 1087 212 2.5e-16
c9525 1706 210 2.5e-16
c9526 1710 205 2.8e-16
c9527 1709 206 2.14e-16
c9528 1708 207 2.13e-16
c9529 1711 204 2.5e-16
c9530 2426 202 2.339e-15
c9531 3 236 3.48e-16
c9532 0 93 1.14e-16
c9533 94 216 1.94e-16
c9534 84 217 1.9e-16
c9535 212 178 3.34e-16
c9536 775 194 7.23e-16
c9537 2296 2641 1.58e-16
c9538 1 739 1.6e-16
c9539 1 1249 1.6e-16
c9540 2379 2348 1.249e-15
c9541 2490 2433 1.58e-16
c9542 1641 241 2.54e-16
c9543 58 237 1.99e-16
c9544 2843 8 1.96e-16
c9545 0 571 2.623e-15
c9546 214 121 1.9e-16
c9547 1 2185 1.6e-16
c9548 2343 2543 1.96e-16
c9549 2294 2587 1.022e-15
c9550 2649 2630 1.96e-16
c9551 1 572 1.6e-16
c9552 0 2022 2.623e-15
c9553 2645 2409 3.54e-16
c9554 2312 2490 1.58e-16
c9555 2305 2572 1.58e-16
c9556 2299 2484 1.96e-16
c9557 1 50 2.79e-16
c9558 0 898 2.957e-15
c9559 253 183 7.76e-16
c9560 255 181 7.23e-16
c9561 2381 192 2.264e-15
c9562 2757 2769 1.58e-16
c9563 811 810 6.77e-16
c9564 548 209 8.32e-16
c9565 549 208 7.76e-16
c9566 0 1210 2.957e-15
c9567 850 221 2.5e-16
c9568 851 220 2.8e-16
c9569 1621 233 2.14e-16
c9570 2766 2746 1.15e-16
c9571 2625 236 8.84e-16
c9572 180 153 1.99e-16
c9573 0 535 2.957e-15
c9574 0 1028 2.585e-15
c9575 0 1473 2.623e-15
c9576 886 887 6.77e-16
c9577 1974 218 2.8e-16
c9578 0 528 2.957e-15
c9579 376 184 2.13e-16
c9580 377 185 2.54e-16
c9581 0 847 2.957e-15
c9582 0 1454 2.623e-15
c9583 2652 2634 3.575e-15
c9584 1 2526 1.947e-15
c9585 465 464 6.77e-16
c9586 1123 1122 6.77e-16
c9587 143 61 3.31e-16
c9588 2276 0 2.585e-15
c9589 0 840 2.957e-15
c9590 188 189 6.86e-16
c9591 1406 1407 6.77e-16
c9592 2299 2335 3.23e-16
c9593 1 350 1.6e-16
c9594 831 212 2.5e-16
c9595 0 1783 2.957e-15
c9596 1 681 1.6e-16
c9597 1455 204 2.5e-16
c9598 1198 1199 6.77e-16
c9599 1 1622 1.6e-16
c9600 2649 8 7.21e-16
c9601 2318 2590 1.96e-16
c9602 2409 208 7.35e-16
c9603 446 447 6.77e-16
c9604 0 1152 2.957e-15
c9605 1643 1642 6.77e-16
c9606 1 662 1.6e-16
c9607 0 2095 2.957e-15
c9608 1 993 1.6e-16
c9609 0 1914 2.957e-15
c9610 1950 197 2.8e-16
c9611 1949 198 2.14e-16
c9612 1948 199 2.13e-16
c9613 1951 196 2.5e-16
c9614 2699 2492 6.13e-16
c9615 2631 243 1.083e-15
c9616 222 464 7.77e-16
c9617 2655 2471 6.2e-16
c9618 1 974 1.6e-16
c9619 1930 195 7.23e-16
c9620 63 232 1.94e-16
c9621 2298 2517 1.96e-16
c9622 1877 232 7.76e-16
c9623 2299 2354 6.36e-16
c9624 314 219 7.23e-16
c9625 0 806 2.623e-15
c9626 758 759 6.77e-16
c9627 956 214 8.32e-16
c9628 1158 195 7.91e-16
c9629 1955 1954 6.77e-16
c9630 1 2755 5.384e-15
c9631 1577 208 7.91e-16
c9632 1268 1269 6.77e-16
c9633 2467 2459 6.67e-16
c9634 1 1731 1.6e-16
c9635 2294 0 6.8974e-14
c9636 644 192 2.13e-16
c9637 2318 2422 1.96e-16
c9638 2649 2425 2.67e-16
c9639 2471 2574 2.57e-16
c9640 0 1118 2.623e-15
c9641 2204 2205 6.77e-16
c9642 1096 225 7.77e-16
c9643 2529 2517 1.6e-16
c9644 2358 2420 1.96e-16
c9645 2023 242 7.23e-16
c9646 2022 243 7.91e-16
c9647 2407 2409 4.083e-15
c9648 2299 2552 4.02e-16
c9650 0 73 7.793e-14
c9651 1788 1789 6.77e-16
c9652 1417 193 2.54e-16
c9653 1416 192 2.13e-16
c9654 0 1875 2.623e-15
c9655 2214 210 2.8e-16
c9656 0 257 2.623e-15
c9657 1 1876 1.6e-16
c9658 221 178 3.34e-16
c9659 2384 2348 1.58e-16
c9660 232 105 1.94e-16
c9661 31 183 3.24e-16
c9662 1858 213 2.5e-16
c9663 1859 212 2.8e-16
c9664 2298 2305 1.479e-15
c9665 2296 2590 1.58e-16
c9666 0 584 2.957e-15
c9667 3 225 2.38e-16
c9668 235 126 1.99e-16
c9669 2761 2636 1.09e-16
c9670 720 223 2.13e-16
c9671 0 1527 2.957e-15
c9672 1547 194 7.91e-16
c9673 1550 188 7.91e-16
c9674 1548 190 8.32e-16
c9675 1 1083 1.6e-16
c9676 2100 2101 6.77e-16
c9677 0 159 1.82e-16
c9678 2140 231 2.13e-16
c9679 218 178 1.99e-16
c9680 209 174 3.31e-16
c9681 2643 2627 1.96e-16
c9682 2647 2625 1.96e-16
c9683 58 226 3.34e-16
c9684 90 207 1.94e-16
c9685 1 163 7.6e-16
c9686 1 2594 1.79e-16
c9687 760 185 7.77e-16
c9688 1 406 1.6e-16
c9689 1273 184 7.91e-16
c9690 0 1839 2.957e-15
c9691 203 174 3.34e-16
c9692 0 209 2.4546e-14
c9693 216 121 3.24e-16
c9694 100 181 1.99e-16
c9695 94 183 3.24e-16
c9696 90 202 3.34e-16
c9697 84 184 1.94e-16
c9698 247 187 2.5e-16
c9699 480 481 6.77e-16
c9700 0 1227 2.623e-15
c9701 1 718 1.6e-16
c9702 1 1228 1.6e-16
c9703 0 203 2.5224e-14
c9704 3 198 2.38e-16
c9705 1 1673 1.6e-16
c9706 58 204 1.99e-16
c9707 2760 8 1.75e-16
c9708 2709 2379 3.92e-16
c9709 2296 2422 2.06e-16
c9710 318 319 6.77e-16
c9711 709 225 2.14e-16
c9712 58 199 1.94e-16
c9713 48 190 1.9e-16
c9714 52 188 3.34e-16
c9715 1307 1306 6.77e-16
c9716 1 1985 1.6e-16
c9717 388 192 2.13e-16
c9718 1057 198 2.54e-16
c9719 8 134 1.96e-16
c9720 0 862 2.623e-15
c9721 232 142 3.24e-16
c9722 0 1469 2.926e-15
c9723 2827 2855 1.96e-16
c9724 2697 2848 1.01e-16
c9725 1817 200 7.91e-16
c9726 2243 2242 6.77e-16
c9727 2334 181 2.431e-15
c9728 2625 2607 1.34e-16
c9729 2825 0 2.0604e-14
c9730 80 85 1.34e-16
c9731 2697 2819 1.514e-15
c9732 839 226 7.23e-16
c9733 838 227 7.91e-16
c9734 0 1798 2.623e-15
c9735 1 1337 1.6e-16
c9736 80 0 2.3365e-14
c9737 0 674 2.957e-15
c9738 2751 2312 2.03e-16
c9739 2318 2364 6.04e-16
c9740 2665 2460 5.14e-16
c9741 2649 2645 7.84e-16
c9742 2654 2572 4.3e-16
c9743 223 333 7.76e-16
c9744 0 1169 2.623e-15
c9745 1028 193 8.32e-16
c9746 1029 192 7.76e-16
c9747 867 866 6.77e-16
c9748 1446 211 7.91e-16
c9749 0 2110 2.623e-15
c9750 27 233 3.31e-16
c9751 1602 213 2.5e-16
c9752 1603 212 2.8e-16
c9753 101 55 2.44e-16
c9754 0 492 2.585e-15
c9755 2509 219 1.083e-15
c9756 1 1932 1.6e-16
c9757 229 610 2.5e-16
c9758 228 611 2.8e-16
c9759 0 986 2.957e-15
c9760 1 136 7.6e-16
c9761 1942 203 7.91e-16
c9762 1381 241 2.14e-16
c9763 73 243 1.99e-16
c9764 1884 231 2.13e-16
c9765 20 181 3.34e-16
c9766 0 821 2.926e-15
c9767 2824 2841 1.69e-16
c9768 2840 2838 1.6e-16
c9769 700 701 6.77e-16
c9770 31 238 3.31e-16
c9771 1 1318 1.6e-16
c9772 2592 2512 6.52e-16
c9773 2087 211 2.5e-16
c9774 8 87 1.96e-16
c9775 1 2254 1.6e-16
c9776 2687 2409 3.83e-16
c9777 2634 2644 2.2e-16
c9778 427 426 6.77e-16
c9779 503 186 7.23e-16
c9780 0 1133 2.926e-15
c9781 42 219 1.99e-16
c9782 1250 228 7.23e-16
c9783 0 1561 2.623e-15
c9784 1921 182 2.54e-16
c9785 1923 180 2.8e-16
c9786 2651 2382 1.96e-16
c9787 1 2075 1.6e-16
c9788 2451 207 3.12e-16
c9789 2439 205 2.07e-16
c9790 240 163 3.24e-16
c9791 307 204 2.8e-16
c9792 305 206 2.54e-16
c9793 955 219 2.8e-16
c9794 1 457 1.6e-16
c9795 0 1888 2.957e-15
c9796 1012 1013 6.77e-16
c9797 1 1398 1.6e-16
c9798 236 100 1.99e-16
c9799 238 94 3.31e-16
c9800 239 84 3.24e-16
c9801 2543 2477 9.03e-16
c9802 801 198 2.54e-16
c9803 803 196 2.8e-16
c9804 2764 2776 1.003e-15
c9805 739 738 6.77e-16
c9806 1 769 1.6e-16
c9807 1249 1248 6.77e-16
c9808 1 1710 1.6e-16
c9809 497 496 6.77e-16
c9810 2779 143 7.74e-16
c9811 2296 2364 1.654e-15
c9812 628 184 2.13e-16
c9813 242 126 1.99e-16
c9814 213 79 1.99e-16
c9815 2637 2510 1.96e-16
c9816 2761 2630 1.96e-16
c9817 2343 2460 2.12e-16
c9818 583 226 7.23e-16
c9819 582 227 7.91e-16
c9820 224 225 2e-16
c9821 1518 236 7.91e-16
c9822 1516 238 8.32e-16
c9823 2185 2184 6.77e-16
c9824 2057 192 7.91e-16
c9825 2294 2543 1.96e-16
c9826 2643 2548 1.96e-16
c9827 2647 2545 1.96e-16
c9828 335 334 6.77e-16
c9829 0 913 2.623e-15
c9830 572 573 6.77e-16
c9831 69 187 3.34e-16
c9832 73 193 1.9e-16
c9833 63 188 3.34e-16
c9834 1769 1768 6.77e-16
c9835 0 1854 2.623e-15
c9836 2260 2261 6.77e-16
c9837 0 911 2.957e-15
c9838 2719 0 3.3247e-14
c9839 2709 2384 3.92e-16
c9840 2389 2318 8.49e-16
c9841 856 233 7.77e-16
c9842 1268 185 8.32e-16
c9843 1269 184 7.76e-16
c9844 50 52 3.92e-16
c9845 1686 203 7.91e-16
c9846 2158 237 2.8e-16
c9847 2157 238 2.14e-16
c9848 2156 239 2.13e-16
c9849 2159 236 2.5e-16
c9850 14 228 1.99e-16
c9851 2775 2758 4.49e-16
c9852 38 8 6.08e-16
c9853 0 548 2.585e-15
c9854 1750 1751 6.77e-16
c9855 0 1223 2.957e-15
c9856 2649 2407 1.58e-16
c9857 0 1666 2.957e-15
c9858 1531 186 7.91e-16
c9859 1534 180 7.91e-16
c9860 1532 182 8.32e-16
c9861 0 2161 2.623e-15
c9862 1 1062 1.6e-16
c9863 2081 2080 6.77e-16
c9864 197 153 1.99e-16
c9865 189 163 1.99e-16
c9866 187 168 1.99e-16
c9867 185 178 1.9e-16
c9868 2335 2322 1.58e-16
c9869 2572 233 5.06e-16
c9870 2547 224 2.264e-15
c9871 1 547 1.6e-16
c9872 240 136 1.94e-16
c9873 0 1484 2.585e-15
c9874 994 228 7.23e-16
c9875 0 1978 2.957e-15
c9876 1472 215 2.13e-16
c9877 20 236 3.34e-16
c9878 121 183 1.94e-16
c9879 105 188 3.34e-16
c9880 2849 0 3.51e-15
c9881 2675 2843 1.58e-16
c9882 143 76 3.31e-16
c9883 1 859 1.6e-16
c9884 194 132 3.34e-16
c9885 192 126 1.94e-16
c9886 0 691 2.623e-15
c9887 2587 0 2.6149e-14
c9888 2761 8 4.34e-16
c9889 1 23 2.79e-16
c9890 1 2131 1.6e-16
c9891 1 2667 2.88e-16
c9892 1 692 1.6e-16
c9893 2322 2354 1.96e-16
c9894 1611 226 7.91e-16
c9895 1957 209 2.14e-16
c9896 164 170 1.34e-16
c9897 0 1003 2.623e-15
c9898 1 2490 8.19e-16
c9899 232 473 7.91e-16
c9900 1121 230 2.54e-16
c9901 1328 207 2.13e-16
c9902 1330 205 2.5e-16
c9903 1 1004 1.6e-16
c9904 1599 212 2.5e-16
c9905 0 1927 2.957e-15
c9906 1801 192 7.91e-16
c9907 2572 2562 3.92e-16
c9908 2296 2389 2.256e-15
c9909 69 229 1.99e-16
c9910 1 1761 1.6e-16
c9911 2778 0 1.23e-16
c9912 0 638 2.623e-15
c9913 2665 2672 5.52e-16
c9914 2333 2651 1.96e-16
c9915 233 600 7.77e-16
c9916 1012 185 8.32e-16
c9917 1013 184 7.76e-16
c9918 31 227 1.99e-16
c9919 1902 237 2.8e-16
c9920 1901 238 2.14e-16
c9921 1900 239 2.13e-16
c9922 1903 236 2.5e-16
c9923 2236 215 2.13e-16
c9924 2312 2379 3.24e-16
c9925 2358 2377 1.96e-16
c9926 147 194 1.99e-16
c9927 142 188 1.99e-16
c9928 136 189 3.34e-16
c9929 2464 208 2.264e-15
c9930 224 453 7.76e-16
c9931 1101 222 2.14e-16
c9932 0 1410 2.957e-15
c9933 76 79 3.92e-16
c9934 0 1905 2.623e-15
c9935 350 351 6.77e-16
c9936 229 168 3.34e-16
c9937 231 178 3.24e-16
c9938 300 207 2.13e-16
c9939 298 210 2.5e-16
c9940 2812 15 2.15e-16
c9941 2787 2779 3.92e-16
c9942 2675 2649 1.96e-16
c9943 2697 2318 1.96e-16
c9944 234 90 3.34e-16
c9945 1 291 1.6e-16
c9946 681 680 6.77e-16
c9947 730 234 2.5e-16
c9948 731 235 2.8e-16
c9949 1142 186 2.8e-16
c9950 31 205 3.34e-16
c9951 1362 221 2.5e-16
c9952 1363 220 2.8e-16
c9953 2215 0 2.957e-15
c9954 2351 2350 1.96e-16
c9955 225 100 3.31e-16
c9956 227 94 1.99e-16
c9957 222 79 1.9e-16
c9958 1622 1623 6.77e-16
c9959 27 190 1.9e-16
c9960 31 200 1.94e-16
c9961 1 603 1.6e-16
c9962 0 1540 2.585e-15
c9963 1239 235 2.5e-16
c9964 1556 201 8.32e-16
c9965 1557 200 7.76e-16
c9966 0 2034 2.957e-15
c9967 0 597 2.926e-15
c9968 2616 239 3.12e-16
c9969 2604 237 2.07e-16
c9970 2351 2505 3.37e-16
c9971 2635 2508 1.96e-16
c9972 58 232 3.24e-16
c9973 2299 2526 1.96e-16
c9974 0 416 2.957e-15
c9975 662 663 6.77e-16
c9976 1859 1858 6.77e-16
c9977 0 1359 2.957e-15
c9978 0 174 7.8182e-14
c9979 993 992 6.77e-16
c9980 1701 209 2.14e-16
c9981 213 157 3.34e-16
c9982 238 121 1.9e-16
c9983 94 205 3.34e-16
c9984 84 206 3.31e-16
c9985 79 217 3.31e-16
c9986 274 189 2.5e-16
c9987 272 191 2.13e-16
c9988 0 85 1.82e-16
c9989 0 728 2.957e-15
c9990 2687 2649 3.54e-16
c9991 2709 2637 3.54e-16
c9992 2655 2318 1.53e-15
c9993 1 97 2.79e-16
c9994 865 230 2.54e-16
c9995 100 198 1.9e-16
c9996 94 200 1.94e-16
c9997 84 201 1.9e-16
c9998 2490 2434 1.238e-15
c9999 2665 2651 3.54e-16
c10000 569 217 2.54e-16
c10001 568 216 2.13e-16
c10002 0 1238 2.623e-15
c10003 974 975 6.77e-16
c10004 0 1683 2.623e-15
c10005 101 34 2.44e-16
c10006 0 44 1.82e-16
c10007 1 1505 1.6e-16
c10008 214 132 1.9e-16
c10009 215 126 3.24e-16
c10010 2318 2574 4.4e-16
c10011 2639 2490 1.58e-16
c10012 2649 2492 3.54e-16
c10013 2299 2485 1.196e-15
c10014 1 45 2.79e-16
c10015 553 552 6.77e-16
c10016 1 2566 1.947e-15
c10017 1002 242 2.5e-16
c10018 1003 243 2.8e-16
c10019 0 1995 2.623e-15
c10020 1481 224 7.91e-16
c10021 1 1996 1.6e-16
c10022 2625 2621 6.13e-16
c10023 8 150 1.96e-16
c10024 1 1817 1.6e-16
c10025 1494 1495 6.77e-16
c10026 2522 221 2.07e-16
c10027 235 342 7.91e-16
c10028 234 343 7.23e-16
c10029 845 222 2.14e-16
c10030 1208 217 7.77e-16
c10031 2004 2005 6.77e-16
c10032 1468 214 8.32e-16
c10033 2166 187 7.91e-16
c10034 2556 2557 1.149e-15
c10035 0 704 2.957e-15
c10036 20 225 1.9e-16
c10037 2266 234 2.5e-16
c10038 2267 235 2.8e-16
c10039 1731 1730 6.77e-16
c10040 2733 2746 1.489e-15
c10041 2732 2735 3.92e-16
c10042 2755 2740 3.31e-16
c10043 2657 0 1.65e-16
c10044 2358 2735 1.445e-15
c10045 2298 2420 1.58e-16
c10046 496 239 2.13e-16
c10047 538 202 2.5e-16
c10048 542 197 2.8e-16
c10049 541 198 2.14e-16
c10050 540 199 2.13e-16
c10051 543 196 2.5e-16
c10052 2113 215 7.91e-16
c10053 0 1016 2.957e-15
c10054 1 526 1.6e-16
c10055 42 230 3.31e-16
c10056 0 1942 2.623e-15
c10057 59 60 1.34e-16
c10058 2109 214 2.14e-16
c10059 0 341 2.926e-15
c10060 184 185 2e-16
c10061 214 147 3.31e-16
c10062 2655 2296 9.25e-16
c10063 683 211 2.8e-16
c10064 687 205 7.23e-16
c10065 685 207 7.76e-16
c10066 1 838 1.6e-16
c10067 2264 0 2.957e-15
c10068 20 198 3.31e-16
c10069 0 653 2.926e-15
c10070 2343 2651 1.176e-15
c10071 2312 2384 1.96e-16
c10072 1179 203 2.8e-16
c10073 1183 197 7.23e-16
c10074 1181 199 7.76e-16
c10075 1 1150 1.6e-16
c10076 1 1595 1.6e-16
c10077 2296 2574 1.58e-16
c10078 512 183 2.13e-16
c10079 2299 2594 4.02e-16
c10080 0 965 2.926e-15
c10081 1876 1877 6.77e-16
c10083 37 213 1.99e-16
c10084 1926 194 2.8e-16
c10085 1785 184 7.91e-16
c10086 243 174 3.34e-16
c10087 310 218 2.8e-16
c10088 809 209 2.54e-16
c10089 808 208 2.13e-16
c10090 1 2439 1.424e-15
c10091 241 90 3.31e-16
c10092 73 223 3.24e-16
c10093 0 1720 2.957e-15
c10094 2230 0 2.623e-15
c10095 1873 222 2.54e-16
c10096 2235 218 7.91e-16
c10097 2364 2360 1.96e-16
c10098 59 9 2.44e-16
c10099 2632 2520 1.08e-16
c10100 2773 80 6.44e-16
c10101 0 243 2.5253e-14
c10102 1092 224 2.13e-16
c10103 0 2051 2.623e-15
c10104 2518 2512 4.77e-16
c10105 2294 2460 1.96e-16
c10106 2643 2465 1.96e-16
c10107 2647 2462 1.96e-16
c10108 2645 2510 1.96e-16
c10109 0 433 2.623e-15
c10110 1 2052 1.6e-16
c10111 439 219 2.5e-16
c10112 939 210 7.91e-16
c10113 942 204 7.91e-16
c10114 940 206 8.32e-16
c10115 0 1374 2.623e-15
c10116 69 210 3.34e-16
c10117 1083 1082 6.77e-16
c10118 1910 187 7.91e-16
c10119 2010 234 2.5e-16
c10120 2011 235 2.8e-16
c10121 2318 2567 1.96e-16
c10122 222 157 3.31e-16
c10123 287 196 2.5e-16
c10124 284 199 2.13e-16
c10125 285 198 2.14e-16
c10126 286 197 2.8e-16
c10127 2384 2355 1.31e-16
c10128 0 924 2.585e-15
c10129 0 745 2.623e-15
c10130 2790 2759 4.56e-16
c10131 2788 2798 1.96e-16
c10132 241 360 7.77e-16
c10133 872 240 2.13e-16
c10134 1342 213 2.8e-16
c10135 0 1686 2.623e-15
c10136 1 1259 1.6e-16
c10137 1853 214 2.14e-16
c10138 2208 198 7.77e-16
c10139 2209 199 7.91e-16
c10140 2210 196 7.23e-16
c10141 2211 197 7.91e-16
c10142 266 195 7.23e-16
c10143 1158 1159 6.77e-16
c10144 2709 8 1.96e-16
c10145 2800 2781 1.96e-16
c10146 2634 2358 4.44e-16
c10147 227 121 3.34e-16
c10148 224 115 1.94e-16
c10149 1 2195 1.6e-16
c10150 406 407 6.77e-16
c10151 1603 1602 6.77e-16
c10152 1 582 1.6e-16
c10153 1540 193 8.32e-16
c10154 1541 192 7.76e-16
c10155 0 2172 2.585e-15
c10156 2475 2488 4.77e-16
c10157 217 157 1.9e-16
c10158 2783 143 9.48e-16
c10159 210 168 1.99e-16
c10160 207 178 3.24e-16
c10161 2343 2585 1.96e-16
c10162 643 642 6.77e-16
c10163 0 1498 2.957e-15
c10164 0 2008 2.957e-15
c10165 202 178 1.99e-16
c10166 193 174 3.31e-16
c10167 1991 227 2.5e-16
c10168 409 200 7.91e-16
c10169 205 121 1.99e-16
c10170 90 191 1.94e-16
c10171 79 184 3.24e-16
c10172 1 379 1.6e-16
c10173 718 719 6.77e-16
c10174 1 889 1.6e-16
c10175 216 132 3.24e-16
c10176 121 200 3.24e-16
c10177 115 196 3.34e-16
c10178 1228 1229 6.77e-16
c10179 0 193 2.4594e-14
c10180 476 477 6.77e-16
c10181 1673 1672 6.77e-16
c10182 0 1645 2.926e-15
c10183 1 2688 2.88e-16
c10184 1 1201 1.6e-16
c10185 1762 228 7.23e-16
c10186 2409 2391 3.92e-16
c10187 58 188 1.99e-16
c10188 2543 0 2.3722e-14
c10189 1 2142 1.6e-16
c10190 1049 201 2.54e-16
c10191 1048 200 2.13e-16
c10192 1467 219 2.8e-16
c10193 982 234 2.8e-16
c10194 0 1957 2.926e-15
c10195 1614 221 2.8e-16
c10196 231 476 2.13e-16
c10197 788 789 6.77e-16
c10198 1334 219 7.91e-16
c10199 1985 1984 6.77e-16
c10200 1654 187 7.91e-16
c10201 101 109 3.02e-16
c10202 0 668 2.585e-15
c10203 679 211 2.5e-16
c10204 2747 2318 2.47e-16
c10205 2641 2305 1.58e-16
c10206 0 1162 2.957e-15
c10207 1 122 5.29e-16
c10208 240 616 2.13e-16
c10209 2106 219 7.23e-16
c10210 164 50 4.85e-16
c10211 2665 2503 3.92e-16
c10212 0 487 2.957e-15
c10213 522 194 2.5e-16
c10214 526 189 2.8e-16
c10215 525 190 2.14e-16
c10216 524 191 2.13e-16
c10217 527 188 2.5e-16
c10218 147 216 1.94e-16
c10219 0 980 2.585e-15
c10220 605 230 2.14e-16
c10221 0 1425 2.623e-15
c10222 37 222 1.9e-16
c10223 1100 1101 6.77e-16
c10224 143 55 3.31e-16
c10225 1545 1544 6.77e-16
c10226 820 216 2.13e-16
c10228 0 1309 2.926e-15
c10229 1 321 1.6e-16
c10230 1368 233 7.77e-16
c10231 0 1737 2.623e-15
c10232 1780 185 8.32e-16
c10233 1781 184 7.76e-16
c10234 1337 1336 6.77e-16
c10235 1257 241 2.54e-16
c10236 2245 0 2.926e-15
c10237 2508 2483 1.09e-16
c10238 0 792 2.957e-15
c10239 233 84 1.9e-16
c10240 735 229 7.23e-16
c10241 734 228 7.91e-16
c10242 1152 182 7.77e-16
c10243 1153 183 7.91e-16
c10244 1154 180 7.23e-16
c10245 1155 181 7.91e-16
c10246 42 209 1.9e-16
c10247 37 217 3.31e-16
c10248 0 1554 2.957e-15
c10249 0 2064 2.957e-15
c10250 1 31 7.6e-16
c10251 2628 239 2.186e-15
c10252 0 1104 2.957e-15
c10253 42 203 1.99e-16
c10254 1 614 1.6e-16
c10255 0 1389 2.926e-15
c10256 0 2047 2.957e-15
c10257 1 945 1.6e-16
c10258 1506 228 7.23e-16
c10259 2386 2390 1.154e-15
c10260 2019 229 7.91e-16
c10261 0 429 2.926e-15
c10262 239 79 1.94e-16
c10263 1 1886 1.6e-16
c10264 2582 230 3.99e-16
c10265 1091 213 7.91e-16
c10266 1 268 1.6e-16
c10267 0 1701 2.926e-15
c10268 1932 1933 6.77e-16
c10269 1 1371 1.6e-16
c10270 1860 225 8.32e-16
c10271 278 203 7.91e-16
c10272 0 96 1.82e-16
c10273 0 741 2.926e-15
c10274 2709 2645 3.54e-16
c10275 1 94 7.6e-16
c10276 3 4 9.76e-16
c10277 2379 2346 3.88e-16
c10278 2724 0 1.65e-16
c10279 213 111 1.99e-16
c10280 2343 2503 2.82e-16
c10281 2312 2630 1.96e-16
c10282 2299 2490 2.79e-16
c10283 1 2379 1.416e-15
c10284 80 42 1.59e-16
c10285 0 1515 2.623e-15
c10286 73 182 3.31e-16
c10287 0 2025 2.623e-15
c10288 1850 219 7.23e-16
c10289 1 1516 1.6e-16
c10290 2351 2627 9.69e-16
c10291 2635 2632 1.96e-16
c10292 1999 221 7.23e-16
c10293 1998 220 7.91e-16
c10294 2590 2522 4.69e-16
c10295 259 180 2.8e-16
c10296 257 182 2.54e-16
c10297 919 203 2.5e-16
c10298 1 2589 7.03e-16
c10299 852 232 2.13e-16
c10300 1484 223 2.13e-16
c10301 0 1827 2.623e-15
c10302 1318 1319 6.77e-16
c10303 2590 2517 4.22e-16
c10304 2192 190 7.77e-16
c10305 2193 191 7.91e-16
c10306 2194 188 7.23e-16
c10307 2195 189 7.91e-16
c10308 1 1828 1.6e-16
c10309 2272 230 7.77e-16
c10310 387 386 6.77e-16
c10311 0 1660 2.585e-15
c10312 2254 2255 6.77e-16
c10313 897 896 6.77e-16
c10314 1524 185 8.32e-16
c10315 1525 184 7.76e-16
c10316 0 2154 2.957e-15
c10317 1624 232 2.13e-16
c10318 2271 229 7.23e-16
c10319 2270 228 7.91e-16
c10320 2298 2377 1.58e-16
c10321 184 157 1.94e-16
c10322 0 536 2.957e-15
c10323 705 214 2.54e-16
c10324 243 487 2.5e-16
c10325 0 1479 2.957e-15
c10326 1 1035 1.6e-16
c10327 0 1972 2.585e-15
c10328 122 71 8.48e-16
c10329 1976 217 7.77e-16
c10330 0 848 2.957e-15
c10331 2654 2841 7.71e-16
c10332 2075 2074 6.77e-16
c10333 1193 208 7.91e-16
c10334 12 0 1.51e-16
c10335 1209 1208 6.77e-16
c10336 183 132 1.94e-16
c10337 181 126 3.34e-16
c10338 2773 0 1.5262e-14
c10339 457 456 6.77e-16
c10340 1 2283 1.6e-16
c10341 835 213 7.91e-16
c10342 0 1179 2.623e-15
c10343 31 240 1.94e-16
c10344 1 1180 1.6e-16
c10345 2150 2151 6.77e-16
c10346 2409 2342 1.58e-16
c10347 1604 225 8.32e-16
c10348 1 1625 1.6e-16
c10349 38 47 6.55e-16
c10350 1398 1399 6.77e-16
c10351 2312 8 4.17e-16
c10352 2647 2635 5.88e-16
c10353 2643 2351 1.372e-15
c10354 2294 2651 1.176e-15
c10355 2305 2590 2.83e-16
c10356 2492 216 7.35e-16
c10357 0 502 2.623e-15
c10358 241 612 8.32e-16
c10359 532 533 6.77e-16
c10360 2510 2492 2.44e-16
c10362 769 768 6.77e-16
c10363 1377 230 2.54e-16
c10364 2508 2501 5.82e-16
c10365 0 314 2.957e-15
c10366 2097 206 2.54e-16
c10367 2099 204 2.8e-16
c10368 0 809 2.623e-15
c10369 240 94 1.94e-16
c10370 1710 1711 6.77e-16
c10371 742 242 2.8e-16
c10372 1163 194 7.91e-16
c10373 1166 188 7.91e-16
c10374 1164 190 8.32e-16
c10375 0 1733 2.926e-15
c10376 1253 241 2.14e-16
c10377 0 1571 2.623e-15
c10378 844 845 6.77e-16
c10379 1 1572 1.6e-16
c10380 0 626 2.957e-15
c10381 2305 2422 1.96e-16
c10382 2634 2572 1.58e-16
c10383 2312 2425 1.96e-16
c10384 2639 2379 1.96e-16
c10385 147 183 3.24e-16
c10386 0 1121 2.623e-15
c10387 2299 2566 1.96e-16
c10388 1947 1946 6.77e-16
c10389 1 467 1.6e-16
c10390 0 1404 2.585e-15
c10391 73 237 3.34e-16
c10392 0 2062 2.623e-15
c10393 2517 2527 1.38e-16
c10394 1514 242 2.5e-16
c10395 1515 243 2.8e-16
c10396 0 1898 2.957e-15
c10397 0 444 2.585e-15
c10398 228 153 1.99e-16
c10399 234 178 1.99e-16
c10400 293 209 2.14e-16
c10401 220 594 7.23e-16
c10402 0 938 2.957e-15
c10403 2654 2641 1.96e-16
c10404 1 779 1.6e-16
c10405 1357 222 2.14e-16
c10406 2014 228 7.91e-16
c10407 1 1289 1.6e-16
c10408 2216 209 7.77e-16
c10409 223 174 1.94e-16
c10410 0 263 2.957e-15
c10411 0 756 2.585e-15
c10412 789 201 2.14e-16
c10413 1780 1781 6.77e-16
c10414 2776 122 4.62e-16
c10415 2800 2804 2.924e-15
c10416 1300 200 2.13e-16
c10417 37 184 3.24e-16
c10418 31 189 3.34e-16
c10419 1 2384 7.39e-16
c10420 1 1270 1.6e-16
c10421 239 157 3.24e-16
c10422 222 111 1.9e-16
c10423 2154 243 7.23e-16
c10424 1 2206 1.6e-16
c10425 0 223 2.6014e-14
c10426 0 1085 2.926e-15
c10427 423 210 7.23e-16
c10428 164 136 3.31e-16
c10429 1 2608 1.947e-15
c10430 0 1528 2.957e-15
c10431 1 220 3.719e-15
c10432 2294 2585 1.96e-16
c10433 2635 2550 1.96e-16
c10434 2351 2548 1.96e-16
c10435 2358 2625 2.83e-16
c10436 48 224 3.24e-16
c10437 79 206 1.9e-16
c10438 1 409 1.6e-16
c10439 2092 2093 6.77e-16
c10440 0 1840 2.957e-15
c10441 2364 2517 2.39e-16
c10442 2411 199 3.12e-16
c10443 2397 197 2.07e-16
c10444 3 211 3.48e-16
c10445 0 116 1.82e-16
c10446 238 132 1.9e-16
c10447 236 126 3.34e-16
c10448 217 111 3.31e-16
c10449 94 189 3.34e-16
c10450 84 190 3.31e-16
c10451 79 201 3.31e-16
c10452 250 186 2.5e-16
c10453 2492 2445 1.31e-16
c10454 2281 241 2.54e-16
c10455 1 121 7.6e-16
c10456 1 721 1.6e-16
c10457 2187 195 2.8e-16
c10458 2191 189 7.23e-16
c10459 2189 191 7.76e-16
c10460 2460 0 2.0278e-14
c10461 143 34 3.31e-16
c10462 997 241 2.14e-16
c10463 48 196 1.99e-16
c10464 1062 1063 6.77e-16
c10465 2299 2439 6.36e-16
c10466 0 355 2.623e-15
c10467 310 311 6.77e-16
c10468 0 865 2.623e-15
c10469 2537 226 4.83e-16
c10470 903 195 2.5e-16
c10471 1 356 1.6e-16
c10472 0 1806 2.623e-15
c10473 547 546 6.77e-16
c10474 2261 233 2.14e-16
c10475 2733 2643 1.58e-16
c10476 220 338 7.23e-16
c10477 1 2837 6.34e-16
c10478 1 702 1.6e-16
c10479 2235 2234 6.77e-16
c10480 1750 234 2.8e-16
c10481 0 2118 2.623e-15
c10482 2569 2557 1.6e-16
c10483 2318 2746 8.42e-16
c10484 2305 2364 4.059e-15
c10485 2312 2645 4.73e-16
c10486 0 517 2.926e-15
c10487 533 201 2.14e-16
c10488 147 238 3.31e-16
c10489 622 623 6.77e-16
c10490 1 2636 2.88e-16
c10491 1451 210 7.91e-16
c10492 1454 204 7.91e-16
c10493 1452 206 8.32e-16
c10494 1 1014 1.6e-16
c10495 122 52 1.58e-16
c10496 0 135 1.14e-16
c10497 1898 243 7.23e-16
c10498 0 829 2.926e-15
c10499 0 1436 2.585e-15
c10500 859 858 6.77e-16
c10501 970 227 7.23e-16
c10502 1947 202 7.91e-16
c10503 1384 240 2.13e-16
c10504 2550 2538 3.22e-16
c10505 0 331 2.623e-15
c10506 1 1771 1.6e-16
c10507 2320 2313 1.069e-15
c10508 2634 2298 8.6e-16
c10509 1 2262 1.6e-16
c10510 1 332 1.6e-16
c10511 0 1141 2.926e-15
c10512 1134 236 7.91e-16
c10513 1132 238 8.32e-16
c10514 0 1748 2.585e-15
c10515 37 239 1.94e-16
c10516 934 935 6.77e-16
c10517 0 1584 2.957e-15
c10518 1 1321 1.6e-16
c10519 2131 2130 6.77e-16
c10520 2090 210 2.5e-16
c10521 2094 205 2.8e-16
c10522 2093 206 2.14e-16
c10523 2092 207 2.13e-16
c10524 2095 204 2.5e-16
c10525 1379 1378 6.77e-16
c10526 2471 2627 4.18e-16
c10527 0 42 7.793e-14
c10528 1 2083 1.6e-16
c10529 692 693 6.77e-16
c10530 0 1567 2.957e-15
c10531 0 2077 2.926e-15
c10532 241 178 1.9e-16
c10533 0 955 2.623e-15
c10534 2617 240 3.8e-16
c10535 215 449 7.91e-16
c10536 1 956 1.6e-16
c10537 1 1401 1.6e-16
c10538 73 226 1.99e-16
c10539 1721 216 7.91e-16
c10540 2228 217 8.32e-16
c10541 2229 216 7.76e-16
c10542 0 278 2.623e-15
c10543 164 23 4.85e-16
c10544 2462 2429 7.14e-16
c10545 1 1718 1.6e-16
c10546 2764 13 1.467e-15
c10547 2719 2651 1.96e-16
c10548 2652 2635 5.88e-16
c10549 635 187 2.8e-16
c10550 639 181 7.23e-16
c10551 637 183 7.76e-16
c10552 240 121 3.24e-16
c10553 0 1282 2.957e-15
c10554 1691 1690 6.77e-16
c10555 1 2637 1.411e-15
c10556 1004 1005 6.77e-16
c10557 1 1713 1.6e-16
c10558 2637 2467 1.96e-16
c10559 2649 2508 1.96e-16
c10560 2641 2420 1.96e-16
c10561 2318 2505 2.5e-16
c10562 932 209 8.32e-16
c10563 933 208 7.76e-16
c10564 73 204 3.34e-16
c10565 1494 234 2.8e-16
c10566 2358 2545 1.96e-16
c10567 2294 2503 1.96e-16
c10568 2005 233 2.14e-16
c10569 0 919 2.957e-15
c10570 1524 1525 6.77e-16
c10571 575 213 7.23e-16
c10572 574 212 7.91e-16
c10573 240 356 2.13e-16
c10574 0 1347 2.623e-15
c10575 69 194 3.34e-16
c10576 73 199 3.24e-16
c10577 0 1857 2.623e-15
c10578 1 1348 1.6e-16
c10579 2407 2433 3.92e-16
c10580 262 194 2.8e-16
c10581 761 185 2.54e-16
c10582 2760 2762 4.53e-16
c10583 2759 2771 1.96e-16
c10584 2389 2305 1.725e-15
c10585 2471 2643 1.58e-16
c10586 1 2378 7.03e-16
c10587 1761 1760 6.77e-16
c10588 714 227 7.23e-16
c10589 1691 202 7.91e-16
c10590 1694 196 7.91e-16
c10591 1692 198 8.32e-16
c10592 1227 226 7.91e-16
c10593 0 2167 2.957e-15
c10594 2199 202 7.23e-16
c10595 2469 2478 1.6e-16
c10597 2758 2781 2.37e-16
c10598 206 157 3.31e-16
c10599 2135 234 7.23e-16
c10600 2134 235 7.91e-16
c10601 227 132 3.34e-16
c10602 225 126 1.9e-16
c10603 2312 2407 1.58e-16
c10604 1 555 1.6e-16
c10605 878 236 7.91e-16
c10606 0 1492 2.585e-15
c10607 1836 1837 6.77e-16
c10608 1215 212 2.5e-16
c10609 1 1065 1.6e-16
c10610 1629 231 7.76e-16
c10611 1834 210 2.5e-16
c10612 1838 205 2.8e-16
c10613 1837 206 2.14e-16
c10614 1836 207 2.13e-16
c10615 1839 204 2.5e-16
c10616 201 157 1.9e-16
c10617 194 168 1.99e-16
c10618 191 178 3.24e-16
c10619 182 174 1.9e-16
c10620 1 2006 1.6e-16
c10621 2630 2623 5.82e-16
c10622 0 368 2.957e-15
c10623 90 180 1.99e-16
c10624 122 63 1.58e-16
c10625 1769 241 2.54e-16
c10626 0 182 2.4398e-14
c10627 205 132 1.99e-16
c10628 121 189 1.99e-16
c10629 111 184 3.24e-16
c10630 115 187 1.99e-16
c10631 1 186 3.839e-15
c10632 1675 195 2.8e-16
c10633 1679 189 7.23e-16
c10634 1677 191 7.76e-16
c10635 0 2133 2.926e-15
c10636 200 132 3.24e-16
c10637 198 126 3.31e-16
c10638 14 213 1.99e-16
c10639 2766 2351 1.195e-15
c10640 2709 2708 6.9e-16
c10641 2574 239 7.64e-16
c10642 2296 2505 2.11e-16
c10643 0 1190 2.623e-15
c10644 1 2630 7.39e-16
c10645 0 1635 2.623e-15
c10646 42 243 1.99e-16
c10647 1961 208 7.91e-16
c10648 1043 1042 6.77e-16
c10649 1 1457 1.6e-16
c10650 2308 181 2.07e-16
c10651 291 290 6.77e-16
c10652 164 97 4.85e-16
c10653 227 147 1.99e-16
c10654 978 221 2.5e-16
c10655 979 220 2.8e-16
c10656 0 1323 2.623e-15
c10657 0 1928 2.957e-15
c10658 1 1324 1.6e-16
c10659 2491 213 4.83e-16
c10660 122 105 1.58e-16
c10661 2637 2639 5.88e-16
c10662 227 327 2.5e-16
c10663 1 2795 2.88e-16
c10664 2102 218 2.8e-16
c10665 2770 0 1.96e-16
c10666 0 641 2.623e-15
c10667 2250 227 7.23e-16
c10668 164 45 4.85e-16
c10669 2299 2379 1.73e-16
c10670 2471 2548 1.58e-16
c10671 517 193 2.14e-16
c10672 147 205 3.34e-16
c10673 2590 233 7.02e-16
c10674 603 602 6.77e-16
c10675 0 1582 2.623e-15
c10676 1438 196 7.91e-16
c10677 27 224 3.24e-16
c10678 2291 2290 6.77e-16
c10679 147 200 1.94e-16
c10680 1 478 1.6e-16
c10681 1104 223 2.13e-16
c10682 1431 203 2.5e-16
c10683 0 1911 2.957e-15
c10684 1364 232 2.13e-16
c10685 2625 2572 2.267e-15
c10686 0 293 2.926e-15
c10687 38 9 1.74e-16
c10688 15 21 1.34e-16
c10689 2574 2522 1.54e-16
c10690 2587 2512 2.24e-16
c10691 11 19 3.266e-15
c10692 2675 2312 1.96e-16
c10693 2654 2364 1.96e-16
c10694 2697 2305 1.96e-16
c10695 215 445 7.76e-16
c10696 0 1299 2.623e-15
c10697 233 79 3.31e-16
c10698 1 790 1.6e-16
c10699 1144 185 7.77e-16
c10700 37 206 1.9e-16
c10701 69 214 1.9e-16
c10702 1 1300 1.6e-16
c10703 2216 0 2.957e-15
c10704 2574 2517 4.05e-16
c10705 2032 239 2.13e-16
c10706 2034 237 2.5e-16
c10707 2651 0 6.9081e-14
c10708 0 605 2.926e-15
c10709 229 115 3.34e-16
c10710 673 672 6.77e-16
c10711 42 193 1.9e-16
c10712 37 201 3.31e-16
c10713 27 196 1.99e-16
c10714 1 8 1.5761e-14
c10715 1 1102 1.6e-16
c10716 1 1547 1.6e-16
c10717 2405 2392 4.77e-16
c10718 237 174 1.99e-16
c10719 2351 2465 1.96e-16
c10720 1614 1615 6.77e-16
c10721 1 2629 7.03e-16
c10722 1084 214 8.32e-16
c10723 0 1360 2.957e-15
c10724 1705 208 7.91e-16
c10725 52 220 3.34e-16
c10726 2423 199 2.186e-15
c10727 2590 2557 3.81e-16
c10728 0 237 2.3935e-14
c10729 214 168 3.31e-16
c10730 239 111 1.94e-16
c10731 100 211 3.34e-16
c10732 772 192 2.13e-16
c10733 2687 2312 3.54e-16
c10734 2655 2305 1.334e-15
c10735 0 1246 2.623e-15
c10736 1 92 2.79e-16
c10737 985 984 6.77e-16
c10738 0 2182 2.623e-15
c10739 2465 2397 4.06e-16
c10740 2490 2432 1.58e-16
c10741 2492 2433 3.68e-16
c10742 2048 183 2.13e-16
c10743 2050 181 2.5e-16
c10744 2639 2630 1.96e-16
c10745 1 2425 7.39e-16
c10746 1223 226 7.23e-16
c10747 1222 227 7.91e-16
c10748 0 2018 2.957e-15
c10749 8 2648 2.78e-16
c10750 2305 2574 5.91e-16
c10751 2647 2409 3.54e-16
c10752 2312 2492 3.54e-16
c10753 0 385 2.623e-15
c10754 1505 1504 6.77e-16
c10755 1 899 1.6e-16
c10756 1830 211 7.91e-16
c10757 1986 213 2.5e-16
c10758 1987 212 2.8e-16
c10759 2378 189 2.431e-15
c10760 0 366 2.623e-15
c10761 0 876 2.585e-15
c10762 2762 2761 1.39e-16
c10763 848 223 2.13e-16
c10764 0 1655 2.957e-15
c10765 1 1211 1.6e-16
c10766 0 2148 2.585e-15
c10767 1765 241 2.14e-16
c10768 2171 186 7.91e-16
c10769 2174 180 7.91e-16
c10770 2172 182 8.32e-16
c10771 14 222 1.9e-16
c10772 1996 1997 6.77e-16
c10773 0 1024 2.957e-15
c10774 1 534 1.6e-16
c10775 1817 1816 6.77e-16
c10776 0 1967 2.957e-15
c10777 34 37 3.92e-16
c10778 2585 0 2.519e-14
c10779 375 187 2.5e-16
c10780 1 529 1.6e-16
c10781 887 186 7.23e-16
c10782 0 1450 2.957e-15
c10783 2719 2833 3.09e-16
c10784 2654 2389 3.18e-16
c10785 0 1945 2.623e-15
c10786 1 846 1.6e-16
c10787 2512 0 6.764e-15
c10788 20 211 1.99e-16
c10789 14 217 3.31e-16
c10790 2272 0 2.957e-15
c10791 2351 2436 1.96e-16
c10792 2625 2556 2.74e-16
c10793 2504 212 1.206e-15
c10794 689 206 2.54e-16
c10795 691 204 2.8e-16
c10796 2687 2694 1.6e-16
c10797 2299 2384 1.059e-15
c10798 975 220 2.5e-16
c10799 828 214 8.32e-16
c10800 1 841 1.6e-16
c10801 1 1782 1.6e-16
c10802 2639 8 4.35e-16
c10803 2299 2608 1.96e-16
c10804 1185 198 2.54e-16
c10805 1187 196 2.8e-16
c10806 0 1597 2.926e-15
c10807 1 1153 1.6e-16
c10808 2298 2625 2.99e-16
c10809 1 2094 1.6e-16
c10810 2629 240 2.264e-15
c10812 1928 193 7.77e-16
c10813 8 71 1.96e-16
c10814 73 232 1.94e-16
c10815 1278 1279 6.77e-16
c10816 0 308 2.585e-15
c10817 312 217 7.77e-16
c10818 526 527 6.77e-16
c10819 0 802 2.957e-15
c10820 63 220 3.34e-16
c10821 1574 211 7.91e-16
c10822 2233 0 2.623e-15
c10823 0 620 2.585e-15
c10824 2641 2377 1.96e-16
c10825 2639 2425 1.96e-16
c10826 2637 2427 1.96e-16
c10827 0 1114 2.957e-15
c10828 1 2645 1.411e-15
c10829 1422 188 7.91e-16
c10830 1509 241 2.14e-16
c10831 2358 2462 3.54e-16
c10832 2645 2467 1.96e-16
c10833 2364 2420 1.96e-16
c10834 2021 240 7.76e-16
c10835 442 218 2.5e-16
c10836 0 439 2.957e-15
c10837 233 157 1.9e-16
c10838 0 932 2.585e-15
c10839 838 839 6.77e-16
c10840 0 1377 2.623e-15
c10841 1415 195 2.5e-16
c10842 69 216 3.24e-16
c10843 1915 186 7.91e-16
c10844 2598 2599 1.149e-15
c10845 226 174 3.34e-16
c10846 0 751 2.957e-15
c10847 2471 2766 1.96e-16
c10848 2788 2760 1.58e-16
c10849 0 1261 2.926e-15
c10850 1344 214 7.77e-16
c10851 0 1689 2.623e-15
c10852 1700 209 8.32e-16
c10853 2197 0 2.926e-15
c10854 1856 215 2.13e-16
c10855 2305 2304 1.96e-16
c10856 0 226 2.3912e-14
c10857 220 105 3.34e-16
c10858 719 220 2.5e-16
c10859 1083 219 2.8e-16
c10860 1 585 1.6e-16
c10861 1230 221 2.8e-16
c10862 1150 1151 6.77e-16
c10863 2042 187 7.23e-16
c10864 1 1526 1.6e-16
c10865 219 163 3.34e-16
c10866 216 168 1.94e-16
c10867 204 174 1.99e-16
c10868 2651 2543 1.96e-16
c10869 2649 2632 1.96e-16
c10870 2318 2627 2.83e-16
c10871 398 399 6.77e-16
c10872 418 197 2.5e-16
c10873 416 199 2.13e-16
c10874 0 1075 2.623e-15
c10875 1595 1594 6.77e-16
c10876 1 155 2.79e-16
c10877 2654 2697 1.58e-16
c10878 908 909 6.77e-16
c10879 199 174 1.94e-16
c10880 1995 226 7.91e-16
c10881 0 381 2.926e-15
c10882 210 115 1.99e-16
c10883 206 111 1.9e-16
c10884 90 197 1.99e-16
c10885 79 190 1.9e-16
c10886 1 1838 1.6e-16
c10887 0 204 2.5381e-14
c10888 245 185 2.14e-16
c10889 2335 2292 1.28e-16
c10890 1 208 3.792e-15
c10891 1646 236 7.91e-16
c10892 1644 238 8.32e-16
c10893 0 1670 2.623e-15
c10894 164 31 3.31e-16
c10895 111 201 3.31e-16
c10896 0 199 2.6007e-14
c10897 3 195 3.48e-16
c10898 2338 2320 1.58e-16
c10899 1 132 7.6e-16
c10900 1220 1221 6.77e-16
c10901 52 186 1.99e-16
c10902 48 187 3.34e-16
c10903 0 1982 2.623e-15
c10904 2503 0 2.0996e-14
c10905 1665 1664 6.77e-16
c10906 229 482 2.5e-16
c10907 228 483 2.8e-16
c10908 2827 2856 3.35e-16
c10909 2654 2655 1.96e-16
c10910 0 1467 2.623e-15
c10911 984 233 7.77e-16
c10912 1616 222 7.77e-16
c10913 1 1468 1.6e-16
c10914 2379 2322 3.99e-16
c10915 2592 2566 9.2e-16
c10916 2364 2444 1.96e-16
c10917 220 142 1.99e-16
c10918 164 94 3.31e-16
c10919 0 1334 2.623e-15
c10920 837 224 7.76e-16
c10921 0 1794 2.957e-15
c10922 1659 186 7.91e-16
c10923 1662 180 7.91e-16
c10924 1660 182 8.32e-16
c10925 2799 0 1.96e-16
c10926 2558 2552 4.77e-16
c10927 2407 2346 1.13e-16
c10928 101 107 1.34e-16
c10929 2639 2645 1.08e-15
c10930 2318 2643 2.438e-15
c10931 2654 2574 6.47e-16
c10932 2649 2647 7.84e-16
c10933 2389 2420 2.48e-16
c10934 1977 1976 6.77e-16
c10935 1 675 1.6e-16
c10936 0 1612 2.585e-15
c10937 1 2407 8.84e-16
c10938 1444 209 8.32e-16
c10939 1445 208 7.76e-16
c10940 37 233 3.31e-16
c10941 1746 221 2.5e-16
c10942 1747 220 2.8e-16
c10943 0 2106 2.957e-15
c10944 1600 215 2.13e-16
c10945 2255 220 2.5e-16
c10946 122 58 1.58e-16
c10947 2296 2627 3.7e-16
c10948 2298 2545 1.58e-16
c10949 0 488 2.957e-15
c10950 136 219 1.99e-16
c10951 2389 2557 1.96e-16
c10952 2507 216 2.264e-15
c10953 2467 2407 2.59e-16
c10954 231 608 2.13e-16
c10955 0 1431 2.957e-15
c10956 42 223 3.24e-16
c10957 1 147 7.6e-16
c10958 1 987 1.6e-16
c10959 2052 2053 6.77e-16
c10960 1940 201 8.32e-16
c10961 1941 200 7.76e-16
c10962 14 184 3.24e-16
c10963 0 819 2.623e-15
c10964 2634 2841 5.75e-16
c10965 2840 2837 6.21e-16
c10966 2826 2824 1.79e-16
c10967 1 820 1.6e-16
c10968 0 1743 2.957e-15
c10969 2085 209 2.14e-16
c10970 656 191 2.13e-16
c10971 658 189 2.5e-16
c10972 2634 2633 1.6e-16
c10973 500 184 2.13e-16
c10974 0 1131 2.623e-15
c10975 1249 230 2.54e-16
c10976 1390 236 7.91e-16
c10977 1388 238 8.32e-16
c10978 1 1132 1.6e-16
c10979 0 454 2.623e-15
c10980 953 217 2.54e-16
c10981 952 216 2.13e-16
c10982 8 52 2.3e-16
c10983 48 229 1.99e-16
c10984 1259 1258 6.77e-16
c10985 1 1889 1.6e-16
c10986 0 766 2.623e-15
c10987 507 506 6.77e-16
c10988 2787 2792 1.144e-15
c10989 2764 2759 1.151e-15
c10990 1 2421 7.03e-16
c10991 0 1276 2.585e-15
c10993 1353 225 2.54e-16
c10994 2195 2194 6.77e-16
c10995 283 202 7.91e-16
c10996 0 251 2.623e-15
c10997 2296 2643 2.85e-16
c10998 240 132 3.24e-16
c10999 2299 2630 4.87e-16
c11000 1924 1925 6.77e-16
c11001 581 224 7.76e-16
c11002 582 583 6.77e-16
c11003 1406 180 7.91e-16
c11004 1404 182 8.32e-16
c11005 2054 195 7.91e-16
c11006 0 578 2.957e-15
c11007 2318 2548 5.73e-16
c11008 2649 2550 1.96e-16
c11009 3 212 3.48e-16
c11010 69 183 1.94e-16
c11011 73 188 3.34e-16
c11012 63 186 1.99e-16
c11013 0 2031 2.957e-15
c11014 0 1850 2.957e-15
c11015 1490 221 2.5e-16
c11016 1491 220 2.8e-16
c11017 0 396 2.585e-15
c11018 922 202 2.5e-16
c11019 926 197 2.8e-16
c11020 925 198 2.14e-16
c11021 924 199 2.13e-16
c11022 927 196 2.5e-16
c11023 2759 2755 1.74e-16
c11024 2634 2641 3.91e-16
c11025 1 2675 5.83e-15
c11026 1 910 1.6e-16
c11027 1684 201 8.32e-16
c11028 1685 200 7.76e-16
c11029 0 2162 2.957e-15
c11030 2766 2758 1.58e-16
c11031 2639 2407 1.58e-16
c11032 1067 211 2.8e-16
c11033 1071 205 7.23e-16
c11034 1069 207 7.76e-16
c11035 1 1222 1.6e-16
c11036 1 1667 1.6e-16
c11037 190 157 3.31e-16
c11038 183 168 3.24e-16
c11039 180 178 3.34e-16
c11040 2130 220 7.23e-16
c11041 2384 2322 2.44e-16
c11042 379 378 6.77e-16
c11043 0 1037 2.926e-15
c11044 402 189 2.5e-16
c11045 400 191 2.13e-16
c11046 242 491 7.91e-16
c11047 240 147 1.94e-16
c11048 889 888 6.77e-16
c11049 0 1480 2.957e-15
c11050 993 230 2.54e-16
c11051 101 66 2.44e-16
c11052 14 239 1.94e-16
c11053 1 1979 1.6e-16
c11054 105 186 1.99e-16
c11055 2675 2845 6.03e-16
c11056 1 2687 4.764e-15
c11057 2285 0 2.926e-15
c11058 2572 2597 3.92e-16
c11059 189 132 1.99e-16
c11060 1409 1408 6.77e-16
c11061 694 218 2.8e-16
c11062 2299 8 1.058e-15
c11063 2733 2351 1.157e-15
c11064 2655 2420 1.96e-16
c11065 2687 2467 3.92e-16
c11066 1130 242 2.5e-16
c11067 1131 243 2.8e-16
c11068 1201 1200 6.77e-16
c11069 1609 224 7.91e-16
c11070 2740 8 1.61e-16
c11071 2364 2739 8.53e-16
c11072 2296 2548 1.58e-16
c11073 0 505 2.623e-15
c11074 1 2492 1.416e-15
c11075 234 471 7.23e-16
c11076 235 470 7.91e-16
c11077 2142 2143 6.77e-16
c11078 1596 214 8.32e-16
c11079 1 1926 1.6e-16
c11080 2574 2562 3.92e-16
c11081 2587 2552 8.91e-16
c11082 2849 2838 3.25e-16
c11083 164 121 3.31e-16
c11084 8 63 2.3e-16
c11085 0 1758 2.623e-15
c11086 2212 2213 6.77e-16
c11087 1736 225 7.77e-16
c11088 2771 0 6.257e-15
c11089 122 130 3.02e-16
c11090 624 239 2.13e-16
c11091 626 237 2.5e-16
c11092 0 634 2.957e-15
c11093 666 202 2.5e-16
c11094 670 197 2.8e-16
c11095 669 198 2.14e-16
c11096 668 199 2.13e-16
c11097 671 196 2.5e-16
c11098 2665 2667 1.6e-16
c11099 2299 2425 2.44e-16
c11100 1726 213 2.8e-16
c11101 2645 2427 1.96e-16
c11102 2665 2490 1.58e-16
c11103 2364 2377 1.96e-16
c11104 0 469 2.926e-15
c11105 2461 205 2.431e-15
c11106 142 186 3.34e-16
c11107 147 189 3.34e-16
c11108 232 597 7.76e-16
c11109 815 205 7.23e-16
c11110 813 207 7.76e-16
c11111 69 238 1.9e-16
c11112 2033 2032 6.77e-16
c11113 1 1411 1.6e-16
c11114 230 163 1.9e-16
c11115 232 174 3.24e-16
c11116 297 208 7.91e-16
c11117 0 781 2.926e-15
c11118 2784 2779 3.92e-16
c11119 2811 38 5.51e-16
c11120 2815 11 4.21e-16
c11121 2652 2649 6.02e-16
c11122 2675 2639 1.96e-16
c11123 1307 203 2.8e-16
c11124 1311 197 7.23e-16
c11125 1309 199 7.76e-16
c11126 728 232 2.13e-16
c11127 1360 223 2.13e-16
c11128 0 264 2.957e-15
c11129 2335 0 1.7914e-14
c11130 8 105 2.3e-16
c11131 793 200 7.91e-16
c11132 122 13 1.237e-15
c11133 233 111 3.31e-16
c11134 1356 1357 6.77e-16
c11135 224 84 1.94e-16
c11136 1 2214 1.6e-16
c11137 0 232 2.5772e-14
c11138 0 1093 2.926e-15
c11139 0 1700 2.585e-15
c11140 42 182 3.31e-16
c11141 37 190 1.9e-16
c11142 27 187 3.34e-16
c11143 0 1536 2.957e-15
c11144 1 235 3.708e-15
c11145 1236 233 8.32e-16
c11146 238 168 3.31e-16
c11147 0 595 2.623e-15
c11148 2651 2460 1.96e-16
c11149 3 221 6.13e-16
c11150 1 2035 1.6e-16
c11151 1 596 1.6e-16
c11152 1 417 1.6e-16
c11153 1399 186 7.23e-16
c11154 0 170 1.82e-16
c11155 1 1358 1.6e-16
c11156 58 220 1.99e-16
c11157 2418 201 3.61e-16
c11158 143 139 1.352e-15
c11159 213 153 1.99e-16
c11160 1 171 2.79e-16
c11161 2687 2639 4.26e-16
c11162 1 729 1.6e-16
c11163 100 195 3.34e-16
c11164 84 196 3.34e-16
c11165 3 218 6.13e-16
c11166 2338 2302 5.66e-16
c11167 2492 2434 2.26e-16
c11168 2340 2315 1.08e-16
c11169 2471 2351 3.54e-16
c11170 2634 2590 3.92e-16
c11171 567 219 2.5e-16
c11172 0 1234 2.957e-15
c11173 52 208 1.94e-16
c11174 48 210 3.34e-16
c11175 2706 0 1.65e-16
c11176 2639 2492 3.54e-16
c11177 2343 2490 1.73e-16
c11178 0 1052 2.585e-15
c11179 321 320 6.77e-16
c11180 1 2708 2.88e-16
c11181 1000 240 2.13e-16
c11182 1479 226 7.23e-16
c11183 1478 227 7.91e-16
c11184 2552 0 6.764e-15
c11185 1981 214 2.14e-16
c11186 394 195 7.23e-16
c11187 2625 2598 6.6e-16
c11188 8 142 3.47e-16
c11189 230 136 3.31e-16
c11190 0 871 2.957e-15
c11191 906 194 2.5e-16
c11192 910 189 2.8e-16
c11193 909 190 2.14e-16
c11194 908 191 2.13e-16
c11195 911 188 2.5e-16
c11196 2654 2842 1.96e-16
c11197 2719 2822 1.187e-15
c11198 2541 225 3.61e-16
c11199 2534 223 3.12e-16
c11200 2734 2732 9.16e-16
c11201 232 341 7.76e-16
c11202 989 230 2.14e-16
c11203 1054 1055 6.77e-16
c11204 0 1809 2.623e-15
c11205 2164 185 8.32e-16
c11206 2165 184 7.76e-16
c11207 2838 0 1.9945e-14
c11208 2264 232 2.13e-16
c11209 2766 2318 1.539e-15
c11210 1 2293 1.97e-16
c11211 1 705 1.6e-16
c11212 0 2121 2.623e-15
c11213 2557 2567 1.38e-16
c11214 2305 2746 1.861e-15
c11215 2364 2735 7.29e-16
c11216 2298 2462 1.58e-16
c11217 537 200 7.91e-16
c11218 2427 2407 3.51e-16
c11219 0 1444 2.585e-15
c11220 27 229 1.99e-16
c11221 1 1017 1.6e-16
c11222 0 1938 2.957e-15
c11223 59 48 2.17e-16
c11224 80 50 2.44e-16
c11225 14 206 1.9e-16
c11226 0 339 2.623e-15
c11227 1811 1810 6.77e-16
c11228 681 209 2.54e-16
c11229 680 208 2.13e-16
c11230 1 340 1.6e-16
c11231 0 1773 2.926e-15
c11232 2317 2302 4.77e-16
c11233 945 944 6.77e-16
c11234 1890 228 7.23e-16
c11235 20 195 1.99e-16
c11236 14 201 3.31e-16
c11237 0 651 2.623e-15
c11238 1 2265 1.6e-16
c11239 2649 2338 1.96e-16
c11240 212 323 2.8e-16
c11241 213 322 2.5e-16
c11242 1177 201 2.54e-16
c11243 1176 200 2.13e-16
c11244 42 237 3.34e-16
c11245 1 652 1.6e-16
c11246 1886 1887 6.77e-16
c11247 1595 219 2.8e-16
c11248 1110 234 2.8e-16
c11249 0 2085 2.926e-15
c11250 662 203 7.91e-16
c11251 2322 186 5.7e-16
c11252 268 269 6.77e-16
c11253 0 963 2.623e-15
c11254 2123 2122 6.77e-16
c11255 1 964 1.6e-16
c11256 1371 1370 6.77e-16
c11257 2364 2599 2.39e-16
c11258 0 303 2.957e-15
c11259 0 796 2.585e-15
c11260 807 211 2.5e-16
c11261 69 227 3.34e-16
c11262 2226 0 2.957e-15
c11263 0 281 2.623e-15
c11264 101 20 1.58e-16
c11265 2548 2480 3.95e-16
c11266 2545 2473 4.3e-16
c11267 1446 1447 6.77e-16
c11268 1 1721 1.6e-16
c11269 143 124 3.31e-16
c11270 2296 2766 1.96e-16
c11271 0 615 2.957e-15
c11272 641 182 2.54e-16
c11273 643 180 2.8e-16
c11274 0 1108 2.585e-15
c11275 1 242 3.839e-15
c11276 212 100 1.99e-16
c11277 2318 2465 2.1e-16
c11278 2312 2508 2.66e-16
c11279 2305 2505 1.96e-16
c11280 2647 2510 1.96e-16
c11281 437 217 2.14e-16
c11282 69 205 1.99e-16
c11283 63 208 1.94e-16
c11284 1496 233 7.77e-16
c11285 0 1865 2.623e-15
c11286 1908 185 8.32e-16
c11287 1909 184 7.76e-16
c11288 2008 232 2.13e-16
c11289 227 168 1.99e-16
c11290 222 153 1.9e-16
c11291 0 920 2.957e-15
c11292 69 200 3.24e-16
c11293 871 243 2.5e-16
c11294 1291 195 2.8e-16
c11295 1295 189 7.23e-16
c11296 1293 191 7.76e-16
c11297 0 1863 2.957e-15
c11298 1340 215 2.13e-16
c11299 1516 1517 6.77e-16
c11300 2611 2599 1.6e-16
c11301 264 193 7.77e-16
c11302 2379 2347 1.74e-16
c11303 2340 187 9.65e-16
c11304 8 129 1.96e-16
c11305 2760 2769 1.96e-16
c11306 2634 2364 3.54e-16
c11307 2299 2407 5.41e-16
c11309 0 2168 2.957e-15
c11310 1634 228 7.23e-16
c11311 2038 186 2.8e-16
c11312 0 557 2.926e-15
c11313 217 153 3.31e-16
c11314 205 168 3.34e-16
c11315 209 163 3.31e-16
c11316 2641 2625 1.96e-16
c11317 371 236 2.8e-16
c11318 369 238 2.54e-16
c11319 1219 213 7.91e-16
c11320 1 1499 1.6e-16
c11321 203 163 3.34e-16
c11322 200 168 1.94e-16
c11323 197 178 3.34e-16
c11324 188 174 1.99e-16
c11325 2635 2572 1.58e-16
c11326 1988 225 8.32e-16
c11327 1 2009 1.6e-16
c11328 406 203 7.91e-16
c11329 0 886 2.623e-15
c11330 208 105 1.94e-16
c11331 2546 222 1.114e-15
c11332 210 211 3.76e-16
c11333 1828 1829 6.77e-16
c11334 0 188 2.5381e-14
c11335 3 185 2.38e-16
c11336 211 126 1.99e-16
c11337 115 194 1.99e-16
c11338 111 190 1.9e-16
c11339 2822 0 1.2483e-14
c11340 164 8 2.708e-15
c11341 2655 2377 1.96e-16
c11342 2687 2427 9.05e-16
c11343 2460 204 8.84e-16
c11344 0 1198 2.623e-15
c11345 1 192 3.792e-15
c11346 1 2852 1.353e-15
c11347 0 1643 2.623e-15
c11348 1681 190 2.54e-16
c11349 1683 188 2.8e-16
c11350 1761 230 2.54e-16
c11351 2409 2390 3.92e-16
c11352 1 1644 1.6e-16
c11353 58 186 3.34e-16
c11354 20 212 3.34e-16
c11355 2296 2465 1.58e-16
c11356 2118 226 2.8e-16
c11357 2389 2599 1.96e-16
c11358 387 180 2.8e-16
c11359 385 182 2.54e-16
c11360 1047 203 2.5e-16
c11361 1465 217 2.54e-16
c11362 1464 216 2.13e-16
c11363 798 799 6.77e-16
c11364 980 232 2.13e-16
c11365 0 1955 2.623e-15
c11366 1612 223 2.13e-16
c11367 1 1956 1.6e-16
c11368 164 92 4.85e-16
c11369 1332 217 8.32e-16
c11370 1333 216 7.76e-16
c11371 0 1788 2.585e-15
c11372 1035 1034 6.77e-16
c11373 1652 185 8.32e-16
c11374 1653 184 7.76e-16
c11375 283 282 6.77e-16
c11376 101 104 1.34e-16
c11377 0 664 2.957e-15
c11378 677 209 2.14e-16
c11379 226 331 7.91e-16
c11380 615 243 2.5e-16
c11381 1024 182 7.77e-16
c11382 1025 183 7.91e-16
c11383 1026 180 7.23e-16
c11384 1027 181 7.91e-16
c11385 0 1607 2.957e-15
c11386 1 1163 1.6e-16
c11387 0 2100 2.585e-15
c11388 1741 222 2.14e-16
c11389 2104 217 7.77e-16
c11390 1110 1111 6.77e-16
c11391 0 647 2.957e-15
c11392 2296 2642 4.47e-16
c11393 0 151 1.14e-16
c11394 521 192 7.91e-16
c11395 142 208 3.24e-16
c11396 136 209 1.9e-16
c11397 1173 201 2.14e-16
c11398 0 976 2.957e-15
c11399 1 486 1.6e-16
c11400 42 226 1.99e-16
c11401 136 203 1.99e-16
c11402 0 318 2.623e-15
c11403 1 481 1.6e-16
c11404 2389 2634 9.95e-16
c11405 1 2461 7.03e-16
c11406 1434 202 2.5e-16
c11407 1437 198 2.14e-16
c11408 1436 199 2.13e-16
c11409 0 1307 2.623e-15
c11410 0 1912 2.957e-15
c11411 2283 2282 6.77e-16
c11412 1 1308 1.6e-16
c11413 2243 0 2.623e-15
c11414 15 19 8.95e-16
c11415 228 90 1.99e-16
c11416 1 2244 1.6e-16
c11417 1701 1700 6.77e-16
c11418 733 231 7.76e-16
c11419 1 793 1.6e-16
c11420 42 204 3.34e-16
c11421 27 210 3.34e-16
c11422 31 219 1.99e-16
c11423 1867 1866 6.77e-16
c11424 1180 1181 6.77e-16
c11425 1 1555 1.6e-16
c11426 3 231 3.08e-16
c11427 221 100 1.99e-16
c11428 1625 1624 6.77e-16
c11429 1 2065 1.6e-16
c11430 42 199 3.24e-16
c11431 0 1549 2.926e-15
c11432 1 1105 1.6e-16
c11433 2075 203 2.8e-16
c11434 2079 197 7.23e-16
c11435 2077 199 7.76e-16
c11436 1505 230 2.54e-16
c11437 8 58 3.47e-16
c11438 1 1388 1.6e-16
c11439 52 235 1.99e-16
c11440 2017 231 7.91e-16
c11441 1 2046 1.6e-16
c11442 0 427 2.623e-15
c11443 1 428 1.6e-16
c11444 1089 215 7.91e-16
c11445 0 98 1.14e-16
c11446 100 218 3.34e-16
c11447 94 219 1.99e-16
c11448 2340 2332 6.67e-16
c11449 277 200 7.76e-16
c11450 276 201 8.32e-16
c11451 2572 2469 1.58e-16
c11452 0 739 2.623e-15
c11453 2709 2647 3.54e-16
c11454 1 2391 1.999e-15
c11455 0 1249 2.623e-15
c11456 1287 195 2.5e-16
c11457 1 740 1.6e-16
c11458 0 2185 2.623e-15
c11459 1642 242 2.5e-16
c11460 1643 243 2.8e-16
c11461 2298 2635 1.58e-16
c11462 0 572 2.585e-15
c11463 2144 230 7.77e-16
c11464 214 115 3.31e-16
c11465 2641 2545 1.96e-16
c11466 2637 2592 1.96e-16
c11467 2299 2492 4.18e-16
c11469 59 27 2.17e-16
c11470 1 215 3.42e-15
c11471 1339 218 7.91e-16
c11472 1848 217 7.77e-16
c11473 2294 2490 1.58e-16
c11474 2358 2409 3.54e-16
c11475 0 391 2.957e-15
c11476 367 236 2.5e-16
c11477 364 239 2.13e-16
c11478 365 238 2.14e-16
c11479 366 237 2.8e-16
c11480 0 901 2.926e-15
c11481 917 201 2.14e-16
c11482 1497 1496 6.77e-16
c11483 14 233 3.31e-16
c11484 551 210 7.23e-16
c11485 0 1213 2.926e-15
c11486 0 1656 2.957e-15
c11487 1623 235 2.5e-16
c11488 20 221 3.34e-16
c11489 2269 231 7.76e-16
c11490 2627 239 3.57e-16
c11491 184 153 3.24e-16
c11492 1 2155 1.6e-16
c11493 1572 1573 6.77e-16
c11494 241 484 8.32e-16
c11495 1 537 1.6e-16
c11496 0 1968 2.957e-15
c11497 1 1478 1.6e-16
c11498 383 180 2.5e-16
c11499 380 183 2.13e-16
c11500 381 182 2.14e-16
c11501 382 181 2.8e-16
c11502 378 186 2.5e-16
c11503 301 300 6.77e-16
c11504 2697 2634 1.876e-15
c11505 2827 2841 1.96e-16
c11506 467 466 6.77e-16
c11507 143 66 3.31e-16
c11508 1 849 1.6e-16
c11509 20 218 1.99e-16
c11510 0 350 2.623e-15
c11511 7 0 2.46e-16
c11512 2764 0 3.5456e-14
c11513 129 132 3.92e-16
c11514 2861 2842 1.96e-16
c11515 0 681 2.623e-15
c11516 1 9 2.73e-16
c11517 833 215 7.91e-16
c11518 0 1622 2.623e-15
c11519 1125 241 2.14e-16
c11520 0 662 2.623e-15
c11521 2318 2351 1.133e-15
c11522 0 498 2.957e-15
c11523 164 155 4.85e-16
c11524 0 993 2.623e-15
c11525 779 778 6.77e-16
c11526 0 1917 2.926e-15
c11527 1289 1288 6.77e-16
c11528 0 974 2.623e-15
c11529 220 466 7.23e-16
c11530 2655 2634 5.11e-16
c11531 960 214 7.77e-16
c11532 63 235 1.99e-16
c11533 1878 234 2.8e-16
c11534 164 132 3.31e-16
c11535 959 213 7.23e-16
c11536 958 212 7.91e-16
c11537 1 315 1.6e-16
c11538 740 240 2.13e-16
c11539 0 1731 2.623e-15
c11540 1 2762 3.53e-16
c11541 1579 210 7.91e-16
c11542 1582 204 7.91e-16
c11543 1580 206 8.32e-16
c11544 1270 1271 6.77e-16
c11545 2239 0 2.957e-15
c11546 80 23 2.44e-16
c11547 2585 2512 1.58e-16
c11548 1 1732 1.6e-16
c11549 646 194 2.8e-16
c11550 2634 2574 6.66e-16
c11551 2343 2379 5.64e-16
c11552 1 627 1.6e-16
c11553 2206 2207 6.77e-16
c11554 1098 227 7.23e-16
c11555 0 2058 2.957e-15
c11556 1512 240 2.13e-16
c11557 52 242 1.99e-16
c11558 2298 2469 1.96e-16
c11559 0 440 2.957e-15
c11560 2407 2322 7.51e-16
c11561 1 1899 1.6e-16
c11562 222 593 2.54e-16
c11563 751 237 7.23e-16
c11564 749 239 7.76e-16
c11565 0 1383 2.957e-15
c11566 1418 194 2.5e-16
c11567 1420 191 2.13e-16
c11568 1790 1791 6.77e-16
c11569 1262 236 7.91e-16
c11570 1260 238 8.32e-16
c11571 1 939 1.6e-16
c11572 1501 230 2.14e-16
c11573 0 1876 2.585e-15
c11574 1 69 7.6e-16
c11575 2013 231 7.76e-16
c11576 2299 2293 4.02e-16
c11577 0 752 2.957e-15
c11578 235 105 1.99e-16
c11579 224 79 3.24e-16
c11580 1 262 1.6e-16
c11581 0 1695 2.957e-15
c11582 1552 190 7.77e-16
c11583 1553 191 7.91e-16
c11584 1554 188 7.23e-16
c11585 1555 189 7.91e-16
c11586 178 176 3.92e-16
c11587 1161 1160 6.77e-16
c11588 2296 2351 1.101e-15
c11589 239 153 1.94e-16
c11590 2153 241 2.54e-16
c11591 409 408 6.77e-16
c11592 420 208 2.13e-16
c11593 723 221 7.91e-16
c11594 0 1083 2.623e-15
c11595 164 147 3.31e-16
c11596 1232 222 7.77e-16
c11597 1 1084 1.6e-16
c11598 2102 2103 6.77e-16
c11599 0 163 7.8194e-14
c11600 1 1529 1.6e-16
c11601 2594 0 6.764e-15
c11602 2312 2632 1.96e-16
c11603 2651 2503 1.96e-16
c11604 2305 2627 2.83e-16
c11605 8 2592 4.84e-16
c11606 2364 2625 2.83e-16
c11607 0 406 2.623e-15
c11608 143 144 1.34e-16
c11609 1 168 7.6e-16
c11610 484 485 6.77e-16
c11611 763 187 2.8e-16
c11612 767 181 7.23e-16
c11613 765 183 7.76e-16
c11614 1275 186 7.91e-16
c11615 1278 180 7.91e-16
c11616 1276 182 8.32e-16
c11617 2342 2346 1.154e-15
c11618 3 207 3.08e-16
c11619 121 219 3.34e-16
c11620 216 115 1.94e-16
c11621 100 185 3.31e-16
c11622 84 187 1.99e-16
c11623 79 196 1.99e-16
c11624 1 1841 1.6e-16
c11625 249 184 7.91e-16
c11626 0 718 2.623e-15
c11627 1 2342 1.79e-16
c11628 0 1228 2.585e-15
c11629 1 108 2.79e-16
c11630 721 720 6.77e-16
c11631 0 1673 2.623e-15
c11632 2185 193 2.54e-16
c11633 2184 192 2.13e-16
c11634 3 202 6.13e-16
c11635 58 208 3.24e-16
c11636 2340 2320 2.59e-16
c11637 711 227 2.5e-16
c11638 0 1047 2.957e-15
c11639 1 2508 7.39e-16
c11640 52 192 1.94e-16
c11641 48 194 3.34e-16
c11642 0 1985 2.623e-15
c11643 2389 2386 1.96e-16
c11644 390 194 2.8e-16
c11645 235 142 3.34e-16
c11646 901 193 2.14e-16
c11647 2652 2709 1.58e-16
c11648 2697 2859 5.57e-16
c11649 0 1802 2.957e-15
c11650 1819 202 7.91e-16
c11651 1822 196 7.91e-16
c11652 1820 198 8.32e-16
c11653 101 99 6.74e-16
c11654 2733 2318 2.195e-15
c11655 222 337 2.54e-16
c11656 0 1337 2.623e-15
c11657 1815 203 2.5e-16
c11658 0 2114 2.957e-15
c11659 1748 232 2.13e-16
c11660 1966 205 2.8e-16
c11661 1965 206 2.14e-16
c11662 1964 207 2.13e-16
c11663 1967 204 2.5e-16
c11664 143 100 3.26e-16
c11665 0 677 2.926e-15
c11666 2647 2312 8.92e-16
c11667 2643 2305 6.53e-16
c11668 221 334 2.8e-16
c11669 356 357 6.77e-16
c11670 1553 1552 6.77e-16
c11671 1031 194 7.23e-16
c11672 1 516 1.6e-16
c11673 0 1439 2.957e-15
c11674 1 1174 1.6e-16
c11675 42 232 1.94e-16
c11676 31 230 3.31e-16
c11677 0 1932 2.585e-15
c11678 80 45 2.44e-16
c11679 0 136 7.793e-14
c11680 0 989 2.926e-15
c11681 2820 2856 2.95e-16
c11682 1 2507 7.03e-16
c11683 0 1432 2.957e-15
c11684 969 225 2.54e-16
c11685 1 828 1.6e-16
c11686 1383 243 2.5e-16
c11687 69 240 3.24e-16
c11688 63 242 1.99e-16
c11689 2306 2293 1.6e-16
c11690 20 185 1.9e-16
c11691 14 190 1.9e-16
c11692 2545 2515 3.88e-16
c11693 2543 2526 1.58e-16
c11694 2625 2554 1.34e-16
c11695 826 219 7.23e-16
c11696 0 1318 2.623e-15
c11697 2044 2045 6.77e-16
c11698 702 703 6.77e-16
c11699 0 1744 2.957e-15
c11700 2254 0 2.623e-15
c11701 2548 2517 2.31e-16
c11702 2545 2527 4.07e-16
c11703 2089 208 7.91e-16
c11704 1 1585 1.6e-16
c11705 2240 214 7.77e-16
c11706 231 100 1.94e-16
c11707 230 94 3.31e-16
c11708 229 84 3.34e-16
c11709 2389 2625 4.18e-16
c11710 1156 192 2.13e-16
c11711 0 2075 2.623e-15
c11712 1 1566 1.6e-16
c11713 0 457 2.623e-15
c11714 1 2076 1.6e-16
c11715 240 168 1.94e-16
c11716 243 163 3.34e-16
c11717 0 1398 2.623e-15
c11718 1014 1015 6.77e-16
c11719 1718 219 7.91e-16
c11720 0 274 2.957e-15
c11721 2586 228 1.206e-15
c11722 2460 2448 2.32e-16
c11723 2427 2419 6.67e-16
c11724 2510 2429 3.94e-16
c11725 0 769 2.623e-15
c11726 633 185 2.54e-16
c11727 632 184 2.13e-16
c11728 242 105 1.99e-16
c11729 0 1710 2.623e-15
c11730 1 1283 1.6e-16
c11731 1251 1250 6.77e-16
c11732 143 20 3.26e-16
c11733 630 186 2.8e-16
c11734 2639 2508 1.96e-16
c11735 2641 2462 1.96e-16
c11736 2187 2186 6.77e-16
c11737 2031 237 7.23e-16
c11738 2029 239 7.76e-16
c11739 2059 194 7.91e-16
c11740 2062 188 7.91e-16
c11741 2060 190 8.32e-16
c11742 1492 232 2.13e-16
c11743 2305 2548 1.96e-16
c11744 2645 2592 1.96e-16
c11745 2364 2545 1.96e-16
c11746 2312 2550 2e-16
c11747 224 157 1.94e-16
c11748 573 215 7.76e-16
c11749 574 575 6.77e-16
c11750 69 189 1.99e-16
c11751 63 192 1.94e-16
c11752 1771 1770 6.77e-16
c11753 1 918 1.6e-16
c11754 52 215 3.24e-16
c11755 48 214 1.9e-16
c11756 2262 2263 6.77e-16
c11757 332 333 6.77e-16
c11758 2160 239 2.13e-16
c11759 2162 237 2.5e-16
c11760 2600 2594 4.77e-16
c11761 2407 2432 3.92e-16
c11762 759 187 2.5e-16
c11763 2760 2732 1.284e-15
c11764 2471 2318 3.54e-16
c11765 2709 2338 3.92e-16
c11766 2665 2637 4.24e-16
c11767 2335 182 1.7e-16
c11768 858 235 7.23e-16
c11769 1271 186 7.23e-16
c11770 713 225 2.54e-16
c11771 1225 224 7.91e-16
c11772 1536 182 7.77e-16
c11773 1537 183 7.91e-16
c11774 1538 180 7.23e-16
c11775 1539 181 7.91e-16
c11776 2196 200 2.13e-16
c11777 20 231 3.24e-16
c11778 206 153 1.9e-16
c11779 2769 2786 1.09e-16
c11780 560 207 2.13e-16
c11781 562 205 2.5e-16
c11782 2133 232 7.76e-16
c11783 1 2166 1.6e-16
c11784 0 1062 2.623e-15
c11785 1073 206 2.54e-16
c11786 1075 204 2.8e-16
c11787 0 1488 2.957e-15
c11788 1212 214 8.32e-16
c11789 2083 2082 6.77e-16
c11790 201 153 3.31e-16
c11791 196 157 3.34e-16
c11792 1833 208 7.91e-16
c11793 189 168 3.34e-16
c11794 193 163 3.31e-16
c11795 0 547 2.623e-15
c11796 2550 227 9.65e-16
c11797 242 142 3.34e-16
c11798 243 136 1.99e-16
c11799 2549 226 2.339e-15
c11800 1 369 1.6e-16
c11801 122 73 1.58e-16
c11802 1475 213 7.91e-16
c11803 2286 236 7.91e-16
c11804 2284 238 8.32e-16
c11805 115 183 3.24e-16
c11806 105 192 1.94e-16
c11807 0 859 2.623e-15
c11808 2709 2712 1.6e-16
c11809 1 2855 9.02e-16
c11810 1 181 3.749e-15
c11811 1 860 1.6e-16
c11812 1673 193 2.54e-16
c11813 1672 192 2.13e-16
c11815 0 2131 2.623e-15
c11816 195 126 1.99e-16
c11817 0 692 2.585e-15
c11818 1 2132 1.6e-16
c11819 0 1186 2.957e-15
c11820 1 2671 2.88e-16
c11821 956 957 6.77e-16
c11822 2153 2152 6.77e-16
c11823 1958 211 7.91e-16
c11824 1401 1400 6.77e-16
c11825 2490 0 3.2592e-14
c11826 0 511 2.957e-15
c11827 0 1004 2.585e-15
c11828 2587 2566 1.58e-16
c11830 1122 229 2.5e-16
c11831 1123 228 2.8e-16
c11832 1718 1719 6.77e-16
c11833 976 223 2.13e-16
c11834 1601 215 7.91e-16
c11835 1803 194 7.91e-16
c11836 1806 188 7.91e-16
c11837 1804 190 8.32e-16
c11838 1893 241 2.14e-16
c11839 1 1929 1.6e-16
c11840 1476 1477 6.77e-16
c11841 2296 2471 1.305e-15
c11842 2637 2343 1.756e-15
c11843 225 324 8.32e-16
c11844 1 2788 2.84e-16
c11845 0 1761 2.623e-15
c11846 1799 195 2.5e-16
c11847 2249 225 2.54e-16
c11848 1713 1712 6.77e-16
c11849 2335 2651 1.96e-16
c11850 2389 2545 1.58e-16
c11851 235 602 7.23e-16
c11852 1015 186 7.23e-16
c11853 0 1578 2.957e-15
c11854 37 224 3.24e-16
c11855 1728 214 7.77e-16
c11856 2645 2382 1.96e-16
c11857 2294 2379 1.96e-16
c11858 2298 2409 9.6e-16
c11859 142 192 3.24e-16
c11860 136 193 1.9e-16
c11861 226 454 2.8e-16
c11862 817 206 2.54e-16
c11863 819 204 2.8e-16
c11864 1103 220 2.5e-16
c11865 0 1413 2.926e-15
c11866 1429 201 2.14e-16
c11867 2625 2574 3.17e-16
c11868 8 2604 3.6e-16
c11869 1 1910 1.6e-16
c11870 228 178 3.34e-16
c11871 0 291 2.623e-15
c11872 2787 19 4.46e-16
c11873 2764 2773 5.64e-16
c11874 2654 2643 1.96e-16
c11875 2652 2312 5.88e-16
c11876 1 292 1.6e-16
c11877 1313 198 2.54e-16
c11878 1315 196 2.8e-16
c11879 683 682 6.77e-16
c11880 31 209 1.9e-16
c11881 63 215 3.24e-16
c11882 0 603 2.623e-15
c11883 1 2217 1.6e-16
c11884 3 234 6.13e-16
c11885 230 121 1.9e-16
c11886 1140 184 2.13e-16
c11887 42 188 3.34e-16
c11888 37 196 1.99e-16
c11889 27 194 3.34e-16
c11890 31 203 1.99e-16
c11891 1 604 1.6e-16
c11892 1559 202 7.23e-16
c11893 0 2037 2.926e-15
c11894 1348 1349 6.77e-16
c11895 58 235 3.34e-16
c11896 224 580 2.13e-16
c11897 0 177 1.14e-16
c11898 995 994 6.77e-16
c11899 1702 211 7.91e-16
c11900 1 1361 1.6e-16
c11901 238 115 3.31e-16
c11902 100 207 1.94e-16
c11903 94 209 1.9e-16
c11904 84 210 1.99e-16
c11905 1 2392 1.79e-16
c11906 0 1242 2.957e-15
c11907 1 236 3.719e-15
c11908 866 229 2.5e-16
c11909 867 228 2.8e-16
c11910 0 2178 2.957e-15
c11911 100 202 3.34e-16
c11912 94 203 1.99e-16
c11913 2420 2406 2.32e-16
c11914 2492 2432 3.98e-16
c11915 2340 2302 1.58e-16
c11916 1637 241 2.14e-16
c11917 2469 2473 1.154e-15
c11918 2665 8 7.9e-16
c11919 0 567 2.957e-15
c11920 570 218 2.5e-16
c11921 215 105 3.24e-16
c11922 2343 2630 7.71e-16
c11923 1 2718 1.65e-16
c11924 59 29 2.44e-16
c11925 80 31 1.59e-16
c11926 0 1505 2.623e-15
c11927 1221 224 7.76e-16
c11928 48 216 3.24e-16
c11929 212 126 3.34e-16
c11930 2649 2572 1.58e-16
c11931 1 2019 1.6e-16
c11932 555 554 6.77e-16
c11933 0 1996 2.585e-15
c11934 0 1817 2.623e-15
c11935 1065 1064 6.77e-16
c11936 1828 209 8.32e-16
c11937 1829 208 7.76e-16
c11938 1984 215 2.13e-16
c11939 0 362 2.957e-15
c11940 313 312 6.77e-16
c11941 0 872 2.957e-15
c11942 1 2313 2.77e-15
c11943 847 220 2.5e-16
c11944 1211 219 2.8e-16
c11945 1471 213 7.23e-16
c11946 1470 212 7.91e-16
c11947 0 1815 2.957e-15
c11948 2006 2007 6.77e-16
c11949 0 2144 2.957e-15
c11950 1 1654 1.6e-16
c11951 1059 196 2.8e-16
c11952 0 2127 2.957e-15
c11953 1 1025 1.6e-16
c11954 2661 0 2.94e-16
c11955 2735 2746 1.028e-15
c11956 0 526 2.623e-15
c11957 1 1966 1.6e-16
c11958 373 185 2.14e-16
c11959 625 624 6.77e-16
c11960 1 2632 7.39e-16
c11961 884 184 2.13e-16
c11962 1774 236 7.91e-16
c11963 1772 238 8.32e-16
c11964 1 1451 1.6e-16
c11965 2111 212 2.5e-16
c11966 20 207 3.24e-16
c11967 2625 2555 2.74e-16
c11968 215 142 1.94e-16
c11969 0 838 2.623e-15
c11970 1 2273 1.6e-16
c11971 2687 2689 1.6e-16
c11972 972 222 8.32e-16
c11973 20 202 1.99e-16
c11974 2298 2302 1.96e-16
c11975 2627 2557 4.58e-16
c11976 2296 2819 1.96e-16
c11977 2343 8 5.04e-16
c11978 2645 2333 1.96e-16
c11979 2312 2338 4.79e-16
c11980 2294 2384 1.96e-16
c11981 2641 2635 5.88e-16
c11982 2655 2545 1.96e-16
c11983 0 1150 2.623e-15
c11984 0 1595 2.623e-15
c11985 937 936 6.77e-16
c11986 1112 233 7.77e-16
c11987 1 1596 1.6e-16
c11988 2322 192 7.35e-16
c11989 1878 1879 6.77e-16
c11990 27 214 1.9e-16
c11991 1787 186 7.91e-16
c11992 1790 180 7.91e-16
c11993 1788 182 8.32e-16
c11994 2543 2490 2.264e-15
c11995 2299 2342 4.02e-16
c11996 0 304 2.957e-15
c11997 260 261 6.77e-16
c11998 2510 2475 4.06e-16
c11999 1457 1456 6.77e-16
c12000 810 210 2.5e-16
c12001 1 803 1.6e-16
c12002 73 220 3.34e-16
c12003 1572 209 8.32e-16
c12004 1573 208 7.76e-16
c12005 1874 221 2.5e-16
c12006 1875 220 2.8e-16
c12007 2467 2455 3.22e-16
c12008 2465 2443 5.43e-16
c12009 2503 2484 7.03e-16
c12010 0 616 2.957e-15
c12011 2343 2425 1.96e-16
c12012 3 241 2.38e-16
c12013 2299 2508 3.83e-16
c12014 1 2647 1.819e-15
c12015 1 1115 1.6e-16
c12016 0 2052 2.585e-15
c12017 2364 2462 3.54e-16
c12018 2358 2510 1.96e-16
c12019 2643 2420 1.96e-16
c12020 2305 2465 2.75e-16
c12021 2647 2467 1.96e-16
c12022 1324 1325 6.77e-16
c12023 58 242 3.34e-16
c12024 441 216 7.91e-16
c12025 233 153 3.31e-16
c12026 0 928 2.957e-15
c12027 1 438 1.6e-16
c12028 0 67 1.14e-16
c12029 1413 193 2.14e-16
c12030 0 1871 2.957e-15
c12031 2386 2393 4.77e-16
c12032 1354 227 7.23e-16
c12033 223 163 1.94e-16
c12034 0 253 2.926e-15
c12035 784 191 2.13e-16
c12036 786 189 2.5e-16
c12037 243 362 7.23e-16
c12038 875 242 7.91e-16
c12039 0 1259 2.623e-15
c12040 1297 190 2.54e-16
c12041 1299 188 2.8e-16
c12042 1 750 1.6e-16
c12043 1 1260 1.6e-16
c12044 2195 0 2.623e-15
c12045 1855 212 2.5e-16
c12046 2599 2609 1.38e-16
c12047 2318 2314 1.96e-16
c12048 2854 8 2.44e-16
c12049 2665 2645 7.42e-16
c12050 2298 2649 1.58e-16
c12051 0 582 2.623e-15
c12052 224 111 3.24e-16
c12053 227 115 1.99e-16
c12054 1 2196 1.6e-16
c12055 716 222 8.32e-16
c12056 1081 217 2.54e-16
c12057 1080 216 2.13e-16
c12058 1228 223 2.13e-16
c12059 1543 194 7.23e-16
c12060 1 225 4.406e-15
c12061 2040 185 7.77e-16
c12062 221 126 3.34e-16
c12063 2639 2632 1.96e-16
c12064 2592 235 9.65e-16
c12065 2827 2697 1.756e-15
c12066 2823 2654 4.69e-16
c12067 0 1501 2.926e-15
c12068 2363 2348 4.77e-16
c12069 1993 224 7.91e-16
c12070 0 379 2.623e-15
c12071 412 198 8.32e-16
c12072 414 196 7.91e-16
c12073 411 202 7.91e-16
c12074 209 121 3.31e-16
c12075 205 115 3.34e-16
c12076 79 187 3.34e-16
c12077 0 889 2.623e-15
c12078 1 380 1.6e-16
c12079 1980 214 8.32e-16
c12080 1230 1231 6.77e-16
c12081 3 191 3.08e-16
c12082 0 127 1.82e-16
c12083 219 132 3.34e-16
c12084 121 203 3.34e-16
c12085 218 126 1.99e-16
c12086 115 200 1.94e-16
c12087 111 196 1.99e-16
c12088 478 479 6.77e-16
c12089 2759 8 2.36e-16
c12090 2709 2722 4.83e-16
c12091 0 1201 2.623e-15
c12092 1207 219 2.5e-16
c12093 1675 1674 6.77e-16
c12094 1 198 4.537e-15
c12095 1 2692 2.88e-16
c12096 0 2142 2.623e-15
c12097 58 192 3.24e-16
c12098 48 183 1.94e-16
c12099 52 181 3.34e-16
c12100 2684 0 1.65e-16
c12101 2120 225 7.77e-16
c12102 1050 202 2.5e-16
c12103 1054 197 2.8e-16
c12104 1053 198 2.14e-16
c12105 1052 199 2.13e-16
c12106 1055 196 2.5e-16
c12107 1 2550 6.241e-15
c12108 231 480 2.13e-16
c12109 1 2547 7.03e-16
c12110 101 82 2.44e-16
c12111 223 136 3.24e-16
c12113 0 1330 2.957e-15
c12114 790 791 6.77e-16
c12115 1987 1986 6.77e-16
c12116 1300 1301 6.77e-16
c12117 1 1795 1.6e-16
c12118 122 0 2.2501e-14
c12119 122 113 8.48e-16
c12120 2343 2645 2.7e-16
c12121 2639 2647 7.98e-16
c12122 2389 2462 6.81e-16
c12123 0 1165 2.926e-15
c12124 242 619 7.91e-16
c12125 0 1608 2.957e-15
c12126 1744 223 2.13e-16
c12127 2252 222 8.32e-16
c12128 2590 2635 1.96e-16
c12129 147 219 1.99e-16
c12130 1 2107 1.6e-16
c12131 607 228 2.5e-16
c12132 1 489 1.6e-16
c12133 1102 1103 6.77e-16
c12134 1 1430 1.6e-16
c12135 0 321 2.623e-15
c12136 1547 1546 6.77e-16
c12137 822 218 2.8e-16
c12138 1321 209 2.54e-16
c12139 1370 235 7.23e-16
c12140 1783 186 7.23e-16
c12141 1258 242 2.5e-16
c12142 1259 243 2.8e-16
c12143 15 10 1.34e-16
c12144 1 1742 1.6e-16
c12145 234 100 3.34e-16
c12146 229 79 1.99e-16
c12147 0 31 7.793e-14
c12148 27 216 3.24e-16
c12149 0 1557 2.926e-15
c12150 1914 186 2.5e-16
c12151 1918 181 2.8e-16
c12152 1917 182 2.14e-16
c12153 1916 183 2.13e-16
c12154 1919 180 2.5e-16
c12155 0 614 2.623e-15
c12156 2635 2422 3.39e-16
c12157 0 450 2.957e-15
c12158 303 204 2.5e-16
c12159 301 206 2.14e-16
c12160 302 205 2.8e-16
c12161 0 945 2.623e-15
c12162 951 219 2.5e-16
c12163 1172 1173 6.77e-16
c12164 0 1886 2.623e-15
c12165 1617 1616 6.77e-16
c12166 1864 225 7.77e-16
c12167 2224 206 7.77e-16
c12168 2225 207 7.91e-16
c12169 2226 204 7.23e-16
c12170 2227 205 7.91e-16
c12171 0 268 2.585e-15
c12172 164 9 3.97e-16
c12173 82 84 3.92e-16
c12174 2591 235 1.083e-15
c12175 0 762 2.957e-15
c12176 794 202 2.5e-16
c12177 798 197 2.8e-16
c12178 797 198 2.14e-16
c12179 796 199 2.13e-16
c12180 799 196 2.5e-16
c12181 0 1371 2.623e-15
c12182 0 1272 2.957e-15
c12183 1934 1935 6.77e-16
c12184 0 94 7.793e-14
c12185 1863 226 7.23e-16
c12186 1862 227 7.91e-16
c12187 2508 2431 1.09e-16
c12188 2764 2770 1.96e-16
c12189 2296 2318 5.5e-16
c12190 2709 2358 3.54e-16
c12191 213 90 1.99e-16
c12192 0 1255 2.957e-15
c12193 0 2191 2.957e-15
c12194 48 238 1.9e-16
c12195 52 236 3.34e-16
c12196 2052 193 8.32e-16
c12197 2053 192 7.76e-16
c12198 2379 0 1.8651e-14
c12199 2639 2550 1.96e-16
c12200 2294 2630 1.96e-16
c12201 1 579 1.6e-16
c12202 0 1516 2.585e-15
c12203 73 186 1.99e-16
c12204 63 181 3.34e-16
c12205 0 54 1.82e-16
c12206 1488 223 2.13e-16
c12207 58 215 1.94e-16
c12208 1 2030 1.6e-16
c12209 0 392 2.957e-15
c12210 1 1851 1.6e-16
c12211 921 200 7.91e-16
c12212 1 2652 2.981e-15
c12213 0 1828 2.585e-15
c12214 20 234 1.99e-16
c12215 2274 228 7.23e-16
c12216 2757 2781 1.58e-16
c12217 1 2337 7.03e-16
c12218 1 2163 1.6e-16
c12219 2343 2407 2.44e-16
c12220 1065 209 2.54e-16
c12221 1064 208 2.13e-16
c12222 899 898 6.77e-16
c12223 1527 186 7.23e-16
c12224 0 2157 2.926e-15
c12225 1627 234 7.91e-16
c12226 187 157 1.99e-16
c12227 190 153 1.9e-16
c12228 2129 222 2.54e-16
c12229 182 163 1.9e-16
c12230 706 213 2.5e-16
c12231 707 212 2.8e-16
c12232 0 1035 2.623e-15
c12233 240 489 7.91e-16
c12234 1 1036 1.6e-16
c12235 164 69 3.31e-16
c12236 1979 219 2.8e-16
c12237 1 1481 1.6e-16
c12238 2590 2469 3.53e-16
c12239 1564 1565 6.77e-16
c12240 105 181 3.34e-16
c12241 2675 2665 3.54e-16
c12242 1195 210 7.91e-16
c12243 1198 204 7.91e-16
c12244 1196 206 8.32e-16
c12245 2283 0 2.623e-15
c12246 2574 2597 3.92e-16
c12247 1211 1210 6.77e-16
c12248 185 126 1.9e-16
c12249 2806 0 1.96e-16
c12250 194 195 3.76e-16
c12251 459 458 6.77e-16
c12252 0 687 2.957e-15
c12253 1 2284 1.6e-16
c12254 2655 2462 1.96e-16
c12255 498 237 2.5e-16
c12256 0 1180 2.585e-15
c12257 1191 211 2.5e-16
c12258 0 1625 2.623e-15
c12259 1128 240 2.13e-16
c12260 31 243 1.99e-16
c12261 1607 226 7.23e-16
c12262 1606 227 7.91e-16
c12263 2294 8 2.34e-16
c12264 2305 2351 9.8e-16
c12265 243 614 7.91e-16
c12266 0 999 2.957e-15
c12267 232 469 7.76e-16
c12268 534 535 6.77e-16
c12269 1117 230 2.14e-16
c12270 1322 211 7.23e-16
c12271 2299 2392 7.84e-16
c12272 164 108 4.85e-16
c12273 2687 2665 1.1e-15
c12274 1 2474 1.999e-15
c12275 771 770 6.77e-16
c12276 8 73 2.3e-16
c12277 0 1754 2.957e-15
c12278 1378 229 2.5e-16
c12279 1379 228 2.8e-16
c12280 1281 1280 6.77e-16
c12281 0 317 2.926e-15
c12282 529 528 6.77e-16
c12283 665 200 7.91e-16
c12284 241 100 3.31e-16
c12285 243 94 1.99e-16
c12286 2320 185 5.06e-16
c12287 514 181 2.5e-16
c12288 1 2769 3.53e-16
c12289 1 635 1.6e-16
c12290 1255 243 2.5e-16
c12291 0 1572 2.585e-15
c12292 846 847 6.77e-16
c12293 1724 215 2.13e-16
c12294 143 126 3.26e-16
c12295 0 629 2.926e-15
c12296 2643 2377 1.96e-16
c12297 2294 2425 1.96e-16
c12298 2647 2427 1.96e-16
c12299 2665 2492 5.04e-16
c12300 0 467 2.623e-15
c12301 142 181 1.99e-16
c12302 136 182 3.31e-16
c12303 1 468 1.6e-16
c12304 63 236 3.34e-16
c12305 0 1901 2.926e-15
c12306 229 157 3.34e-16
c12307 2299 2313 1.96e-16
c12308 294 211 7.91e-16
c12309 0 941 2.926e-15
c12310 0 779 2.623e-15
c12311 753 238 2.54e-16
c12312 755 236 2.8e-16
c12313 0 1384 2.957e-15
c12314 2675 2343 1.96e-16
c12315 2652 2639 5.88e-16
c12316 841 840 6.77e-16
c12317 0 1289 2.623e-15
c12318 1305 201 2.54e-16
c12319 1304 200 2.13e-16
c12320 1 780 1.6e-16
c12321 1359 220 2.5e-16
c12322 2219 211 2.8e-16
c12323 2223 205 7.23e-16
c12324 2221 207 7.76e-16
c12325 220 174 1.99e-16
c12326 2384 0 1.7027e-14
c12327 790 203 7.91e-16
c12328 2801 13 4.83e-16
c12329 1782 1783 6.77e-16
c12330 222 90 1.9e-16
c12331 0 1270 2.623e-15
c12332 1302 202 2.8e-16
c12333 1 265 1.6e-16
c12334 0 1696 2.957e-15
c12335 37 187 3.34e-16
c12336 27 183 1.94e-16
c12337 31 193 1.9e-16
c12338 1 2338 9.86e-16
c12339 916 917 6.77e-16
c12340 2206 0 2.623e-15
c12341 1 1092 1.6e-16
c12342 237 163 1.99e-16
c12343 1 1537 1.6e-16
c12344 0 220 2.5436e-14
c12345 230 132 1.9e-16
c12346 231 126 3.24e-16
c12347 2299 2632 9.09e-16
c12348 1396 184 2.13e-16
c12349 1153 1152 6.77e-16
c12350 52 225 1.9e-16
c12351 48 227 3.34e-16
c12352 2299 2519 1.496e-15
c12353 0 409 2.623e-15
c12354 236 105 3.34e-16
c12355 90 217 3.31e-16
c12356 79 210 3.34e-16
c12357 1 166 2.79e-16
c12358 769 182 2.54e-16
c12359 771 180 2.8e-16
c12360 2687 2343 3.54e-16
c12361 2094 2095 6.77e-16
c12362 861 230 2.14e-16
c12363 1996 223 2.13e-16
c12364 0 121 7.8203e-14
c12365 100 191 1.94e-16
c12366 94 193 1.9e-16
c12367 84 194 1.99e-16
c12368 2340 2309 1.28e-16
c12369 0 721 2.623e-15
c12370 20 241 1.9e-16
c12371 2282 242 2.5e-16
c12372 2283 243 2.8e-16
c12373 2825 8 2.83e-16
c12374 2389 2635 1.58e-16
c12375 565 217 2.14e-16
c12376 2637 2587 1.96e-16
c12377 1 115 7.6e-16
c12378 1 2712 2.88e-16
c12379 0 1679 2.957e-15
c12380 1 1235 1.6e-16
c12381 2164 2165 6.77e-16
c12382 2492 2441 2.74e-16
c12383 48 205 1.99e-16
c12384 2703 0 1.65e-16
c12385 80 8 1.303e-15
c12386 2343 2492 3.69e-16
c12387 2641 2409 3.54e-16
c12388 0 1048 2.957e-15
c12389 999 243 2.5e-16
c12390 0 1991 2.957e-15
c12391 48 200 3.24e-16
c12392 52 198 3.31e-16
c12393 1477 224 7.76e-16
c12394 2125 222 2.14e-16
c12395 392 193 7.77e-16
c12396 0 356 2.585e-15
c12397 230 147 3.31e-16
c12398 905 192 7.91e-16
c12399 2719 2865 7.19e-16
c12400 2675 2854 1.58e-16
c12401 2823 2861 1.96e-16
c12402 1 870 1.6e-16
c12403 2298 2348 1.96e-16
c12404 2627 2599 7.1e-16
c12405 101 87 2.44e-16
c12406 0 702 2.623e-15
c12407 14 224 3.24e-16
c12408 2263 235 2.5e-16
c12409 2733 2305 5.98e-16
c12410 2732 2312 3.15e-16
c12411 1 2847 1.6e-16
c12412 2312 2358 7.84e-16
c12413 2645 2294 2.54e-16
c12414 2643 2735 1.58e-16
c12415 2298 2510 2.44e-16
c12416 534 203 7.91e-16
c12417 142 236 1.99e-16
c12418 136 237 3.34e-16
c12419 0 1014 2.623e-15
c12420 1 2644 2.88e-16
c12421 0 1440 2.957e-15
c12422 37 229 1.99e-16
c12423 1 1939 1.6e-16
c12424 2687 2854 3.18e-16
c12425 0 1771 2.623e-15
c12426 1387 242 7.91e-16
c12427 1889 230 2.54e-16
c12428 20 191 3.24e-16
c12429 14 196 1.99e-16
c12430 2262 0 2.623e-15
c12431 0 332 2.585e-15
c12432 2625 2564 1.34e-16
c12433 1 1772 1.6e-16
c12434 0 826 2.957e-15
c12435 215 320 2.13e-16
c12436 0 1321 2.623e-15
c12437 1175 203 2.5e-16
c12438 27 238 1.9e-16
c12439 1593 217 2.54e-16
c12440 1592 216 2.13e-16
c12441 1108 232 2.13e-16
c12442 0 2083 2.623e-15
c12443 2322 181 5.64e-16
c12444 660 201 8.32e-16
c12445 661 200 7.76e-16
c12446 2634 2627 3.92e-16
c12447 506 187 7.23e-16
c12448 1 2084 1.6e-16
c12449 0 1138 2.957e-15
c12450 694 695 6.77e-16
c12451 0 463 2.957e-15
c12452 2471 2517 1.96e-16
c12453 2457 206 3.99e-16
c12454 0 956 2.585e-15
c12455 805 209 2.14e-16
c12456 1 2429 1.79e-16
c12457 0 1401 2.623e-15
c12458 1 302 1.6e-16
c12459 0 1718 2.623e-15
c12460 1723 218 7.91e-16
c12461 63 225 1.9e-16
c12462 1869 222 2.14e-16
c12463 2231 218 7.23e-16
c12464 2460 2439 7.03e-16
c12465 2465 2444 3.46e-16
c12466 2637 0 4.1791e-14
c12467 0 775 2.957e-15
c12468 2719 8 2.44e-16
c12469 2764 2799 1.96e-16
c12470 2654 2351 1.96e-16
c12471 2697 2635 1.96e-16
c12472 243 121 3.34e-16
c12473 240 115 1.94e-16
c12474 0 1285 2.926e-15
c12475 1 2227 1.6e-16
c12476 0 1713 2.623e-15
c12477 1006 1007 6.77e-16
c12478 214 84 3.31e-16
c12479 2299 2550 1.73e-16
c12480 585 584 6.77e-16
c12481 935 210 7.23e-16
c12482 73 208 1.94e-16
c12483 2007 235 2.5e-16
c12484 226 163 3.34e-16
c12485 1526 1527 6.77e-16
c12486 0 1348 2.585e-15
c12487 63 198 3.31e-16
c12488 868 241 8.32e-16
c12489 1 921 1.6e-16
c12490 1289 193 2.54e-16
c12491 1288 192 2.13e-16
c12492 1 1862 1.6e-16
c12493 2804 2757 1.58e-16
c12494 2471 2305 6.03e-16
c12495 2655 2635 8.18e-16
c12496 2709 2340 3.92e-16
c12497 2634 2643 3.91e-16
c12498 1763 1762 6.77e-16
c12499 225 105 1.9e-16
c12500 38 29 1.74e-16
c12501 210 157 1.99e-16
c12502 0 555 2.623e-15
c12503 204 163 1.99e-16
c12504 1 2169 1.6e-16
c12505 2294 2407 1.58e-16
c12506 8 2587 8.81e-16
c12507 0 1065 2.623e-15
c12508 1 556 1.6e-16
c12509 1838 1839 6.77e-16
c12510 1217 215 7.91e-16
c12511 1630 229 2.8e-16
c12512 0 2006 2.623e-15
c12513 2352 2342 1.6e-16
c12514 199 163 1.94e-16
c12515 186 174 3.34e-16
c12516 2651 2490 1.58e-16
c12517 2635 2574 3.54e-16
c12518 405 200 7.76e-16
c12519 404 201 8.32e-16
c12520 2574 229 5.64e-16
c12521 2543 220 8.84e-16
c12522 0 882 2.957e-15
c12523 90 184 3.24e-16
c12524 208 209 2e-16
c12525 209 132 3.31e-16
c12526 121 193 3.31e-16
c12527 207 126 3.24e-16
c12528 111 187 3.34e-16
c12529 115 189 3.34e-16
c12530 105 198 3.31e-16
c12531 1770 242 2.5e-16
c12532 1771 243 2.8e-16
c12533 0 186 2.3912e-14
c12534 3 180 3.48e-16
c12535 0 1194 2.957e-15
c12536 1 2864 2.15e-16
c12537 132 203 3.34e-16
c12538 202 126 1.99e-16
c12539 58 181 1.99e-16
c12540 2630 0 2.6483e-14
c12541 2572 238 5.06e-16
c12542 2116 224 2.13e-16
c12543 1045 201 2.14e-16
c12544 1908 1909 6.77e-16
c12545 0 1457 2.623e-15
c12546 1463 219 2.5e-16
c12547 1963 210 7.91e-16
c12548 0 512 2.957e-15
c12549 2422 2409 1.701e-15
c12551 225 142 3.31e-16
c12552 226 136 1.99e-16
c12553 0 1324 2.585e-15
c12554 0 1784 2.957e-15
c12555 1896 240 2.13e-16
c12556 2321 181 4.83e-16
c12557 2480 213 2.07e-16
c12558 143 82 3.31e-16
c12559 2407 209 5.06e-16
c12560 2641 2649 7.84e-16
c12561 224 329 7.91e-16
c12562 0 1767 2.957e-15
c12563 1 665 1.6e-16
c12564 0 2096 2.957e-15
c12565 2322 2313 1.96e-16
c12566 1468 1469 6.77e-16
c12567 143 118 3.31e-16
c12568 1 1606 1.6e-16
c12569 214 316 8.32e-16
c12570 518 195 7.91e-16
c12571 147 209 1.9e-16
c12572 136 204 3.34e-16
c12573 1 646 1.6e-16
c12574 0 1421 2.926e-15
c12575 27 227 3.34e-16
c12576 31 223 3.24e-16
c12577 1 977 1.6e-16
c12578 1936 190 7.77e-16
c12579 1937 191 7.91e-16
c12580 1938 188 7.23e-16
c12581 1939 189 7.91e-16
c12582 0 478 2.623e-15
c12583 147 203 1.99e-16
c12584 142 198 1.9e-16
c12585 136 199 3.24e-16
c12586 225 456 7.77e-16
c12587 2836 2825 1.451e-15
c12588 2389 2835 3.71e-16
c12589 1107 221 7.91e-16
c12590 1433 200 7.91e-16
c12591 8 174 3.79e-16
c12592 1 1913 1.6e-16
c12593 15 26 6.55e-16
c12594 0 790 2.623e-15
c12595 2675 2294 1.96e-16
c12596 213 446 2.8e-16
c12597 0 1300 2.585e-15
c12598 1147 187 2.8e-16
c12599 1151 181 7.23e-16
c12600 1149 183 7.76e-16
c12601 37 210 3.34e-16
c12602 27 205 1.99e-16
c12603 8 0 3.25183e-13
c12604 2808 59 5.93e-16
c12605 2809 80 9.48e-16
c12606 8 113 1.96e-16
c12607 229 111 1.99e-16
c12608 223 94 3.24e-16
c12609 675 674 6.77e-16
c12610 0 1102 2.623e-15
c12611 27 200 3.24e-16
c12612 0 1547 2.623e-15
c12613 2073 201 2.54e-16
c12614 2072 200 2.13e-16
c12615 1 1548 1.6e-16
c12616 2351 2420 1.96e-16
c12617 2015 229 7.23e-16
c12618 90 239 1.94e-16
c12619 1087 213 7.23e-16
c12620 1086 212 7.91e-16
c12621 1707 210 7.91e-16
c12622 1710 204 7.91e-16
c12623 1708 206 8.32e-16
c12624 84 216 1.94e-16
c12625 213 178 3.34e-16
c12626 2574 2469 2.52e-16
c12627 774 194 2.8e-16
c12628 2764 2771 1.96e-16
c12629 2687 2294 3.54e-16
c12630 1 2390 1.424e-15
c12631 1285 193 2.14e-16
c12632 987 986 6.77e-16
c12633 2420 2397 5.1e-16
c12634 2467 2390 1.943e-15
c12635 1640 240 2.13e-16
c12636 58 236 1.99e-16
c12637 2425 0 1.6712e-14
c12638 0 568 2.957e-15
c12639 2637 2543 1.96e-16
c12640 2645 2587 1.96e-16
c12641 59 37 2.17e-16
c12642 122 42 1.58e-16
c12643 0 1511 2.957e-15
c12644 0 2021 2.926e-15
c12645 2364 2409 3.54e-16
c12646 2312 2572 2.94e-16
c12647 2294 2492 3.54e-16
c12648 1 48 7.6e-16
c12649 255 180 2.5e-16
c12650 252 183 2.13e-16
c12651 253 182 2.14e-16
c12652 254 181 2.8e-16
c12653 0 899 2.623e-15
c12654 1507 1506 6.77e-16
c12655 820 821 6.77e-16
c12656 1 390 1.6e-16
c12657 1 900 1.6e-16
c12658 0 1823 2.957e-15
c12659 2017 2016 6.77e-16
c12660 2761 2763 1.452e-15
c12661 548 208 2.13e-16
c12662 0 1211 2.623e-15
c12663 851 221 7.91e-16
c12664 1057 1056 6.77e-16
c12665 1 1212 1.6e-16
c12666 1767 243 2.5e-16
c12667 1620 233 8.32e-16
c12668 1 1657 1.6e-16
c12669 0 534 2.623e-15
c12670 701 214 2.14e-16
c12671 1819 1818 6.77e-16
c12672 1132 1133 6.77e-16
c12673 0 529 2.623e-15
c12674 1 1969 1.6e-16
c12675 377 184 7.91e-16
c12676 0 846 2.623e-15
c12677 2675 2825 3.15e-16
c12678 1 2516 1.999e-15
c12679 0 1453 2.926e-15
c12680 0 346 2.957e-15
c12681 24 0 1.14e-16
c12682 2585 2566 5.58e-16
c12683 0 841 2.623e-15
c12684 2854 2852 1.693e-15
c12685 831 213 7.23e-16
c12686 830 212 7.91e-16
c12687 0 1175 2.957e-15
c12688 1652 1653 6.77e-16
c12689 1 11 2.84e-16
c12690 0 1782 2.623e-15
c12691 0 1618 2.957e-15
c12692 0 658 2.957e-15
c12693 2409 207 7.64e-16
c12694 2649 2590 1.96e-16
c12695 0 1153 2.623e-15
c12696 1889 1888 6.77e-16
c12697 1 499 1.6e-16
c12698 0 2094 2.623e-15
c12699 1950 196 7.91e-16
c12700 1948 198 8.32e-16
c12701 2409 202 5.7e-16
c12702 0 970 2.957e-15
c12703 1 1916 1.6e-16
c12704 2631 242 2.339e-15
c12705 222 465 2.54e-16
c12706 1 2475 1.79e-16
c12707 1931 195 2.8e-16
c12708 1373 230 2.14e-16
c12709 73 235 1.99e-16
c12710 1964 1965 6.77e-16
c12711 2503 2490 1.076e-15
c12712 1876 232 2.13e-16
c12713 315 219 2.8e-16
c12714 0 805 2.926e-15
c12715 2655 2320 1.58e-16
c12716 957 215 7.76e-16
c12717 1159 194 7.23e-16
c12718 1 2732 6.67e-16
c12719 1449 1448 6.77e-16
c12720 2645 0 5.283e-14
c12721 1 2238 1.6e-16
c12722 2649 2422 1.96e-16
c12723 0 1117 2.926e-15
c12724 1 2358 8.3e-16
c12725 1097 225 2.54e-16
c12726 2528 2517 1.6e-16
c12727 1511 243 2.5e-16
c12728 2358 2467 1.96e-16
c12729 48 240 3.24e-16
c12730 2022 242 2.8e-16
c12731 1 2059 1.6e-16
c12732 2299 2559 1.496e-15
c12733 232 163 3.24e-16
c12734 1417 192 7.91e-16
c12735 69 219 3.34e-16
c12736 1 441 1.6e-16
c12737 0 74 1.82e-16
c12738 0 1872 2.957e-15
c12739 1 1382 1.6e-16
c12740 222 178 3.31e-16
c12741 2634 2766 3.54e-16
c12742 31 182 3.31e-16
c12743 1 753 1.6e-16
c12744 1346 212 7.23e-16
c12745 1859 213 7.91e-16
c12746 1 1694 1.6e-16
c12747 2298 2312 1.391e-15
c12748 0 585 2.623e-15
c12749 223 121 1.94e-16
c12750 234 126 1.99e-16
c12751 2761 2633 1.34e-16
c12752 721 223 7.91e-16
c12753 0 1526 2.623e-15
c12754 219 168 1.99e-16
c12755 217 178 1.9e-16
c12756 208 174 3.24e-16
c12757 2643 2625 1.96e-16
c12758 8 2543 1.36e-16
c12759 58 225 3.31e-16
c12760 0 402 2.957e-15
c12761 143 134 3.31e-16
c12762 90 206 1.9e-16
c12763 2675 2719 1.58e-16
c12764 1 160 2.79e-16
c12765 910 911 6.77e-16
c12766 760 184 2.13e-16
c12767 0 1838 2.623e-15
c12768 210 111 3.34e-16
c12769 100 180 1.99e-16
c12770 94 182 3.31e-16
c12771 90 201 3.31e-16
c12772 84 183 3.24e-16
c12773 79 194 3.34e-16
c12774 0 208 2.5772e-14
c12775 246 187 7.91e-16
c12776 0 714 2.957e-15
c12777 2277 241 2.14e-16
c12778 0 1224 2.957e-15
c12779 1 211 3.708e-15
c12780 0 132 7.8194e-14
c12781 2183 195 2.5e-16
c12782 3 197 6.13e-16
c12783 2467 211 9.65e-16
c12784 0 1207 2.957e-15
c12785 708 225 8.32e-16
c12786 0 1650 2.957e-15
c12787 1222 1223 6.77e-16
c12788 1 1046 1.6e-16
c12789 58 198 1.9e-16
c12790 48 189 1.99e-16
c12791 1667 1666 6.77e-16
c12792 2299 2429 4.02e-16
c12793 232 136 1.94e-16
c12794 0 861 2.926e-15
c12795 2719 2687 2.28e-16
c12796 2697 2820 7.4e-16
c12797 0 1468 2.585e-15
c12798 801 800 6.77e-16
c12799 986 235 7.23e-16
c12800 0 1962 2.957e-15
c12801 2334 180 1.206e-15
c12802 2625 2606 1.34e-16
c12803 1 1803 1.6e-16
c12804 230 481 2.54e-16
c12805 2654 2819 9.32e-16
c12806 80 86 1.34e-16
c12807 698 219 7.23e-16
c12808 838 226 2.8e-16
c12809 0 1797 2.926e-15
c12810 1813 201 2.14e-16
c12811 143 87 3.31e-16
c12812 0 675 2.623e-15
c12813 2407 0 3.0825e-14
c12814 2639 2358 8.4e-16
c12815 2750 2312 8.09e-16
c12816 2318 2305 1.005e-15
c12817 2697 2409 2.733e-15
c12818 2665 2508 3.92e-16
c12819 223 332 2.13e-16
c12820 1 2115 1.6e-16
c12821 1979 1978 6.77e-16
c12822 1 676 1.6e-16
c12823 1028 192 2.13e-16
c12824 1447 210 7.23e-16
c12825 0 2109 2.926e-15
c12826 1113 1112 6.77e-16
c12827 1603 213 7.91e-16
c12828 0 147 7.793e-14
c12829 1 1438 1.6e-16
c12830 2471 2557 1.96e-16
c12831 0 987 2.623e-15
c12832 229 611 7.91e-16
c12833 42 220 3.34e-16
c12834 1 988 1.6e-16
c12835 2054 2055 6.77e-16
c12836 1943 202 7.23e-16
c12837 1380 241 8.32e-16
c12838 73 242 1.99e-16
c12839 1 1433 1.6e-16
c12840 14 187 3.34e-16
c12841 20 180 3.34e-16
c12842 0 327 2.957e-15
c12843 0 820 2.585e-15
c12844 222 461 2.14e-16
c12845 824 217 7.77e-16
c12846 0 1314 2.957e-15
c12847 436 437 6.77e-16
c12848 31 237 3.34e-16
c12849 2250 0 2.957e-15
c12850 2592 2519 5.45e-16
c12851 2086 211 7.91e-16
c12852 1 1745 1.6e-16
c12853 2655 2409 6.1e-16
c12854 2634 2642 1.6e-16
c12855 502 186 2.8e-16
c12856 0 1132 2.585e-15
c12857 1250 229 2.5e-16
c12858 1251 228 2.8e-16
c12859 1 27 7.6e-16
c12860 2351 2377 8.46e-16
c12861 2651 2379 1.96e-16
c12862 0 951 2.957e-15
c12863 954 218 2.5e-16
c12864 0 1394 2.957e-15
c12865 748 749 6.77e-16
c12866 0 1889 2.623e-15
c12867 237 94 3.34e-16
c12868 238 84 3.31e-16
c12869 1 275 1.6e-16
c12870 1355 227 2.8e-16
c12871 0 1706 2.957e-15
c12872 2490 2484 9.32e-16
c12873 2425 2401 6.86e-16
c12874 2296 2305 7.79e-16
c12875 243 132 3.34e-16
c12876 241 126 1.9e-16
c12877 214 79 1.9e-16
c12878 2637 2460 1.96e-16
c12879 2641 2510 1.96e-16
c12880 2343 2508 2.82e-16
c12881 434 205 2.5e-16
c12882 432 207 2.13e-16
c12883 1926 1927 6.77e-16
c12884 582 226 2.8e-16
c12885 2643 2545 1.96e-16
c12886 2647 2592 1.96e-16
c12887 2645 2543 1.96e-16
c12888 224 153 3.24e-16
c12889 928 199 2.13e-16
c12890 930 197 2.5e-16
c12891 0 1343 2.957e-15
c12892 73 192 1.94e-16
c12893 0 1853 2.926e-15
c12894 2675 0 3.9895e-14
c12895 0 910 2.623e-15
c12896 757 185 2.14e-16
c12897 2759 2762 1.96e-16
c12898 2800 2757 6.15e-16
c12899 2389 2649 1.58e-16
c12900 857 233 2.54e-16
c12901 1268 184 2.13e-16
c12902 1687 202 7.23e-16
c12903 2158 236 7.91e-16
c12904 2156 238 8.32e-16
c12905 14 229 1.99e-16
c12906 0 1222 2.623e-15
c12907 0 1058 2.957e-15
c12908 0 1667 2.623e-15
c12909 194 157 1.99e-16
c12910 196 153 1.99e-16
c12911 1 1489 1.6e-16
c12912 188 163 1.99e-16
c12913 184 178 1.94e-16
c12914 2338 2322 1.58e-16
c12915 243 147 1.99e-16
c12916 891 890 6.77e-16
c12917 994 229 2.5e-16
c12918 995 228 2.8e-16
c12919 0 1979 2.623e-15
c12920 1473 215 7.91e-16
c12921 1 1980 1.6e-16
c12922 121 182 1.9e-16
c12923 2687 0 1.2781e-14
c12924 1671 195 2.5e-16
c12925 6 4 9.1e-16
c12926 193 132 3.31e-16
c12927 191 126 3.24e-16
c12928 196 197 6.86e-16
c12929 0 688 2.957e-15
c12930 1411 1410 6.77e-16
c12931 0 1631 2.957e-15
c12932 1 2666 2.88e-16
c12933 27 240 3.24e-16
c12934 1 1187 1.6e-16
c12935 1203 1202 6.77e-16
c12936 1956 209 8.32e-16
c12937 1957 208 7.76e-16
c12938 2492 0 4.5716e-14
c12939 164 166 2.17e-16
c12940 0 1000 2.957e-15
c12941 1 2572 5.65e-16
c12942 1 510 1.6e-16
c12943 1120 231 2.13e-16
c12944 1328 206 7.77e-16
c12945 1329 207 7.91e-16
c12946 1330 204 7.23e-16
c12947 1331 205 7.91e-16
c12948 0 1926 2.623e-15
c12949 1599 213 7.23e-16
c12950 1598 212 7.91e-16
c12951 164 115 3.31e-16
c12952 69 230 1.9e-16
c12953 1797 193 2.14e-16
c12954 2214 2215 6.77e-16
c12955 1738 227 7.23e-16
c12956 0 637 2.926e-15
c12957 2665 2671 1.6e-16
c12958 2384 2651 1.96e-16
c12959 1168 191 2.13e-16
c12960 1170 189 2.5e-16
c12961 233 601 2.54e-16
c12962 1012 184 2.13e-16
c12963 31 226 1.99e-16
c12964 1 1579 1.6e-16
c12965 1902 236 7.91e-16
c12966 1900 238 8.32e-16
c12967 2358 2427 1.96e-16
c12968 2647 2382 1.96e-16
c12969 147 193 1.9e-16
c12970 136 188 3.34e-16
c12971 224 452 2.13e-16
c12972 0 1411 2.623e-15
c12973 1100 222 8.32e-16
c12974 2035 2034 6.77e-16
c12975 1 1412 1.6e-16
c12976 230 168 3.31e-16
c12977 235 174 3.34e-16
c12978 300 206 8.32e-16
c12979 299 210 7.91e-16
c12980 2587 2525 1.34e-16
c12981 596 597 6.77e-16
c12982 1793 1792 6.77e-16
c12983 2787 38 1.484e-15
c12984 2793 15 2.06e-16
c12985 2697 2649 1.96e-16
c12986 2654 2318 1.96e-16
c12987 233 90 3.31e-16
c12988 417 416 6.77e-16
c12989 0 1295 2.957e-15
c12990 731 234 7.91e-16
c12991 31 204 3.34e-16
c12992 1363 221 7.91e-16
c12993 73 215 3.24e-16
c12994 1240 233 7.77e-16
c12995 2214 0 2.623e-15
c12996 795 202 7.91e-16
c12997 226 94 1.99e-16
c12998 1358 1359 6.77e-16
c12999 227 84 1.99e-16
c13000 0 235 2.5224e-14
c13001 42 186 1.99e-16
c13002 37 194 3.34e-16
c13003 27 189 1.99e-16
c13004 31 199 3.24e-16
c13005 1 2340 1.028e-15
c13006 1239 234 7.23e-16
c13007 1238 235 7.91e-16
c13008 1556 200 2.13e-16
c13009 171 174 3.92e-16
c13010 0 2035 2.623e-15
c13011 239 178 3.24e-16
c13012 0 596 2.585e-15
c13013 2635 2505 1.96e-16
c13014 0 417 2.623e-15
c13015 0 1090 2.957e-15
c13016 1 2036 1.6e-16
c13017 426 211 7.23e-16
c13018 0 1358 2.623e-15
c13019 2105 2104 6.77e-16
c13020 729 728 6.77e-16
c13021 1701 208 7.76e-16
c13022 2419 203 3.61e-16
c13023 0 415 2.957e-15
c13024 0 86 1.82e-16
c13025 214 157 3.31e-16
c13026 237 121 1.99e-16
c13027 94 204 3.34e-16
c13028 84 205 3.34e-16
c13029 79 216 3.24e-16
c13030 275 189 7.91e-16
c13031 274 188 7.23e-16
c13032 273 191 7.91e-16
c13033 272 190 7.77e-16
c13034 2577 232 3.8e-16
c13035 0 729 2.623e-15
c13036 2709 2641 3.54e-16
c13037 2655 2649 7.46e-16
c13038 230 352 7.77e-16
c13039 864 231 2.13e-16
c13040 1 1243 1.6e-16
c13041 100 197 1.99e-16
c13042 94 199 3.24e-16
c13043 84 200 1.94e-16
c13044 2465 2386 1.029e-15
c13045 0 727 2.957e-15
c13046 1428 1429 6.77e-16
c13047 2634 2351 3.54e-16
c13048 569 216 7.91e-16
c13049 1 2179 1.6e-16
c13050 0 1237 2.926e-15
c13051 0 1680 2.957e-15
c13052 1 566 1.6e-16
c13053 52 211 1.99e-16
c13054 2639 2572 1.58e-16
c13055 2649 2574 3.54e-16
c13056 2299 2475 7.84e-16
c13057 323 322 6.77e-16
c13058 912 191 2.13e-16
c13059 914 189 2.5e-16
c13060 1 2556 1.999e-15
c13061 1003 242 7.91e-16
c13062 0 1992 2.957e-15
c13063 1983 212 2.5e-16
c13064 234 342 2.8e-16
c13065 1740 1741 6.77e-16
c13066 1 363 1.6e-16
c13067 991 228 2.5e-16
c13068 844 222 8.32e-16
c13069 1209 217 2.54e-16
c13070 1208 216 2.13e-16
c13071 1 873 1.6e-16
c13072 1469 215 7.76e-16
c13073 2293 0 7.116e-15
c13074 2627 2597 3.88e-16
c13075 2167 186 7.23e-16
c13076 1 1814 1.6e-16
c13077 2407 2401 3.92e-16
c13078 0 705 2.623e-15
c13079 2267 234 7.91e-16
c13080 2733 2735 1.274e-15
c13081 2734 2746 4.95e-16
c13082 2732 2740 6.83e-16
c13083 2299 2358 1.544e-15
c13084 1 2145 1.6e-16
c13085 1 2298 1.307e-15
c13086 2298 2467 1.58e-16
c13087 0 522 2.957e-15
c13088 496 238 7.77e-16
c13089 497 239 7.91e-16
c13090 539 202 7.91e-16
c13091 542 196 7.91e-16
c13092 540 198 8.32e-16
c13093 1 2126 1.6e-16
c13094 0 1017 2.623e-15
c13095 8 42 2.3e-16
c13096 0 1941 2.926e-15
c13097 2108 214 8.32e-16
c13098 14 210 3.34e-16
c13099 0 340 2.585e-15
c13100 0 834 2.957e-15
c13101 2820 2842 5.08e-16
c13102 682 210 2.5e-16
c13103 686 205 2.8e-16
c13104 685 206 2.14e-16
c13105 684 207 2.13e-16
c13106 687 204 2.5e-16
c13107 947 946 6.77e-16
c13108 2265 0 2.623e-15
c13109 20 197 3.34e-16
c13110 0 652 2.585e-15
c13111 2647 2333 1.96e-16
c13112 2637 2651 5.88e-16
c13113 0 1146 2.957e-15
c13114 705 704 6.77e-16
c13115 1136 239 2.13e-16
c13116 1138 237 2.5e-16
c13117 1178 202 2.5e-16
c13118 1182 197 2.8e-16
c13119 1181 198 2.14e-16
c13120 1180 199 2.13e-16
c13121 1183 196 2.5e-16
c13122 512 182 7.77e-16
c13123 513 183 7.91e-16
c13124 515 181 7.91e-16
c13125 2299 2601 1.496e-15
c13126 270 271 6.77e-16
c13127 0 964 2.585e-15
c13128 37 214 1.9e-16
c13129 2543 2492 3.17e-16
c13130 242 174 3.34e-16
c13131 809 208 7.91e-16
c13132 1 305 1.6e-16
c13133 0 1721 2.623e-15
c13134 1017 1016 6.77e-16
c13135 1872 223 2.13e-16
c13136 2229 0 2.926e-15
c13137 2364 2348 2.39e-16
c13138 59 14 2.17e-16
c13139 80 9 2.44e-16
c13140 0 776 2.957e-15
c13141 0 242 2.396e-14
c13142 1 617 1.6e-16
c13143 0 2048 2.957e-15
c13144 2643 2462 1.96e-16
c13145 2318 2420 1.96e-16
c13146 2645 2460 1.96e-16
c13147 2364 2510 1.96e-16
c13148 2294 2508 1.96e-16
c13149 438 219 7.91e-16
c13150 340 341 6.77e-16
c13151 0 1373 2.926e-15
c13152 69 209 3.31e-16
c13153 63 211 1.99e-16
c13154 1 929 1.6e-16
c13155 1498 235 7.23e-16
c13156 1911 186 7.23e-16
c13157 2011 234 7.91e-16
c13158 2318 2557 2.39e-16
c13159 1 1870 1.6e-16
c13160 284 198 8.32e-16
c13161 286 196 7.91e-16
c13162 577 576 6.77e-16
c13163 2389 2761 1.96e-16
c13164 2788 2759 1.58e-16
c13165 241 361 2.54e-16
c13166 69 203 3.34e-16
c13167 873 240 7.91e-16
c13168 1 252 1.6e-16
c13169 0 1685 2.926e-15
c13170 1 1355 1.6e-16
c13171 2265 2264 6.77e-16
c13172 1852 214 8.32e-16
c13173 2209 198 2.54e-16
c13174 2211 196 2.8e-16
c13175 1518 1519 6.77e-16
c13176 267 195 2.8e-16
c13178 2776 2777 1.158e-15
c13179 2798 2781 1.96e-16
c13180 2298 2639 1.58e-16
c13181 2665 2647 3.7e-16
c13182 1339 1338 6.77e-16
c13183 226 121 3.34e-16
c13184 860 230 8.32e-16
c13185 2028 2029 6.77e-16
c13186 652 653 6.77e-16
c13187 1079 219 2.5e-16
c13188 1696 199 2.13e-16
c13189 1698 197 2.5e-16
c13190 1540 192 2.13e-16
c13191 1849 1848 6.77e-16
c13192 2202 203 7.23e-16
c13193 2475 2487 1.6e-16
c13194 216 157 1.94e-16
c13195 209 168 1.9e-16
c13196 206 178 3.31e-16
c13197 223 132 1.94e-16
c13198 2343 2632 1.96e-16
c13199 2637 2585 1.96e-16
c13200 0 1071 2.957e-15
c13201 880 239 2.13e-16
c13202 882 237 2.5e-16
c13203 0 1499 2.623e-15
c13204 0 2009 2.623e-15
c13205 1632 230 7.77e-16
c13206 1 1500 1.6e-16
c13207 203 168 1.99e-16
c13208 201 178 1.9e-16
c13209 192 174 3.24e-16
c13210 1991 226 7.23e-16
c13211 1990 227 7.91e-16
c13212 204 121 1.99e-16
c13213 211 105 1.99e-16
c13214 90 190 1.9e-16
c13215 79 183 1.94e-16
c13216 1830 1831 6.77e-16
c13217 80 69 1.59e-16
c13218 964 965 6.77e-16
c13219 2371 194 4.83e-16
c13220 0 192 2.5827e-14
c13221 121 199 1.94e-16
c13222 111 194 3.34e-16
c13223 1 195 3.708e-15
c13224 1205 217 2.14e-16
c13225 0 1644 2.585e-15
c13226 0 2138 2.957e-15
c13227 1762 229 2.5e-16
c13228 1763 228 2.8e-16
c13229 2429 2432 1.154e-15
c13230 2296 2420 1.58e-16
c13231 2471 2599 1.96e-16
c13232 1049 200 7.91e-16
c13233 896 183 2.13e-16
c13234 898 181 2.5e-16
c13235 0 1463 2.957e-15
c13236 1466 218 2.5e-16
c13237 0 1956 2.585e-15
c13238 2330 182 3.99e-16
c13239 223 147 3.24e-16
c13240 1335 218 7.23e-16
c13241 1721 1720 6.77e-16
c13242 1655 186 7.23e-16
c13243 1 1331 1.6e-16
c13244 2801 0 2.08e-16
c13245 2842 2843 8.49e-16
c13246 678 211 7.91e-16
c13247 2745 2318 6.61e-16
c13248 2343 2647 8.19e-16
c13249 2389 2510 2.44e-16
c13250 0 1163 2.623e-15
c13251 1 101 2.84e-16
c13252 240 617 7.91e-16
c13253 242 243 3.76e-16
c13254 1 1164 1.6e-16
c13255 31 232 1.94e-16
c13256 1743 220 2.5e-16
c13257 2107 219 2.8e-16
c13258 1 1609 1.6e-16
c13259 164 48 3.31e-16
c13260 2665 2550 3.92e-16
c13261 0 486 2.623e-15
c13262 523 194 7.91e-16
c13263 526 188 7.91e-16
c13264 524 190 8.32e-16
c13265 142 211 3.34e-16
c13266 1174 203 7.91e-16
c13267 604 230 8.32e-16
c13268 1440 199 2.13e-16
c13269 1442 197 2.5e-16
c13270 0 481 2.623e-15
c13271 0 815 2.957e-15
c13272 2471 2634 3.15e-16
c13274 760 761 6.77e-16
c13275 0 1308 2.585e-15
c13276 1319 211 2.5e-16
c13277 744 241 7.77e-16
c13278 1369 233 2.54e-16
c13279 1780 184 2.13e-16
c13280 20 17 3.92e-16
c13281 1256 240 2.13e-16
c13282 2244 0 2.585e-15
c13283 0 298 2.957e-15
c13284 2490 2526 3.92e-16
c13285 2630 2512 6.14e-16
c13286 2508 2482 1.09e-16
c13287 0 793 2.623e-15
c13288 19 25 2.94e-15
c13289 650 195 7.23e-16
c13290 232 94 1.94e-16
c13291 0 1127 2.957e-15
c13292 734 229 2.8e-16
c13293 1153 182 2.54e-16
c13294 1155 180 2.8e-16
c13295 42 208 1.94e-16
c13296 37 216 3.24e-16
c13297 1245 230 2.14e-16
c13298 0 1555 2.623e-15
c13299 0 2065 2.623e-15
c13300 1 29 2.79e-16
c13301 1182 1183 6.77e-16
c13302 0 610 2.957e-15
c13303 1 1556 1.6e-16
c13304 2628 238 1.114e-15
c13305 3 228 3.48e-16
c13306 2651 2425 1.96e-16
c13307 0 1105 2.623e-15
c13308 1627 1626 6.77e-16
c13309 949 217 2.14e-16
c13310 1 451 1.6e-16
c13311 0 1388 2.585e-15
c13312 0 2046 2.623e-15
c13313 1506 229 2.5e-16
c13314 1507 228 2.8e-16
c13315 0 1882 2.957e-15
c13316 2590 2583 5.82e-16
c13317 0 428 2.585e-15
c13318 238 79 1.9e-16
c13319 2589 232 2.264e-15
c13320 2787 2791 4.83e-16
c13321 1 763 1.6e-16
c13322 1349 225 2.14e-16
c13323 1 1273 1.6e-16
c13324 1861 224 7.76e-16
c13325 0 247 2.957e-15
c13326 215 174 1.94e-16
c13327 279 202 7.23e-16
c13328 2490 2485 7.97e-16
c13329 2425 2402 1.58e-16
c13330 0 740 2.585e-15
c13331 776 193 7.77e-16
c13332 2709 2364 3.54e-16
c13333 1 84 7.6e-16
c13334 1 1254 1.6e-16
c13336 2723 0 1.65e-16
c13337 2146 228 7.23e-16
c13338 0 215 2.5999e-14
c13339 214 111 1.9e-16
c13340 1 2190 1.6e-16
c13341 2637 2503 1.96e-16
c13342 2343 2550 1.96e-16
c13343 2299 2572 9.78e-16
c13344 0 1512 2.957e-15
c13345 1 212 3.719e-15
c13346 73 181 3.34e-16
c13347 1851 219 2.8e-16
c13348 2635 2627 1.96e-16
c13349 8 2585 2.83e-16
c13350 2351 2625 1.561e-15
c13351 1998 221 2.8e-16
c13352 918 203 7.91e-16
c13353 1 2588 7.03e-16
c13354 1 393 1.6e-16
c13355 0 1824 2.957e-15
c13356 2193 190 2.54e-16
c13357 2195 188 2.8e-16
c13358 1499 1498 6.77e-16
c13359 2273 230 2.54e-16
c13360 2767 2766 1.386e-15
c13361 2009 2008 6.77e-16
c13362 633 632 6.77e-16
c13363 1063 211 2.5e-16
c13364 1524 184 2.13e-16
c13365 0 2155 2.623e-15
c13366 1625 232 7.91e-16
c13367 2270 229 2.8e-16
c13368 2298 2427 1.58e-16
c13369 187 153 3.34e-16
c13370 183 157 3.24e-16
c13371 0 537 2.623e-15
c13372 1 2156 1.6e-16
c13373 704 215 2.13e-16
c13374 1574 1575 6.77e-16
c13375 242 487 7.23e-16
c13376 243 486 7.91e-16
c13377 0 1478 2.623e-15
c13378 1977 217 2.54e-16
c13379 1976 216 2.13e-16
c13380 101 71 2.44e-16
c13381 2492 223 7.64e-16
c13382 0 849 2.623e-15
c13383 890 187 7.23e-16
c13384 2654 2824 3.77e-16
c13385 2652 2665 3.62e-16
c13386 182 132 1.9e-16
c13387 180 126 3.34e-16
c13388 1752 233 7.77e-16
c13389 192 193 2e-16
c13390 2687 2460 7.6e-16
c13391 2655 2510 1.96e-16
c13392 2299 2340 9.12e-16
c13393 0 1176 2.957e-15
c13394 1189 209 2.14e-16
c13395 1 15 7.2e-16
c13396 1 686 1.6e-16
c13397 1127 243 2.5e-16
c13398 2409 2350 1.58e-16
c13399 1605 224 7.76e-16
c13400 2645 2651 5.88e-16
c13401 2312 2590 3.08e-16
c13402 2643 2635 5.88e-16
c13403 0 501 2.926e-15
c13404 164 160 1.656e-15
c13405 1644 1645 6.77e-16
c13406 240 613 7.76e-16
c13407 615 614 6.77e-16
c13408 1320 209 7.77e-16
c13409 1 998 1.6e-16
c13410 1291 1290 6.77e-16
c13411 1 2473 1.424e-15
c13412 962 212 7.23e-16
c13413 1376 231 2.13e-16
c13414 0 315 2.623e-15
c13415 1 1755 1.6e-16
c13416 240 84 1.94e-16
c13417 2634 2664 1.31e-16
c13418 1 316 1.6e-16
c13419 0 1732 2.585e-15
c13420 1956 1957 6.77e-16
c13421 0 1568 2.957e-15
c13422 1252 241 8.32e-16
c13423 0 627 2.623e-15
c13424 2318 2377 1.96e-16
c13425 2312 2422 1.96e-16
c13426 147 182 3.31e-16
c13427 1 628 1.6e-16
c13428 1424 191 2.13e-16
c13429 1426 189 2.5e-16
c13430 73 236 3.34e-16
c13431 0 2061 2.926e-15
c13432 0 1899 2.623e-15
c13433 1515 242 7.91e-16
c13434 2024 241 7.77e-16
c13435 229 153 1.99e-16
c13436 0 939 2.623e-15
c13437 1 1900 1.6e-16
c13438 233 178 1.9e-16
c13439 293 208 7.76e-16
c13440 292 209 8.32e-16
c13441 221 594 2.5e-16
c13442 220 595 2.8e-16
c13443 2793 2787 7.61e-16
c13444 2652 2343 5.88e-16
c13445 0 69 7.8203e-14
c13446 1 940 1.6e-16
c13447 1503 228 2.5e-16
c13448 1356 222 8.32e-16
c13449 1 1385 1.6e-16
c13450 2014 229 2.8e-16
c13451 2217 209 2.54e-16
c13452 2216 208 2.13e-16
c13453 0 262 2.623e-15
c13454 788 201 8.32e-16
c13455 789 200 7.76e-16
c13456 2816 2761 7.99e-16
c13457 2298 2299 1.372e-15
c13458 232 121 3.24e-16
c13459 0 1266 2.957e-15
c13460 227 79 3.34e-16
c13461 37 183 1.94e-16
c13462 31 188 3.34e-16
c13463 2202 0 2.957e-15
c13464 1163 1162 6.77e-16
c13465 1 1697 1.6e-16
c13466 0 591 2.957e-15
c13467 238 157 3.31e-16
c13468 2154 242 2.5e-16
c13469 2155 243 2.8e-16
c13470 411 410 6.77e-16
c13471 422 210 2.8e-16
c13472 0 1084 2.585e-15
c13473 0 1529 2.623e-15
c13474 1 2598 1.999e-15
c13475 1 221 3.749e-15
c13476 1234 220 7.23e-16
c13477 0 168 7.793e-14
c13478 2635 2548 1.96e-16
c13479 2645 2585 1.96e-16
c13480 2351 2545 1.96e-16
c13481 2294 2632 1.96e-16
c13482 8 2503 1.36e-16
c13483 79 205 1.99e-16
c13484 486 487 6.77e-16
c13485 0 1841 2.623e-15
c13486 1847 219 2.5e-16
c13487 2342 0 6.764e-15
c13488 237 132 1.99e-16
c13489 216 111 3.24e-16
c13490 219 115 1.99e-16
c13491 94 188 3.34e-16
c13492 84 189 3.34e-16
c13493 79 200 3.24e-16
c13494 251 186 7.91e-16
c13495 2280 240 2.13e-16
c13496 1 218 3.839e-15
c13497 723 722 6.77e-16
c13498 1648 239 2.13e-16
c13499 1650 237 2.5e-16
c13500 164 27 3.31e-16
c13501 1233 1232 6.77e-16
c13502 2186 194 2.5e-16
c13503 2190 189 2.8e-16
c13504 2189 190 2.14e-16
c13505 2188 191 2.13e-16
c13506 2191 188 2.5e-16
c13507 2492 2438 1.31e-16
c13508 58 211 3.34e-16
c13509 1 1678 1.6e-16
c13510 2508 0 2.2634e-14
c13511 2296 2377 1.58e-16
c13512 2651 2407 1.58e-16
c13513 996 241 8.32e-16
c13514 1 1049 1.6e-16
c13515 52 195 1.99e-16
c13516 1308 1309 6.77e-16
c13517 0 352 2.957e-15
c13518 1 1990 1.6e-16
c13519 902 195 7.91e-16
c13520 2827 2866 2.35e-16
c13521 2719 2855 3.42e-16
c13522 0 1805 2.926e-15
c13523 2244 2245 6.77e-16
c13524 2339 186 2.339e-15
c13525 0 698 2.957e-15
c13526 2260 233 8.32e-16
c13527 220 339 2.8e-16
c13528 221 338 2.5e-16
c13529 793 792 6.77e-16
c13530 840 225 7.77e-16
c13531 1 2841 9.63e-16
c13532 1664 183 2.13e-16
c13533 1666 181 2.5e-16
c13534 0 2117 2.926e-15
c13535 2568 2557 1.6e-16
c13536 2312 2364 1.474e-15
c13537 0 516 2.585e-15
c13538 532 201 8.32e-16
c13539 533 200 7.76e-16
c13540 147 237 3.34e-16
c13541 358 359 6.77e-16
c13542 0 1174 2.623e-15
c13543 0 1010 2.957e-15
c13544 1555 1554 6.77e-16
c13545 868 869 6.77e-16
c13546 42 235 1.99e-16
c13547 2065 2064 6.77e-16
c13548 101 52 1.58e-16
c13549 122 50 8.48e-16
c13550 1 1441 1.6e-16
c13551 0 146 1.14e-16
c13552 1898 242 2.5e-16
c13553 1899 243 2.8e-16
c13554 0 335 2.957e-15
c13555 0 828 2.585e-15
c13556 2856 2858 1.77e-16
c13557 2655 2709 1.58e-16
c13558 970 226 2.5e-16
c13559 971 227 2.8e-16
c13560 1105 1104 6.77e-16
c13561 1385 240 7.91e-16
c13562 69 243 3.34e-16
c13563 14 194 3.34e-16
c13564 2258 0 2.957e-15
c13565 0 328 2.957e-15
c13566 2543 2539 6.13e-16
c13567 2592 2516 2.7e-16
c13568 2320 2301 3.92e-16
c13569 2837 2838 7.17e-16
c13570 1388 1389 6.77e-16
c13571 212 319 2.5e-16
c13572 2046 2047 6.77e-16
c13573 37 238 1.9e-16
c13574 1 827 1.6e-16
c13575 0 1585 2.623e-15
c13576 1591 219 2.5e-16
c13577 2091 210 7.91e-16
c13578 2094 204 7.91e-16
c13579 2092 206 8.32e-16
c13580 2242 212 7.23e-16
c13581 228 100 1.99e-16
c13582 428 429 6.77e-16
c13583 2471 2625 4.18e-16
c13584 504 185 7.77e-16
c13585 0 1566 2.623e-15
c13586 1392 239 2.13e-16
c13587 1394 237 2.5e-16
c13588 1 1139 1.6e-16
c13589 0 2076 2.585e-15
c13590 2454 210 4.83e-16
c13591 243 168 1.99e-16
c13592 0 952 2.957e-15
c13593 1 462 1.6e-16
c13594 0 1895 2.957e-15
c13595 73 225 1.9e-16
c13596 2228 216 2.13e-16
c13597 0 277 2.926e-15
c13598 2548 2469 5.01e-16
c13599 2784 59 4.82e-16
c13600 11 13 4.576e-15
c13601 2675 2651 1.96e-16
c13602 634 186 2.5e-16
c13603 638 181 2.8e-16
c13604 637 182 2.14e-16
c13605 636 183 2.13e-16
c13606 639 180 2.5e-16
c13607 0 1283 2.623e-15
c13608 740 741 6.77e-16
c13609 1 2641 1.411e-15
c13610 1 774 1.6e-16
c13611 1717 217 2.14e-16
c13612 1937 1936 6.77e-16
c13613 1 1284 1.6e-16
c13614 2649 2505 1.96e-16
c13615 2641 2467 1.96e-16
c13616 225 584 7.77e-16
c13617 932 208 2.13e-16
c13618 1408 183 2.13e-16
c13619 1410 181 2.5e-16
c13620 2358 2592 1.96e-16
c13621 2294 2550 1.96e-16
c13622 2645 2503 1.96e-16
c13623 2004 233 8.32e-16
c13624 227 157 1.99e-16
c13625 574 213 2.8e-16
c13626 0 918 2.623e-15
c13627 0 1344 2.957e-15
c13628 69 193 3.31e-16
c13629 73 198 3.31e-16
c13630 63 195 1.99e-16
c13631 52 212 3.34e-16
c13632 761 184 7.91e-16
c13633 2759 2769 1.96e-16
c13634 2634 2318 6.75e-16
c13635 2687 2651 6.04e-16
c13636 2389 2312 5.5e-16
c13637 714 226 2.5e-16
c13638 715 227 2.8e-16
c13639 0 2166 2.623e-15
c13640 2198 202 2.8e-16
c13641 20 228 3.34e-16
c13642 2469 2476 4.77e-16
c13643 210 153 3.34e-16
c13644 205 157 3.34e-16
c13645 226 132 3.34e-16
c13646 2134 234 2.8e-16
c13647 1215 213 7.23e-16
c13648 1214 212 7.91e-16
c13649 1628 231 2.13e-16
c13650 0 2002 2.957e-15
c13651 200 157 1.94e-16
c13652 1835 210 7.91e-16
c13653 1838 204 7.91e-16
c13654 1836 206 8.32e-16
c13655 193 168 1.9e-16
c13656 190 178 3.31e-16
c13657 181 174 1.99e-16
c13658 2651 2492 4.5e-16
c13659 2340 2322 6e-16
c13660 0 369 2.623e-15
c13661 101 63 1.58e-16
c13662 59 62 1.34e-16
c13663 80 78 6.74e-16
c13664 1 883 1.6e-16
c13665 204 132 1.99e-16
c13666 121 188 1.99e-16
c13667 111 183 1.94e-16
c13668 105 195 1.99e-16
c13669 1768 240 2.13e-16
c13670 2855 0 7.531e-15
c13671 0 181 2.3925e-14
c13672 0 860 2.585e-15
c13673 2709 2716 1.6e-16
c13674 1 185 4.406e-15
c13675 0 1639 2.957e-15
c13676 1674 194 2.5e-16
c13677 1678 189 2.8e-16
c13678 1677 190 2.14e-16
c13679 1676 191 2.13e-16
c13680 1679 188 2.5e-16
c13681 1 1195 1.6e-16
c13682 0 2132 2.585e-15
c13683 199 132 1.94e-16
c13684 197 126 3.34e-16
c13685 1757 230 2.14e-16
c13686 14 214 1.9e-16
c13687 2447 2434 4.77e-16
c13688 2766 2635 4.12e-16
c13689 0 1189 2.926e-15
c13690 0 1632 2.957e-15
c13691 958 959 6.77e-16
c13692 1461 217 2.14e-16
c13693 42 242 1.99e-16
c13694 2155 2154 6.77e-16
c13695 0 1951 2.957e-15
c13696 38 46 3.02e-16
c13697 1403 1402 6.77e-16
c13698 537 536 6.77e-16
c13699 226 147 1.99e-16
c13700 1 513 1.6e-16
c13701 0 1320 2.957e-15
c13702 979 221 7.91e-16
c13703 0 1929 2.623e-15
c13704 2225 2224 6.77e-16
c13705 1895 243 2.5e-16
c13706 2630 2552 4.17e-16
c13707 1 1785 1.6e-16
c13708 2788 0 7.752e-15
c13709 1478 1479 6.77e-16
c13710 2296 2634 5.56e-16
c13711 2494 215 3.12e-16
c13712 2641 2639 7.98e-16
c13713 227 326 7.91e-16
c13714 226 327 7.23e-16
c13715 1 1766 1.6e-16
c13716 2250 226 2.5e-16
c13717 2251 227 2.8e-16
c13718 2335 8 5.14e-16
c13719 2471 2545 1.58e-16
c13720 1715 1714 6.77e-16
c13721 516 193 8.32e-16
c13722 517 192 7.76e-16
c13723 147 204 3.34e-16
c13724 1 2097 1.6e-16
c13725 1 143 8.407e-15
c13726 0 1581 2.926e-15
c13727 849 848 6.77e-16
c13728 37 227 3.34e-16
c13729 1730 212 7.23e-16
c13730 2358 2382 7.6e-16
c13731 2298 2322 3.22e-16
c13732 0 474 2.957e-15
c13733 142 195 3.34e-16
c13734 147 199 3.24e-16
c13735 1105 223 7.91e-16
c13736 1430 203 7.91e-16
c13737 0 1910 2.623e-15
c13738 0 292 2.585e-15
c13739 2587 2519 8.43e-16
c13740 0 786 2.957e-15
c13741 215 444 2.13e-16
c13742 2764 2806 1.96e-16
c13743 2652 2294 5.88e-16
c13744 2654 2305 1.96e-16
c13745 2697 2312 1.96e-16
c13746 0 1296 2.957e-15
c13747 1145 185 2.54e-16
c13748 1144 184 2.13e-16
c13749 37 205 1.99e-16
c13750 63 212 3.34e-16
c13751 2217 0 2.623e-15
c13752 2032 238 7.77e-16
c13753 2033 239 7.91e-16
c13754 2034 236 7.23e-16
c13755 2035 237 7.91e-16
c13756 0 604 2.585e-15
c13757 230 115 3.31e-16
c13758 0 1098 2.957e-15
c13759 42 192 1.94e-16
c13760 37 200 3.24e-16
c13761 1 2590 1.637e-15
c13762 1 231 3.42e-15
c13763 2071 203 2.5e-16
c13764 2404 2392 1.6e-16
c13765 236 174 1.99e-16
c13766 1350 1351 6.77e-16
c13767 2351 2462 1.96e-16
c13768 2635 2465 1.96e-16
c13769 0 423 2.957e-15
c13770 1 2628 7.03e-16
c13771 1860 1861 6.77e-16
c13772 0 1361 2.623e-15
c13773 1085 215 7.76e-16
c13774 1402 187 7.23e-16
c13775 52 221 3.34e-16
c13776 2423 198 1.114e-15
c13777 2392 0 6.737e-15
c13778 238 111 1.9e-16
c13779 0 236 2.5335e-14
c13780 2340 2328 3.22e-16
c13781 2338 2331 5.82e-16
c13782 0 735 2.957e-15
c13783 2655 2312 1.717e-15
c13784 0 1245 2.926e-15
c13785 1 79 7.6e-16
c13786 0 2181 2.926e-15
c13787 2462 2397 3.15e-16
c13788 2490 2439 2.77e-16
c13789 1639 243 2.5e-16
c13790 2048 182 7.77e-16
c13791 2049 183 7.91e-16
c13792 2050 180 7.23e-16
c13793 2051 181 7.91e-16
c13794 2838 8 1.465e-15
c13795 212 105 3.34e-16
c13796 2647 2587 1.96e-16
c13797 1 2422 7.39e-16
c13798 1 569 1.6e-16
c13799 1222 226 2.8e-16
c13800 0 2019 2.623e-15
c13801 52 218 1.99e-16
c13802 48 219 3.34e-16
c13803 1 1510 1.6e-16
c13804 2643 2409 3.54e-16
c13805 2312 2574 4.4e-16
c13806 1 2020 1.6e-16
c13807 2505 214 1.7e-16
c13808 1067 1066 6.77e-16
c13809 1831 210 7.23e-16
c13810 1987 213 7.91e-16
c13811 2378 188 1.206e-15
c13812 0 365 2.926e-15
c13813 315 314 6.77e-16
c13814 1 1822 1.6e-16
c13815 233 344 7.77e-16
c13816 849 223 7.91e-16
c13817 0 1654 2.623e-15
c13818 1764 241 8.32e-16
c13819 0 711 2.957e-15
c13820 1732 1733 6.77e-16
c13821 0 1025 2.623e-15
c13822 0 1966 2.623e-15
c13823 2632 0 2.5228e-14
c13824 374 187 7.91e-16
c13825 0 1023 2.957e-15
c13826 2492 226 5.7e-16
c13827 627 626 6.77e-16
c13828 886 186 2.8e-16
c13829 1 2515 1.424e-15
c13830 0 1451 2.623e-15
c13831 143 71 3.31e-16
c13832 1 1452 1.6e-16
c13833 2301 2302 1.149e-15
c13834 2273 0 2.623e-15
c13835 14 216 3.24e-16
c13836 2504 213 2.431e-15
c13837 2506 214 1.114e-15
c13838 212 142 1.99e-16
c13839 2687 2693 1.6e-16
c13840 1 347 1.6e-16
c13841 975 221 7.23e-16
c13842 974 220 7.91e-16
c13843 829 215 7.76e-16
c13844 1 2787 2.708e-15
c13845 0 1778 2.957e-15
c13846 1899 1898 6.77e-16
c13847 2271 0 2.957e-15
c13848 1 1619 1.6e-16
c13849 2639 2590 1.96e-16
c13850 1 659 1.6e-16
c13851 0 1596 2.585e-15
c13852 939 938 6.77e-16
c13853 1114 235 7.23e-16
c13854 0 2090 2.957e-15
c13855 2409 197 5.64e-16
c13856 42 215 3.24e-16
c13857 1 971 1.6e-16
c13858 1929 193 2.54e-16
c13859 1928 192 2.13e-16
c13860 2592 2572 2.59e-16
c13861 2503 2492 3.81e-16
c13862 312 216 2.13e-16
c13863 313 217 2.54e-16
c13864 262 263 6.77e-16
c13865 0 803 2.623e-15
c13866 1459 1458 6.77e-16
c13867 240 79 3.24e-16
c13868 1 804 1.6e-16
c13869 0 1727 2.957e-15
c13870 69 223 1.94e-16
c13871 63 221 3.34e-16
c13872 1575 210 7.23e-16
c13873 2503 2499 6.13e-16
c13874 59 17 2.44e-16
c13875 122 23 7.01e-16
c13876 2647 0 4.9142e-14
c13877 2639 2422 1.96e-16
c13878 2641 2427 1.96e-16
c13879 0 1115 2.623e-15
c13880 1 2364 2.84e-16
c13881 1 1116 1.6e-16
c13882 1508 241 8.32e-16
c13883 2305 2420 2.29e-16
c13884 2364 2467 1.96e-16
c13885 1326 1327 6.77e-16
c13886 2020 240 2.13e-16
c13887 0 438 2.623e-15
c13888 443 218 7.91e-16
c13889 589 222 2.14e-16
c13890 1414 195 7.91e-16
c13891 63 218 1.99e-16
c13892 1084 1085 6.77e-16
c13893 223 168 3.24e-16
c13894 220 163 1.99e-16
c13895 1 1873 1.6e-16
c13896 225 174 3.31e-16
c13897 1529 1528 6.77e-16
c13898 0 750 2.623e-15
c13899 224 90 3.24e-16
c13900 0 1260 2.585e-15
c13901 1345 214 2.54e-16
c13902 1700 208 2.13e-16
c13903 1857 215 7.91e-16
c13904 2196 0 2.585e-15
c13905 2776 143 1.301e-15
c13906 2760 2781 1.58e-16
c13907 2665 2358 3.54e-16
c13908 232 132 3.24e-16
c13909 227 111 3.34e-16
c13910 221 105 3.34e-16
c13911 2149 241 2.14e-16
c13912 0 225 2.4551e-14
c13913 0 1079 2.957e-15
c13914 1604 1605 6.77e-16
c13915 719 221 7.23e-16
c13916 718 220 7.91e-16
c13917 1082 218 2.5e-16
c13918 38 35 2.32e-16
c13919 0 1522 2.957e-15
c13920 2043 187 2.8e-16
c13921 2047 181 7.23e-16
c13922 2045 183 7.76e-16
c13923 0 562 2.957e-15
c13924 2649 2627 1.96e-16
c13925 2318 2625 2.83e-16
c13926 0 1072 2.957e-15
c13927 2632 243 9.65e-16
c13928 419 197 7.91e-16
c13929 418 196 7.23e-16
c13930 417 199 7.91e-16
c13931 416 198 7.77e-16
c13932 143 149 1.34e-16
c13933 644 645 6.77e-16
c13934 1 157 7.6e-16
c13935 1841 1840 6.77e-16
c13936 1 403 1.6e-16
c13937 0 1834 2.957e-15
c13938 198 174 1.9e-16
c13939 2296 2386 2.39e-16
c13940 0 380 2.585e-15
c13941 209 115 1.9e-16
c13942 205 111 1.99e-16
c13943 105 218 1.99e-16
c13944 90 196 1.99e-16
c13945 79 189 1.99e-16
c13946 245 184 7.76e-16
c13947 244 185 8.32e-16
c13948 1 207 3.42e-15
c13949 1 894 1.6e-16
c13950 1 715 1.6e-16
c13951 0 1669 2.926e-15
c13952 164 29 4.85e-16
c13953 1 1225 1.6e-16
c13954 2181 193 2.14e-16
c13955 0 198 2.4415e-14
c13956 111 200 3.24e-16
c13957 115 203 1.99e-16
c13958 2505 216 1.24e-16
c13959 1 202 3.839e-15
c13960 1 2696 1.65e-16
c13961 1 1206 1.6e-16
c13962 0 1981 2.926e-15
c13963 1 1651 1.6e-16
c13964 58 195 3.34e-16
c13965 52 185 1.9e-16
c13966 2550 0 2.2437e-14
c13967 2122 227 7.23e-16
c13968 229 483 7.91e-16
c13969 232 147 1.94e-16
c13970 0 1464 2.957e-15
c13971 985 233 2.54e-16
c13972 1617 222 2.54e-16
c13973 1 1963 1.6e-16
c13974 2364 2434 2.39e-16
c13975 122 97 7.01e-16
c13976 164 84 3.31e-16
c13977 221 142 1.99e-16
c13978 220 136 3.34e-16
c13979 696 217 7.77e-16
c13980 2732 2343 1.224e-15
c13981 0 1333 2.926e-15
c13982 836 224 2.13e-16
c13983 0 1795 2.623e-15
c13984 1 2389 4.41e-16
c13985 1302 1303 6.77e-16
c13986 1 1796 1.6e-16
c13987 2407 2354 4.33e-16
c13988 2256 222 7.77e-16
c13989 2639 2364 1.372e-15
c13990 2649 2643 7.84e-16
c13991 2343 2358 3.044e-15
c13992 2389 2467 1.58e-16
c13993 1 2808 2.88e-16
c13994 1444 208 2.13e-16
c13995 1747 221 7.91e-16
c13996 0 2107 2.623e-15
c13997 122 45 7.01e-16
c13998 101 58 1.58e-16
c13999 2255 221 7.23e-16
c14000 2254 220 7.91e-16
c14001 2296 2625 5.75e-16
c14002 2298 2592 2.44e-16
c14003 0 489 2.623e-15
c14004 142 218 3.34e-16
c14005 1 2108 1.6e-16
c14006 231 609 7.91e-16
c14007 229 228 6.86e-16
c14008 0 1430 2.623e-15
c14009 1 145 2.79e-16
c14010 965 225 2.14e-16
c14011 1940 200 2.13e-16
c14012 143 52 3.26e-16
c14013 14 183 1.94e-16
c14014 0 816 2.957e-15
c14015 2839 2837 6.21e-16
c14016 1 326 1.6e-16
c14017 0 1742 2.623e-15
c14018 1 1315 1.6e-16
c14019 2592 2529 1.34e-16
c14020 2084 209 8.32e-16
c14021 2085 208 7.76e-16
c14022 656 190 7.77e-16
c14023 657 191 7.91e-16
c14024 658 188 7.23e-16
c14025 659 189 7.91e-16
c14026 1 2251 1.6e-16
c14027 0 1128 2.957e-15
c14028 736 230 7.77e-16
c14029 27 219 3.34e-16
c14030 1248 231 2.13e-16
c14031 0 2071 2.957e-15
c14032 1 37 7.6e-16
c14033 0 453 2.926e-15
c14034 240 157 1.94e-16
c14035 953 216 7.91e-16
c14036 516 517 6.77e-16
c14037 1 950 1.6e-16
c14038 8 50 1.96e-16
c14039 1 1395 1.6e-16
c14040 52 231 3.24e-16
c14041 48 230 1.9e-16
c14042 1866 227 7.23e-16
c14043 0 765 2.926e-15
c14044 1352 224 2.13e-16
c14045 0 248 2.957e-15
c14046 2492 2484 1.96e-16
c14047 1 1707 1.6e-16
c14048 828 829 6.77e-16
c14049 2055 194 7.23e-16
c14050 0 579 2.623e-15
c14051 3 213 6.13e-16
c14052 2647 2543 1.96e-16
c14053 2318 2545 2.83e-16
c14054 2649 2548 1.96e-16
c14055 2389 2434 1.96e-16
c14056 1 580 1.6e-16
c14057 69 182 1.9e-16
c14058 63 185 1.9e-16
c14059 0 2030 2.623e-15
c14060 1491 221 7.91e-16
c14061 0 1851 2.623e-15
c14062 1 1342 1.6e-16
c14063 58 212 1.99e-16
c14064 2000 222 7.77e-16
c14065 0 906 2.957e-15
c14066 1 1852 1.6e-16
c14067 2652 0 5.8093e-14
c14068 923 202 7.91e-16
c14069 926 196 7.91e-16
c14070 924 198 8.32e-16
c14071 2389 2639 1.58e-16
c14072 1 2697 5.004e-15
c14073 1684 200 2.13e-16
c14074 0 2163 2.623e-15
c14075 230 349 2.14e-16
c14076 554 211 7.23e-16
c14077 0 1218 2.957e-15
c14078 388 389 6.77e-16
c14079 1066 210 2.5e-16
c14080 1070 205 2.8e-16
c14081 1069 206 2.14e-16
c14082 1068 207 2.13e-16
c14083 1071 204 2.5e-16
c14084 1585 1584 6.77e-16
c14085 1 1059 1.6e-16
c14086 2298 2382 1.58e-16
c14087 194 153 3.34e-16
c14088 189 157 3.34e-16
c14089 0 543 2.957e-15
c14090 2130 221 2.5e-16
c14091 2131 220 2.8e-16
c14092 182 168 3.31e-16
c14093 186 163 3.34e-16
c14094 403 189 7.91e-16
c14095 402 188 7.23e-16
c14096 401 191 7.91e-16
c14097 400 190 7.77e-16
c14098 0 1036 2.585e-15
c14099 0 1481 2.623e-15
c14100 992 231 2.13e-16
c14101 14 238 1.9e-16
c14102 1566 1567 6.77e-16
c14103 0 855 2.957e-15
c14104 105 185 1.9e-16
c14105 2675 2838 3.15e-16
c14106 2697 2845 1.53e-16
c14107 2076 2077 6.77e-16
c14108 143 63 3.26e-16
c14109 1 2655 3.873e-15
c14110 1669 193 2.14e-16
c14111 2284 0 2.585e-15
c14112 2572 2604 1.96e-16
c14113 188 132 1.99e-16
c14114 2755 8 1.241e-15
c14115 2655 2467 1.96e-16
c14116 1 5 2.445e-15
c14117 2299 2590 4.67e-16
c14118 1040 191 2.13e-16
c14119 1042 189 2.5e-16
c14120 1 689 1.6e-16
c14121 1131 242 7.91e-16
c14122 37 240 3.24e-16
c14123 1 1630 1.6e-16
c14124 2296 2545 1.58e-16
c14125 1 2574 4.969e-15
c14126 234 470 2.8e-16
c14127 1119 228 2.5e-16
c14128 1 1001 1.6e-16
c14129 1597 215 7.76e-16
c14130 0 1922 2.957e-15
c14131 2465 2409 1.58e-16
c14132 0 1757 2.926e-15
c14133 63 231 3.24e-16
c14134 1283 1282 6.77e-16
c14135 1737 225 2.54e-16
c14136 2769 0 6.976e-15
c14137 531 530 6.77e-16
c14138 122 127 1.34e-16
c14139 143 105 3.26e-16
c14140 0 635 2.623e-15
c14141 2245 225 2.14e-16
c14142 624 238 7.77e-16
c14143 625 239 7.91e-16
c14144 626 236 7.23e-16
c14145 627 237 7.91e-16
c14146 667 202 7.91e-16
c14147 670 196 7.91e-16
c14148 668 198 8.32e-16
c14149 2665 2666 1.6e-16
c14150 2338 2730 1.14e-16
c14151 2299 2422 2.27e-16
c14152 1 636 1.6e-16
c14153 2322 2311 2.01e-16
c14154 2364 2427 1.96e-16
c14155 2305 2377 1.96e-16
c14156 0 468 2.585e-15
c14157 142 185 3.31e-16
c14158 147 188 3.34e-16
c14159 136 186 1.99e-16
c14160 2461 204 1.206e-15
c14161 232 596 2.13e-16
c14162 814 205 2.8e-16
c14163 813 206 2.14e-16
c14164 812 207 2.13e-16
c14165 815 204 2.5e-16
c14166 69 237 1.99e-16
c14167 8 163 3.47e-16
c14168 8 2594 1.74e-16
c14169 0 287 2.957e-15
c14170 0 780 2.585e-15
c14171 2697 2639 1.96e-16
c14172 843 842 6.77e-16
c14173 1264 239 2.13e-16
c14174 1266 237 2.5e-16
c14175 1306 202 2.5e-16
c14176 1310 197 2.8e-16
c14177 1309 198 2.14e-16
c14178 1308 199 2.13e-16
c14179 1311 196 2.5e-16
c14180 729 232 7.91e-16
c14181 1361 223 7.91e-16
c14182 1 1294 1.6e-16
c14183 2210 0 2.957e-15
c14184 0 265 2.623e-15
c14185 2592 2468 1.28e-16
c14186 2338 0 2.0442e-14
c14187 2760 2804 7.26e-16
c14188 101 13 1.237e-15
c14189 0 599 2.957e-15
c14190 231 105 3.24e-16
c14191 725 233 2.14e-16
c14192 0 1092 2.585e-15
c14193 42 181 3.34e-16
c14194 37 189 1.99e-16
c14195 918 919 6.77e-16
c14196 1237 232 7.76e-16
c14197 0 1537 2.623e-15
c14198 1 234 3.839e-15
c14199 237 168 3.34e-16
c14200 0 592 2.957e-15
c14201 3 222 2.38e-16
c14202 228 126 3.34e-16
c14203 2651 2508 1.96e-16
c14204 424 209 7.77e-16
c14205 0 1535 2.957e-15
c14206 0 1354 2.957e-15
c14207 1398 186 2.8e-16
c14208 1 1091 1.6e-16
c14209 1155 1154 6.77e-16
c14210 58 221 1.99e-16
c14211 2299 2527 1.196e-15
c14212 214 153 1.9e-16
c14213 2655 2639 7.46e-16
c14214 1 414 1.6e-16
c14215 863 228 2.5e-16
c14216 1280 183 2.13e-16
c14217 1282 181 2.5e-16
c14218 0 1847 2.957e-15
c14219 2414 202 4.83e-16
c14220 0 115 7.793e-14
c14221 3 217 2.38e-16
c14222 115 113 3.92e-16
c14223 2335 2293 6.86e-16
c14224 2471 2635 1.58e-16
c14225 2298 2333 1.58e-16
c14226 566 219 7.91e-16
c14227 0 1235 2.623e-15
c14228 1 111 7.6e-16
c14229 1 2716 2.88e-16
c14230 1 726 1.6e-16
c14231 122 31 1.58e-16
c14232 1 1236 1.6e-16
c14233 2166 2167 6.77e-16
c14234 58 218 3.34e-16
c14235 48 209 3.31e-16
c14236 52 207 3.24e-16
c14237 1 1681 1.6e-16
c14238 2705 0 1.65e-16
c14239 2637 2490 1.58e-16
c14240 2343 2572 1.58e-16
c14241 2639 2574 3.54e-16
c14242 2574 240 7.35e-16
c14243 1 2555 1.424e-15
c14244 1001 240 7.91e-16
c14245 52 202 1.99e-16
c14246 48 203 3.34e-16
c14247 1478 226 2.8e-16
c14248 2127 220 2.5e-16
c14249 1 1993 1.6e-16
c14250 2374 190 3.99e-16
c14251 397 191 7.76e-16
c14252 399 189 7.23e-16
c14253 395 195 2.8e-16
c14254 8 136 2.3e-16
c14255 0 870 2.623e-15
c14256 231 142 1.94e-16
c14257 907 194 7.91e-16
c14258 910 188 7.91e-16
c14259 908 190 8.32e-16
c14260 2719 2864 9.38e-16
c14261 2675 2822 7.38e-16
c14262 2734 2733 1.96e-16
c14263 232 340 2.13e-16
c14264 988 230 8.32e-16
c14265 1824 199 2.13e-16
c14266 1826 197 2.5e-16
c14267 2164 184 2.13e-16
c14268 80 81 1.34e-16
c14269 122 94 1.58e-16
c14270 14 227 3.34e-16
c14271 2265 232 7.91e-16
c14272 2732 2294 1.307e-15
c14273 2766 2649 1.58e-16
c14274 2299 2364 7.84e-16
c14275 369 368 6.77e-16
c14276 1 2816 3.53e-16
c14277 1008 239 2.13e-16
c14278 1010 237 2.5e-16
c14279 2236 2237 6.77e-16
c14280 2294 2358 9.37e-16
c14281 2312 2746 1.882e-15
c14282 2305 2735 1.751e-15
c14283 2364 2740 3.92e-16
c14284 1034 195 7.23e-16
c14285 1 2653 2.94e-16
c14286 1 523 1.6e-16
c14287 27 230 1.9e-16
c14288 0 1939 2.623e-15
c14289 80 48 1.59e-16
c14290 59 40 2.44e-16
c14291 14 205 1.99e-16
c14292 0 336 2.957e-15
c14293 1 1940 1.6e-16
c14294 681 208 7.91e-16
c14295 2057 2056 6.77e-16
c14296 1 835 1.6e-16
c14297 0 1772 2.585e-15
c14298 2316 2302 1.6e-16
c14299 1890 229 2.5e-16
c14300 1891 228 2.8e-16
c14301 14 200 3.24e-16
c14302 2548 2541 5.82e-16
c14303 0 648 2.957e-15
c14304 213 323 7.91e-16
c14305 1177 200 7.91e-16
c14306 42 236 3.34e-16
c14307 0 1591 2.957e-15
c14308 1594 218 2.5e-16
c14309 1 1147 1.6e-16
c14310 0 2084 2.585e-15
c14311 2132 2133 6.77e-16
c14312 1733 225 2.14e-16
c14313 1380 1381 6.77e-16
c14314 663 202 7.23e-16
c14315 0 960 2.957e-15
c14316 2623 241 3.61e-16
c14317 2429 0 6.764e-15
c14318 2458 209 3.61e-16
c14319 0 302 2.623e-15
c14320 806 211 7.91e-16
c14321 0 1896 2.957e-15
c14322 69 226 3.34e-16
c14323 1871 220 2.5e-16
c14324 2227 0 2.623e-15
c14325 2545 2480 8.15e-16
c14326 15 13 8.91e-16
c14327 143 129 3.31e-16
c14328 240 111 3.24e-16
c14329 243 115 1.99e-16
c14330 1692 1693 6.77e-16
c14331 1 2228 1.6e-16
c14332 1 777 1.6e-16
c14333 1 241 4.406e-15
c14334 1568 199 2.13e-16
c14335 1570 197 2.5e-16
c14336 213 100 1.99e-16
c14337 2312 2505 2.65e-16
c14338 2649 2465 1.96e-16
c14339 2643 2510 1.96e-16
c14340 2647 2460 1.96e-16
c14341 2318 2462 1.96e-16
c14342 1 2049 1.6e-16
c14343 2471 2469 2.39e-16
c14344 437 216 7.76e-16
c14345 436 217 8.32e-16
c14346 1929 1928 6.77e-16
c14347 587 586 6.77e-16
c14348 73 211 1.99e-16
c14349 69 204 1.99e-16
c14350 63 207 3.24e-16
c14351 1497 233 2.54e-16
c14352 1908 184 2.13e-16
c14353 1 1372 1.6e-16
c14354 2009 232 7.91e-16
c14355 226 168 1.99e-16
c14356 0 921 2.623e-15
c14357 224 178 1.94e-16
c14358 214 576 7.77e-16
c14359 778 195 7.23e-16
c14360 2389 2299 1.568e-15
c14361 69 199 1.94e-16
c14362 63 202 1.99e-16
c14363 871 242 7.23e-16
c14364 870 243 7.91e-16
c14365 1290 194 2.5e-16
c14366 1294 189 2.8e-16
c14367 1293 190 2.14e-16
c14368 1292 191 2.13e-16
c14369 1295 188 2.5e-16
c14370 0 1862 2.623e-15
c14371 2610 2599 1.6e-16
c14372 264 192 2.13e-16
c14373 265 193 2.54e-16
c14374 1 1684 1.6e-16
c14375 2760 2766 2.61e-16
c14376 2788 2770 6.68e-16
c14377 2634 2305 3.54e-16
c14378 2298 2343 5.596e-15
.model nenh nmos
+ level = 2
+   vto = 0.688434   kp = 4.769e-05   gamma = 0.399818
+   phi = 0.85
+
+   cgso = 3.54e-10   cgdo = 3.54e-10
+   rsh = 70   cj = 0.000363
+   mj = 0.916   cjsw = 1.83e-10   mjsw = 0.195
+   tox = 2.15e-08   nsub = 1.79246e+16
+   nss = 3e+10   nfs = 0   tpg = 1
+   xj = 9e-07   ld = -8.3e-08   uo = 683.594
+   ucrit = 200   uexp = 0.0177713
+   vmax = 81459.2   neff = 2.18502
+
+   delta = 2.72869
.model penh pmos
+ level = 2
+   vto = -0.635779   kp = 1.91591e-05   gamma = 0.335224
+   phi = 0.85
+
+   cgso = 4.01e-10   cgdo = 4.01e-10
+   rsh = 164   cj = 0.000442
+   mj = 0.3285   cjsw = 2.34e-10   mjsw = 0.307
+   tox = 2.15e-08   nsub = 6e+17
+   nss = 3e+10   nfs = 85.3597   tpg = -1
+   xj = 1e-09   ld = -2.3e-08   uo = 41.2542
+   ucrit = 50408.2   uexp = 0.0976377
+   vmax = 42755.1   neff = 0.0107262
+
+   delta = 4.72482
Vsclk 6 0 pwl (0 0 1e-09 3.3 5.1e-08 3.3 5.2e-08 0
+ 1.06e-07 0 1.07e-07 3.3 1.57e-07 3.3 1.58e-07 0
+ 2.12e-07 0 2.13e-07 3.3 2.63e-07 3.3 2.64e-07 0
+ 3.18e-07 0 3.19e-07 3.3 3.69e-07 3.3 3.7e-07 0
+ 4.24e-07 0 4.25e-07 3.3 4.75e-07 3.3 )
Vmclk 2843 0 pwl (0 0 5.3e-08 0 5.4e-08 3.3 1.04e-07 3.3
+ 1.05e-07 0 1.06e-07 0 1.59e-07 0 1.6e-07 3.3
+ 2.1e-07 3.3 2.11e-07 0 2.12e-07 0 2.65e-07 0
+ 2.66e-07 3.3 3.16e-07 3.3 3.17e-07 0 3.18e-07 0
+ 3.71e-07 0 3.72e-07 3.3 4.22e-07 3.3 4.23e-07 0
+ 4.24e-07 0 4.77e-07 0 )
Vwdata 2652 0 pwl (0 3.3 1.53e-07 3.3 1.54e-07 0 4.71e-07 0
+ 4.72e-07 3.3 5.77e-07 3.3 )
Vwrite 2757 0 pwl (0 3.3 1.53e-07 3.3 1.54e-07 0 2.59e-07 0
+ 2.6e-07 3.3 3.65e-07 3.3 3.66e-07 0 4.71e-07 0
+ 4.72e-07 3.3 5.77e-07 3.3 )
Vsaddr9 2805 0 pwl (0 0 4.71e-07 0 8.95e-07 0 )
Vsaddr8 2804 0 pwl (0 0 2.59e-07 0 2.6e-07 3.3 4.71e-07 3.3
+ 4.72e-07 0 6.83e-07 0 )
Vsaddr7 2788 0 pwl (0 3.3 2.59e-07 3.3 2.6e-07 0 4.71e-07 0
+ 4.72e-07 3.3 6.83e-07 3.3 )
Vsaddr6 2781 0 pwl (0 0 2.59e-07 0 2.6e-07 3.3 4.71e-07 3.3
+ 4.72e-07 0 6.83e-07 0 )
Vsaddr5 2786 0 pwl (0 0 4.71e-07 0 8.95e-07 0 )
Vsaddr4 2800 0 pwl (0 3.3 2.59e-07 3.3 2.6e-07 0 4.71e-07 0
+ 4.72e-07 3.3 6.83e-07 3.3 )
Vsaddr3 2798 0 pwl (0 0 2.59e-07 0 2.6e-07 3.3 4.71e-07 3.3
+ 4.72e-07 0 6.83e-07 0 )
Vsaddr2 2771 0 pwl (0 3.3 2.59e-07 3.3 2.6e-07 0 4.71e-07 0
+ 4.72e-07 3.3 6.83e-07 3.3 )
Vsaddr1 2769 0 pwl (0 3.3 4.71e-07 3.3 8.95e-07 3.3 )
Vsaddr0 2762 0 pwl (0 0 4.71e-07 0 8.95e-07 0 )
VVdd 1 0 3.3
.options device temp=70
.options dist strategy=1; round-robin distribution strategy
.options linsol type=klu
.print TRAN v(2827) v(6) v(2843) v(2652) v(2757)
*.options limpts=50000 itl5=50000
.TRAN 1e-09 2e-07
*.TRAN 1e-09 4.75e-07
.end
