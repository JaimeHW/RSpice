*****************************************************
* The purpose of this test is to verify that the
* -remeasure command line flag works properly if
* there are .FFT lines in the netlist, but no
* .MEASURE lines.  The <netlistName>.fft0 file
* should be regenerated by the -remeasure operation,
* but no <netlistName>.mt0 file should be made.
*****************************************************
.TRAN 0 1

V1 1 0 1
R1 1 2 1
R2 2 0 1

.PRINT TRAN FORMAT=CSV V(1) V(2)
.OPTIONS FFT FFTOUT=1

.FFT V(1) NP=8 WINDOW=HANN
.FFT V(2) NP=8 WINDOW=HARRIS

.END
