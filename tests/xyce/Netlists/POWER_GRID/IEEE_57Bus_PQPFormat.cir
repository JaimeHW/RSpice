UW ARCHIVE           IEEE 57 Bus Test Case
* This test uses the GenBus model.  However, the Q-limits are not
* being enforced,  and they don't affect the final solution.
* The QMAX and QMIN limits are present in the GenBus instance lines,
* but are commented out.

*********************************************
* Simulation control statements             *
* Slack bus voltage is 1.04                 *
*********************************************
.DC V1VM 1.04 1.04 1

*********************************************
* Bus 1 is the slack bus.  Ammeter          *
* is wired so that current flows into Bus 1 *
*********************************************
V1Th Bus1Th ammBus1P 0V
V1VM Bus1VM ammBus1Q 1.04V
Vamm1P 0 ammBus1P 0V
Vamm1Q 0 ammBus1Q 0V

*********************************************
* Branch Definitions                        *
*********************************************
YPowerGridBranch pg1_2 bus1Th bus2Th bus1VM bus2VM AT=PQP R=0.0083 X=0.028 B=0.129
YPowerGridBranch pg2_3 bus2Th bus3Th bus2VM bus3VM AT=PQP R=0.0298 X=0.085 B=0.0818
YPowerGridBranch pg3_4 bus3Th bus4Th bus3VM bus4VM AT=PQP R=0.0112 X=0.0366 B=0.038
YPowerGridBranch pg4_5 bus4Th bus5Th bus4VM bus5VM AT=PQP R=0.0625 X=0.132 B=0.0258
YPowerGridBranch pg4_6 bus4Th bus6Th bus4VM bus6VM AT=PQP R=0.043 X=0.148 B=0.0348
YPowerGridBranch pg6_7 bus6Th bus7Th bus6VM bus7VM AT=PQP R=0.02 X=0.102 B=0.0276
YPowerGridBranch pg6_8 bus6Th bus8Th bus6VM bus8VM AT=PQP R=0.0339 X=0.173 B=0.047
YPowerGridBranch pg8_9 bus8Th bus9Th bus8VM bus9VM AT=PQP R=0.0099 X=0.0505 B=0.0548
YPowerGridBranch pg9_10 bus9Th bus10Th bus9VM bus10VM AT=PQP R=0.0369 X=0.1679 B=0.044
YPowerGridBranch pg9_11 bus9Th bus11Th bus9VM bus11VM AT=PQP R=0.0258 X=0.0848 B=0.0218
YPowerGridBranch pg9_12 bus9Th bus12Th bus9VM bus12VM AT=PQP R=0.0648 X=0.295 B=0.0772
YPowerGridBranch pg9_13 bus9Th bus13Th bus9VM bus13VM AT=PQP R=0.0481 X=0.158 B=0.0406
YPowerGridBranch pg13_14 bus13Th bus14Th bus13VM bus14VM AT=PQP R=0.0132 X=0.0434 B=0.011
YPowerGridBranch pg13_15 bus13Th bus15Th bus13VM bus15VM AT=PQP R=0.0269 X=0.0869 B=0.023
YPowerGridBranch pg1_15 bus1Th bus15Th bus1VM bus15VM AT=PQP R=0.0178 X=0.091 B=0.0988
YPowerGridBranch pg1_16 bus1Th bus16Th bus1VM bus16VM AT=PQP R=0.0454 X=0.206 B=0.0546
YPowerGridBranch pg1_17 bus1Th bus17Th bus1VM bus17VM AT=PQP R=0.0238 X=0.108 B=0.0286
YPowerGridBranch pg3_15 bus3Th bus15Th bus3VM bus15VM AT=PQP R=0.0162 X=0.053 B=0.0544
YPowerGridBranch pg5_6 bus5Th bus6Th bus5VM bus6VM AT=PQP R=0.0302 X=0.0641 B=0.0124
YPowerGridBranch pg7_8 bus7Th bus8Th bus7VM bus8VM AT=PQP R=0.0139 X=0.0712 B=0.0194
YPowerGridBranch pg10_12 bus10Th bus12Th bus10VM bus12VM AT=PQP R=0.0277 X=0.1262 B=0.0328
YPowerGridBranch pg11_13 bus11Th bus13Th bus11VM bus13VM AT=PQP R=0.0223 X=0.0732 B=0.0188
YPowerGridBranch pg12_13 bus12Th bus13Th bus12VM bus13VM AT=PQP R=0.0178 X=0.058 B=0.0604
YPowerGridBranch pg12_16 bus12Th bus16Th bus12VM bus16VM AT=PQP R=0.018 X=0.0813 B=0.0216
YPowerGridBranch pg12_17 bus12Th bus17Th bus12VM bus17VM AT=PQP R=0.0397 X=0.179 B=0.0476
YPowerGridBranch pg14_15 bus14Th bus15Th bus14VM bus15VM AT=PQP R=0.0171 X=0.0547 B=0.0148
YPowerGridBranch pg18_19 bus18Th bus19Th bus18VM bus19VM AT=PQP R=0.461 X=0.685 B=0
YPowerGridBranch pg19_20 bus19Th bus20Th bus19VM bus20VM AT=PQP R=0.283 X=0.434 B=0
YPowerGridBranch pg21_22 bus21Th bus22Th bus21VM bus22VM AT=PQP R=0.0736 X=0.117 B=0
YPowerGridBranch pg22_23 bus22Th bus23Th bus22VM bus23VM AT=PQP R=0.0099 X=0.0152 B=0
YPowerGridBranch pg23_24 bus23Th bus24Th bus23VM bus24VM AT=PQP R=0.166 X=0.256 B=0.0084
YPowerGridBranch pg24_25 bus24Th bus25Th bus24VM bus25VM AT=PQP R=0 X=1.182 B=0
YPowerGridBranch pg24_25a bus24Th bus25Th bus24VM bus25VM AT=PQP R=0 X=1.23 B=0
YPowerGridBranch pg26_27 bus26Th bus27Th bus26VM bus27VM AT=PQP R=0.165 X=0.254 B=0
YPowerGridBranch pg27_28 bus27Th bus28Th bus27VM bus28VM AT=PQP R=0.0618 X=0.0954 B=0
YPowerGridBranch pg28_29 bus28Th bus29Th bus28VM bus29VM AT=PQP R=0.0418 X=0.0587 B=0
YPowerGridBranch pg25_30 bus25Th bus30Th bus25VM bus30VM AT=PQP R=0.135 X=0.202 B=0
YPowerGridBranch pg30_31 bus30Th bus31Th bus30VM bus31VM AT=PQP R=0.326 X=0.497 B=0
YPowerGridBranch pg31_32 bus31Th bus32Th bus31VM bus32VM AT=PQP R=0.507 X=0.755 B=0
YPowerGridBranch pg32_33 bus32Th bus33Th bus32VM bus33VM AT=PQP R=0.0392 X=0.036 B=0
YPowerGridBranch pg34_35 bus34Th bus35Th bus34VM bus35VM AT=PQP R=0.052 X=0.078 B=0.0032
YPowerGridBranch pg35_36 bus35Th bus36Th bus35VM bus36VM AT=PQP R=0.043 X=0.0537 B=0.0016
YPowerGridBranch pg36_37 bus36Th bus37Th bus36VM bus37VM AT=PQP R=0.029 X=0.0366 B=0
YPowerGridBranch pg37_38 bus37Th bus38Th bus37VM bus38VM AT=PQP R=0.0651 X=0.1009 B=0.002
YPowerGridBranch pg37_39 bus37Th bus39Th bus37VM bus39VM AT=PQP R=0.0239 X=0.0379 B=0
YPowerGridBranch pg36_40 bus36Th bus40Th bus36VM bus40VM AT=PQP R=0.03 X=0.0466 B=0
YPowerGridBranch pg22_38 bus22Th bus38Th bus22VM bus38VM AT=PQP R=0.0192 X=0.0295 B=0
YPowerGridBranch pg41_42 bus41Th bus42Th bus41VM bus42VM AT=PQP R=0.207 X=0.352 B=0
YPowerGridBranch pg41_43 bus41Th bus43Th bus41VM bus43VM AT=PQP R=0 X=0.412 B=0
YPowerGridBranch pg38_44 bus38Th bus44Th bus38VM bus44VM AT=PQP R=0.0289 X=0.0585 B=0.002
YPowerGridBranch pg46_47 bus46Th bus47Th bus46VM bus47VM AT=PQP R=0.023 X=0.068 B=0.0032
YPowerGridBranch pg47_48 bus47Th bus48Th bus47VM bus48VM AT=PQP R=0.0182 X=0.0233 B=0
YPowerGridBranch pg48_49 bus48Th bus49Th bus48VM bus49VM AT=PQP R=0.0834 X=0.129 B=0.0048
YPowerGridBranch pg49_50 bus49Th bus50Th bus49VM bus50VM AT=PQP R=0.0801 X=0.128 B=0
YPowerGridBranch pg50_51 bus50Th bus51Th bus50VM bus51VM AT=PQP R=0.1386 X=0.22 B=0
YPowerGridBranch pg29_52 bus29Th bus52Th bus29VM bus52VM AT=PQP R=0.1442 X=0.187 B=0
YPowerGridBranch pg52_53 bus52Th bus53Th bus52VM bus53VM AT=PQP R=0.0762 X=0.0984 B=0
YPowerGridBranch pg53_54 bus53Th bus54Th bus53VM bus54VM AT=PQP R=0.1878 X=0.232 B=0
YPowerGridBranch pg54_55 bus54Th bus55Th bus54VM bus55VM AT=PQP R=0.1732 X=0.2265 B=0
YPowerGridBranch pg44_45 bus44Th bus45Th bus44VM bus45VM AT=PQP R=0.0624 X=0.1242 B=0.004
YPowerGridBranch pg56_41 bus56Th bus41Th bus56VM bus41VM AT=PQP R=0.553 X=0.549 B=0
YPowerGridBranch pg56_42 bus56Th bus42Th bus56VM bus42VM AT=PQP R=0.2125 X=0.354 B=0
YPowerGridBranch pg57_56 bus57Th bus56Th bus57VM bus56VM AT=PQP R=0.174 X=0.26 B=0
YPowerGridBranch pg38_49 bus38Th bus49Th bus38VM bus49VM AT=PQP R=0.115 X=0.177 B=0.003
YPowerGridBranch pg38_48 bus38Th bus48Th bus38VM bus48VM AT=PQP R=0.0312 X=0.0482 B=0

*******************************************************
* Transformer Definitions                             *
* There is a parallel branch between buses 4 and 18.  *
* All transformers have a fixed tap-ratio, with PS=0. *
*******************************************************
YPowerGridTransformer pg4_18 bus4Th bus18Th bus4VM bus18VM AT=PQP R=0 X=0.555 TR=0.97
YPowerGridTransformer pg4_18a bus4Th bus18Th bus4VM bus18VM AT=PQP R=0 X=0.43 TR=0.978
YPowerGridTransformer pg21_20 bus21Th bus20Th bus21VM bus20VM AT=PQP R=0 X=0.7767 TR=1.043
YPowerGridTransformer pg24_26 bus24Th bus26Th bus24VM bus26VM AT=PQP R=0 X=0.0473 TR=1.043
YPowerGridTransformer pg7_29 bus7Th bus29Th bus7VM bus29VM AT=PQP R=0 X=0.0648 TR=0.967
YPowerGridTransformer pg34_32 bus34Th bus32Th bus34VM bus32VM AT=PQP R=0 X=0.953 TR=0.975
YPowerGridTransformer pg11_41 bus11Th bus41Th bus11VM bus41VM AT=PQP R=0 X=0.749 TR=0.955
YPowerGridTransformer pg15_45 bus15Th bus45Th bus15VM bus45VM AT=PQP R=0 X=0.1042 TR=0.955
YPowerGridTransformer pg14_46 bus14Th bus46Th bus14VM bus46VM AT=PQP R=0 X=0.0735 TR=0.9
YPowerGridTransformer pg10_51 bus10Th bus51Th bus10VM bus51VM AT=PQP R=0 X=0.0712 TR=0.93
YPowerGridTransformer pg13_49 bus13Th bus49Th bus13VM bus49VM AT=PQP R=0 X=0.191 TR=0.895
YPowerGridTransformer pg11_43 bus11Th bus43Th bus11VM bus43VM AT=PQP R=0 X=0.153 TR=0.958
YPowerGridTransformer pg40_56 bus40Th bus56Th bus40VM bus56VM AT=PQP R=0 X=1.195 TR=0.958
YPowerGridTransformer pg39_57 bus39Th bus57Th bus39VM bus57VM AT=PQP R=0 X=1.355 TR=0.98
YPowerGridTransformer pg9_55 bus9Th bus55Th bus9VM bus55VM AT=PQP R=0 X=0.1205 TR=0.94

*********************************************
* Bus Shunt Definitions                     *
*********************************************
YPowerGridBusShunt pg18_GND bus18Th 0 bus18VM 0 AT=PQP G=0 B=0.1
YPowerGridBusShunt pg25_GND bus25Th 0 bus25VM 0 AT=PQP G=0 B=0.059
YPowerGridBusShunt pg53_GND bus53Th 0 bus53VM 0 AT=PQP G=0 B=0.063

********************************************************************
* GenBus models used rather than I sources. Ammeters wired so that *
* positive power (P,Q) flows into bus.                             *
* The QMAX and QMIN values are all commented out.  So, the         *
* Q limits are not being enforced in this test case.               *
********************************************************************
YPGGB pvb2 bus2Th ammbus2P bus2VM ammBus2Q AT=PQP VM=1.01 P=0
* + QMAX=0.5 QMIN=-0.17
Vamm2P 0 ammBus2P 0V
Vamm2Q 0 ammBus2Q 0V

YPGGB pvb3 bus3Th ammbus3P bus3VM ammBus3Q AT=PQP VM=0.985 P=0.4
*+ QMAX=0.6 QMIN=-0.1
Vamm3P 0 ammBus3P 0V
Vamm3Q 0 ammBus3Q 0V

YPGGB pvb6 bus6Th ammbus6P bus6VM ammBus6Q AT=PQP VM=0.98 P=0
*+ QMAX=0.25 QMin=-0.08
Vamm6P 0 ammBus6P 0V
Vamm6Q 0 ammBus6Q 0V

YPGGB pvb8 bus8Th ammbus8P bus8VM ammBus8Q AT=PQP VM=1.005 P=4.5
*+ QMAX=2 QMin=-1.4
Vamm8P 0 ammBus8P 0V
Vamm8Q 0 ammBus8Q 0V

YPGGB pvb9 bus9Th ammbus9P bus9VM ammBus9Q AT=PQP VM=0.98 P=0
*+ QMAX=0.09 QMin=-0.03
Vamm9P 0 ammBus9P 0V
Vamm9Q 0 ammBus9Q 0V

YPGGB pvb12 bus12Th ammbus12P bus12VM ammBus12Q AT=PQP VM=1.015 P=3.1
*+ QMAX=1.55 QMin=-1.5
Vamm12P 0 ammBus12P 0V
Vamm12Q 0 ammBus12Q 0V

*********************************************
* Load Definitions                          *
*********************************************
ILoad1P bus1Th 0 0.55
ILoad1Q bus1VM 0 0.17
ILoad2P bus2Th 0 0.03
ILoad2Q bus2VM 0 0.88
ILoad3P bus3Th 0 0.41
ILoad3Q bus3VM 0 0.21
ILoad4P bus4Th 0 0
ILoad4Q bus4VM 0 0
ILoad5P bus5Th 0 0.13
ILoad5Q bus5VM 0 0.04
ILoad6P bus6Th 0 0.75
ILoad6Q bus6VM 0 0.02
ILoad7P bus7Th 0 0
ILoad7Q bus7VM 0 0
ILoad8P bus8Th 0 1.5
ILoad8Q bus8VM 0 0.22
ILoad9P bus9Th 0 1.21
ILoad9Q bus9VM 0 0.26
ILoad10P bus10Th 0 0.05
ILoad10Q bus10VM 0 0.02
ILoad11P bus11Th 0 0
ILoad11Q bus11VM 0 0
ILoad12P bus12Th 0 3.77
ILoad12Q bus12VM 0 0.24
ILoad13P bus13Th 0 0.18
ILoad13Q bus13VM 0 0.023
ILoad14P bus14Th 0 0.105
ILoad14Q bus14VM 0 0.053
ILoad15P bus15Th 0 0.22
ILoad15Q bus15VM 0 0.05
ILoad16P bus16Th 0 0.43
ILoad16Q bus16VM 0 0.03
ILoad17P bus17Th 0 0.42
ILoad17Q bus17VM 0 0.08
ILoad18P bus18Th 0 0.272
ILoad18Q bus18VM 0 0.098
ILoad19P bus19Th 0 0.033
ILoad19Q bus19VM 0 0.006
ILoad20P bus20Th 0 0.023
ILoad20Q bus20VM 0 0.01
ILoad21P bus21Th 0 0
ILoad21Q bus21VM 0 0
ILoad22P bus22Th 0 0
ILoad22Q bus22VM 0 0
ILoad23P bus23Th 0 0.063
ILoad23Q bus23VM 0 0.021
ILoad24P bus24Th 0 0
ILoad24Q bus24VM 0 0
ILoad25P bus25Th 0 0.063
ILoad25Q bus25VM 0 0.032
ILoad26P bus26Th 0 0
ILoad26Q bus26VM 0 0
ILoad27P bus27Th 0 0.093
ILoad27Q bus27VM 0 0.005
ILoad28P bus28Th 0 0.046
ILoad28Q bus28VM 0 0.023
ILoad29P bus29Th 0 0.17
ILoad29Q bus29VM 0 0.026
ILoad30P bus30Th 0 0.036
ILoad30Q bus30VM 0 0.018
ILoad31P bus31Th 0 0.058
ILoad31Q bus31VM 0 0.029
ILoad32P bus32Th 0 0.016
ILoad32Q bus32VM 0 0.008
ILoad33P bus33Th 0 0.038
ILoad33Q bus33VM 0 0.019
ILoad34P bus34Th 0 0
ILoad34Q bus34VM 0 0
ILoad35P bus35Th 0 0.06
ILoad35Q bus35VM 0 0.03
ILoad36P bus36Th 0 0
ILoad36Q bus36VM 0 0
ILoad37P bus37Th 0 0
ILoad37Q bus37VM 0 0
ILoad38P bus38Th 0 0.14
ILoad38Q bus38VM 0 0.07
ILoad39P bus39Th 0 0
ILoad39Q bus39VM 0 0
ILoad40P bus40Th 0 0
ILoad40Q bus40VM 0 0
ILoad41P bus41Th 0 0.063
ILoad41Q bus41VM 0 0.03
ILoad42P bus42Th 0 0.071
ILoad42Q bus42VM 0 0.044
ILoad43P bus43Th 0 0.02
ILoad43Q bus43VM 0 0.01
ILoad44P bus44Th 0 0.12
ILoad44Q bus44VM 0 0.018
ILoad45P bus45Th 0 0
ILoad45Q bus45VM 0 0
ILoad46P bus46Th 0 0
ILoad46Q bus46VM 0 0
ILoad47P bus47Th 0 0.297
ILoad47Q bus47VM 0 0.116
ILoad48P bus48Th 0 0
ILoad48Q bus48VM 0 0
ILoad49P bus49Th 0 0.18
ILoad49Q bus49VM 0 0.085
ILoad50P bus50Th 0 0.21
ILoad50Q bus50VM 0 0.105
ILoad51P bus51Th 0 0.18
ILoad51Q bus51VM 0 0.053
ILoad52P bus52Th 0 0.049
ILoad52Q bus52VM 0 0.022
ILoad53P bus53Th 0 0.2
ILoad53Q bus53VM 0 0.1
ILoad54P bus54Th 0 0.041
ILoad54Q bus54VM 0 0.014
ILoad55P bus55Th 0 0.068
ILoad55Q bus55VM 0 0.034
ILoad56P bus56Th 0 0.076
ILoad56Q bus56VM 0 0.022
ILoad57P bus57Th 0 0.067
ILoad57Q bus57VM 0 0.02

*************************************************************
* .NODESET used to enforce "flat start" for PQ formulations *
*************************************************************
.NODESET V(bus1Th)=0 V(bus1VM)=1.04 V(bus2Th)=0 V(bus2VM)=1 V(bus3Th)=0 V(bus3VM)=1
+ V(bus4Th)=0 V(bus4VM)=1 V(bus5Th)=0 V(bus5VM)=1 V(bus6Th)=0 V(bus6VM)=1
+ V(bus7Th)=0 V(bus7VM)=1 V(bus8Th)=0 V(bus8VM)=1 V(bus9Th)=0 V(bus9VM)=1
+ V(bus10Th)=0 V(bus10VM)=1 V(bus11Th)=0 V(bus11VM)=1 V(bus12Th)=0 V(bus12VM)=1
+ V(bus13Th)=0 V(bus13VM)=1 V(bus14Th)=0 V(bus14VM)=1 V(bus15Th)=0 V(bus15VM)=1
+ V(bus16Th)=0 V(bus16VM)=1 V(bus17Th)=0 V(bus17VM)=1 V(bus18Th)=0 V(bus18VM)=1
+ V(bus19Th)=0 V(bus19VM)=1 V(bus20Th)=0 V(bus20VM)=1 V(bus21Th)=0 V(bus21VM)=1
+ V(bus22Th)=0 V(bus22VM)=1 V(bus23Th)=0 V(bus23VM)=1 V(bus24Th)=0 V(bus24VM)=1
+ V(bus25Th)=0 V(bus25VM)=1 V(bus26Th)=0 V(bus26VM)=1 V(bus27Th)=0 V(bus27VM)=1
+ V(bus28Th)=0 V(bus28VM)=1 V(bus29Th)=0 V(bus29VM)=1 V(bus30Th)=0 V(bus30VM)=1
+ V(bus31Th)=0 V(bus31VM)=1 V(bus32Th)=0 V(bus32VM)=1 V(bus33Th)=0 V(bus33VM)=1
+ V(bus34Th)=0 V(bus34VM)=1 V(bus35Th)=0 V(bus35VM)=1 V(bus36Th)=0 V(bus36VM)=1
+ V(bus37Th)=0 V(bus37VM)=1 V(bus38Th)=0 V(bus38VM)=1 V(bus39Th)=0 V(bus39VM)=1
+ V(bus40Th)=0 V(bus40VM)=1 V(bus41Th)=0 V(bus41VM)=1 V(bus42Th)=0 V(bus42VM)=1
+ V(bus43Th)=0 V(bus43VM)=1 V(bus44Th)=0 V(bus44VM)=1 V(bus45Th)=0 V(bus45VM)=1
+ V(bus46Th)=0 V(bus46VM)=1 V(bus47Th)=0 V(bus47VM)=1 V(bus48Th)=0 V(bus48VM)=1
+ V(bus49Th)=0 V(bus49VM)=1 V(bus50Th)=0 V(bus50VM)=1 V(bus51Th)=0 V(bus51VM)=1
+ V(bus52Th)=0 V(bus52VM)=1 V(bus53Th)=0 V(bus53VM)=1 V(bus54Th)=0 V(bus54VM)=1
+ V(bus55Th)=0 V(bus55VM)=1 V(bus56Th)=0 V(bus56VM)=1 V(bus57Th)=0 V(bus57VM)=1

*********************************************
* Output Statements                         *
*********************************************
.PRINT DC width=10 precision=6
+ V(bus1Th) V(bus1VM) V(bus2Th) V(bus2VM) V(bus3Th) V(bus3VM) V(bus4Th) V(bus4VM)
+ V(bus5Th) V(bus5VM) V(bus6Th) V(bus6VM) V(bus7Th) V(bus7VM) V(bus8Th) V(bus8VM)
+ V(bus9Th) V(bus9VM) V(bus10Th) V(bus10VM) V(bus11Th) V(bus11VM) V(bus12Th) V(bus12VM)
+ V(bus13Th) V(bus13VM) V(bus14Th) V(bus14VM) V(bus15Th) V(bus15VM) V(bus16Th) V(bus16VM)
+ V(bus17Th) V(bus17VM) V(bus18Th) V(bus18VM) V(bus19Th) V(bus19VM) V(bus20Th) V(bus20VM)
+ V(bus21Th) V(bus21VM) V(bus22Th) V(bus22VM) V(bus23Th) V(bus23VM) V(bus24Th) V(bus24VM)
+ V(bus25Th) V(bus25VM) V(bus26Th) V(bus26VM) V(bus27Th) V(bus27VM) V(bus28Th) V(bus28VM)
+ V(bus29Th) V(bus29VM) V(bus30Th) V(bus30VM) V(bus31Th) V(bus31VM) V(bus32Th) V(bus32VM)
+ V(bus33Th) V(bus33VM) V(bus34Th) V(bus34VM) V(bus35Th) V(bus35VM) V(bus36Th) V(bus36VM)
+ V(bus37Th) V(bus37VM) V(bus38Th) V(bus38VM) V(bus39Th) V(bus39VM) V(bus40Th) V(bus40VM)
+ V(bus41Th) V(bus41VM) V(bus42Th) V(bus42VM) V(bus43Th) V(bus43VM) V(bus44Th) V(bus44VM)
+ V(bus45Th) V(bus45VM) V(bus46Th) V(bus46VM) V(bus47Th) V(bus47VM) V(bus48Th) V(bus48VM)
+ V(bus49Th) V(bus49VM) V(bus50Th) V(bus50VM) V(bus51Th) V(bus51VM) V(bus52Th) V(bus52VM)
+ V(bus53Th) V(bus53VM) V(bus54Th) V(bus54VM) V(bus55Th) V(bus55VM) V(bus56Th) V(bus56VM)
+ V(bus57Th) V(bus57VM)
+ I(Vamm1P) I(Vamm1Q) I(Vamm2P) I(Vamm2Q) I(Vamm3P) I(Vamm3Q)
+ I(ILoad4P) I(ILoad4Q) I(ILoad5P) I(ILoad5Q) I(Vamm6P) I(Vamm6Q)
+ I(ILoad7P) I(ILoad7Q) I(Vamm8P) I(Vamm8Q) I(Vamm9P) I(Vamm9Q)
+ I(ILoad10P) I(ILoad10Q) I(ILoad11P) I(ILoad11Q) I(Vamm12P) I(Vamm12Q)
+ I(ILoad13P) I(ILoad13Q) I(ILoad14P) I(ILoad14Q) I(ILoad15P) I(ILoad15Q)
+ I(ILoad16P) I(ILoad16Q) I(ILoad17P) I(ILoad17Q) I(ILoad18P) I(ILoad18Q)
+ I(ILoad19P) I(ILoad19Q) I(ILoad20P) I(ILoad20Q) I(ILoad21P) I(ILoad21Q)
+ I(ILoad22P) I(ILoad22Q) I(ILoad23P) I(ILoad23Q) I(ILoad24P) I(ILoad24Q)
+ I(ILoad25P) I(ILoad25Q) I(ILoad26P) I(ILoad26Q) I(ILoad27P) I(ILoad27Q)
+ I(ILoad28P) I(ILoad28Q) I(ILoad29P) I(ILoad29Q) I(ILoad30P) I(ILoad30Q)
+ I(ILoad31P) I(ILoad31Q) I(ILoad32P) I(ILoad32Q) I(ILoad33P) I(ILoad33Q)
+ I(ILoad34P) I(ILoad34Q) I(ILoad35P) I(ILoad35Q) I(ILoad36P) I(ILoad36Q)
+ I(ILoad37P) I(ILoad37Q) I(ILoad38P) I(ILoad38Q) I(ILoad39P) I(ILoad39Q)
+ I(ILoad40P) I(ILoad40Q) I(ILoad41P) I(ILoad41Q) I(ILoad42P) I(ILoad42Q)
+ I(ILoad43P) I(ILoad43Q) I(ILoad44P) I(ILoad44Q) I(ILoad45P) I(ILoad45Q)
+ I(ILoad46P) I(ILoad46Q) I(ILoad47P) I(ILoad47Q) I(ILoad48P) I(ILoad48Q)
+ I(ILoad49P) I(ILoad49Q) I(ILoad50P) I(ILoad50Q) I(ILoad51P) I(ILoad51Q)
+ I(ILoad52P) I(ILoad52Q) I(ILoad53P) I(ILoad53Q) I(ILoad54P) I(ILoad54Q)
+ I(ILoad55P) I(ILoad55Q) I(ILoad56P) I(ILoad56Q) I(ILoad57P) I(ILoad57Q)

.end
