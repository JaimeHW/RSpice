*****************==== 17-Stage CMOS RO ====*******************
***********Benchmarking Implementation of BSIM3 by Jane Xi 11/05/2002.
*
* Eric Keiter: This is a ring oscillator.  For normal operation, it
* requires an initial condition to be set.  Otherwise, all the signals
* stay completely flat for the entire simulation.
*
.include Xmodelcard.nmos
.include Xmodelcard.pmos

vdd 1 0 2.0
mp1 3 2 1 1 p1 l=0.35u w=10u ad=5p pd=6u as=5p ps=6u
mn1 3 2 0 0 n1 l=0.35u w=5u
mp2 4 3 1 1 p1 l=0.35u w=10u ad=5p pd=6u as=5p ps=6u
mn2 4 3 0 0 n1 l=0.35u w=5u ad=5p pd=6u as=5p ps=6u
mp3 5 4 1 1 p1 l=0.35u w=10u ad=5p pd=6u as=5p ps=6u
mn3 5 4 0 0 n1 l=0.35u w=5u ad=5p pd=6u as=5p ps=6u
mp4 6 5 1 1 p1 l=0.35u w=10u ad=5p pd=6u as=5p ps=6u
mn4 6 5 0 0 n1 l=0.35u w=5u ad=5p pd=6u as=5p ps=6u
mp5 7 6 1 1 p1 l=0.35u w=10u ad=5p pd=6u as=5p ps=6u
mn5 7 6 0 0 n1 l=0.35u w=5u ad=5p pd=6u as=5p ps=6u
mp6 8 7 1 1 p1 l=0.35u w=10u ad=5p pd=6u as=5p ps=6u
mn6 8 7 0 0 n1 l=0.35u w=5u ad=5p pd=6u as=5p ps=6u
mp7 9 8 1 1 p1 l=0.35u w=10u ad=5p pd=6u as=5p ps=6u
mn7 9 8 0 0 n1 l=0.35u w=5u ad=5p pd=6u as=5p ps=6u
mp8 10 9 1 1 p1 l=0.35u w=10u ad=5p pd=6u as=5p ps=6u
mn8 10 9 0 0 n1 l=0.35u w=5u ad=5p pd=6u as=5p ps=6u
mp9 11 10 1 1 p1 l=0.35u w=10u ad=5p pd=6u as=5p ps=6u
mn9 11 10 0 0 n1 l=0.35u w=5u ad=5p pd=6u as=5p ps=6u
mp10 12 11 1 1 p1 l=0.35u w=10u ad=5p pd=6u as=5p ps=6u
mn10 12 11 0 0 n1 l=0.35u w=5u ad=5p pd=6u as=5p ps=6u

mp11 13 12 1 1 p1 l=0.35u w=10u ad=5p pd=6u as=5p ps=6u
mn11 13 12 0 0 n1 l=0.35u w=5u ad=5p pd=6u as=5p ps=6u
mp12 14 13 1 1 p1 l=0.35u w=10u ad=5p pd=6u as=5p ps=6u
mn12 14 13 0 0 n1 l=0.35u w=5u ad=5p
mp13 15 14 1 1 p1 l=0.35u w=10u ad=5p pd=6u as=5p ps=6u
mn13 15 14 0 0 n1 l=0.35u w=5u ad=5p pd=6u as=5p ps=6u
mp14 16 15 1 1 p1 l=0.35u w=10u ad=5p ps=6u
mn14 16 15 0 0 n1 l=0.35u w=5u ad=5p pd=6u as=5p ps=6u
mp15 17 16 1 1 p1 l=0.35u w=10u ad=5p pd=6u as=5p ps=6u
mn15 17 16 0 0 n1 l=0.35u w=5u ad=5p as=5p ps=6u
mp16 18 17 1 1 p1 l=0.35u w=10u ad=5p pd=6u as=5p ps=6u
mn16 18 17 0 0 n1 l=0.35u w=5u pd=6u as=5p ps=6u
mp17 2  18 1 1 p1 l=0.35u w=10u ad=5p pd=6u as=5p ps=6u
mn17 2  18 0 0 n1 l=0.35u w=5u ad=5p pd=6u as=5p ps=6u
c1 18 0 .1p

*original spice3 style ic statements.
.ic v(2)=2.0 v(3)=0.0

.tran .1ns 8ns
.options timeint reltol=1.0e-3
.print tran precision=12 width=21 {v(2)+1.0} {v(5)+1.0}
.end
