res_noise.cir - noise analysis: resistor divider, amp, and lp filter
*
* Test .NOISE with data=<tableName>.  The Total Noise Integral values
* should be printed to stdout.
*
.global_param mag=1
.global_param phase=0.1
*
*
* resistor divider
v1  1 0 dc 5.0 ac  {mag} {phase}
r1  1 2 100k
r2  2 0 100k
*
* amp and lp filter
eamp  3 0 2 0 1
rlp1  3 4 100
clp1  4 0 1.59nf
*

.noise  v(4)  v1  data=table
*.noise  v(4)  v1  dec 5 1 1e5
.print noise V(4) {log(onoise)} {log(inoise)}

*.ac data=table
*.print ac V(4)

* values in table match values generated by DEC sweep
* on commented out .NOISE line
.data table
+ mag phase freq
+1  0.1  1.00000000e+00
+1  0.1  1.58489319e+00
+1  0.1  2.51188643e+00
+1  0.1  3.98107171e+00
+1  0.1  6.30957344e+00
+1  0.1  1.00000000e+01
+1  0.1  1.58489319e+01
+1  0.1  2.51188643e+01
+1  0.1  3.98107171e+01
+1  0.1  6.30957344e+01
+1  0.1  1.00000000e+02
+1  0.1  1.58489319e+02
+1  0.1  2.51188643e+02
+1  0.1  3.98107171e+02
+1  0.1  6.30957344e+02
+1  0.1  1.00000000e+03
+1  0.1  1.58489319e+03
+1  0.1  2.51188643e+03
+1  0.1  3.98107171e+03
+1  0.1  6.30957344e+03
+1  0.1  1.00000000e+04
+1  0.1  1.58489319e+04
+1  0.1  2.51188643e+04
+1  0.1  3.98107171e+04
+1  0.1  6.30957344e+04
+1  0.1  1.00000000e+05
.enddata
