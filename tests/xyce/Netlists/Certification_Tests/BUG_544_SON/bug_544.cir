Crossbar Memristor Network of 100x100
********************************************************************************
*************************** File Information ***********************************
********************************************************************************
* Created on            : PC
* Created               : Wed Oct 15 12:30:59 2014
* Application Type      : Crossbar
* Memristor Model       : Biolek's model
* Netlist Type          : Xyce
* Analysis type         : Transient Analysis
* Time Step             : 1 ms
* Number of Simulations : 10000
* Rows (inputs)         : 100
* Columns (outputs)     : 100
* Number of Memristors  : 10000

********************************************************************************
******************* Global Nodes for all Sub-circuits **************************
********************************************************************************
Vdd     $G_VPlus  0    DC   10
Vss     $G_VMinus 0    DC  -10

********************************************************************************
********************* Parameters for Signal Source(s) **************************
********************************************************************************
* Sources from File     : PatchOneSource.txt
********************************************************************************
* SINE    : V1 1 0 DC 0 SIN(OFF AMPL FREQ TD THETA)
* PULSE   : V1 1 0 DC 0 PULSE(VLO VHI TD TR TF PW PER)
* DC      : V1 1 0 1.2 DC
* TRIANGLE: V1 1 0 DC 0 PULSE(VLO VHI TD TR TF PW PER)
* SQUARE  : V1 1 0 DC 0 PULSE(VLO VHI TD TR TF PW PER)
********************************************************************************
* DC    : V1 = 0.737255,  V2 = 0.709804,  V3 = 0.694118,  V4 = 0.698039
*         V5 = 0.658824,  V6 = 0.619608,  V7 = 0.713725,  V8 = 0.694118
*         V9 = 0.65098,  V10 = 0.662745,  V11 = 0.615686,  V12 = 0.572549
*         V13 = 0.67451,  V14 = 0.666667,  V15 = 0.635294,  V16 = 0.611765
*         V17 = 0.560784,  V18 = 0.541176,  V19 = 0.639216,  V20 = 0.639216
*         V21 = 0.6,  V22 = 0.584314,  V23 = 0.545098,  V24 = 0.537255
*         V25 = 0.666667,  V26 = 0.635294,  V27 = 0.588235,  V28 = 0.568627
*         V29 = 0.537255,  V30 = 0.513725,  V31 = 0.654902,  V32 = 0.619608
*         V33 = 0.572549,  V34 = 0.560784,  V35 = 0.521569,  V36 = 0.501961
*         V37 = 0.737255,  V38 = 0.709804,  V39 = 0.694118,  V40 = 0.698039
*         V41 = 0.658824,  V42 = 0.619608,  V43 = 0.713725,  V44 = 0.694118
*         V45 = 0.65098,  V46 = 0.662745,  V47 = 0.615686,  V48 = 0.572549
*         V49 = 0.67451,  V50 = 0.666667,  V51 = 0.635294,  V52 = 0.611765
*         V53 = 0.560784,  V54 = 0.541176,  V55 = 0.639216,  V56 = 0.639216
*         V57 = 0.6,  V58 = 0.584314,  V59 = 0.545098,  V60 = 0.537255
*         V61 = 0.666667,  V62 = 0.635294,  V63 = 0.588235,  V64 = 0.568627
*         V65 = 0.537255,  V66 = 0.513725,  V67 = 0.654902,  V68 = 0.619608
*         V69 = 0.572549,  V70 = 0.560784,  V71 = 0.521569,  V72 = 0.501961
*         V73 = 0.737255,  V74 = 0.709804,  V75 = 0.694118,  V76 = 0.698039
*         V77 = 0.658824,  V78 = 0.619608,  V79 = 0.713725,  V80 = 0.694118
*         V81 = 0.65098,  V82 = 0.662745,  V83 = 0.615686,  V84 = 0.572549
*         V85 = 0.67451,  V86 = 0.666667,  V87 = 0.635294,  V88 = 0.611765
*         V89 = 0.560784,  V90 = 0.541176,  V91 = 0.639216,  V92 = 0.639216
*         V93 = 0.6,  V94 = 0.584314,  V95 = 0.545098,  V96 = 0.537255
*         V97 = 0.666667,  V98 = 0.635294,  V99 = 0.588235,  V100 = 0.568627
********************************************************************************
V1      1    0    DC 0.737255
V2      2    0    DC 0.709804
V3      3    0    DC 0.694118
V4      4    0    DC 0.698039
V5      5    0    DC 0.658824
V6      6    0    DC 0.619608
V7      7    0    DC 0.713725
V8      8    0    DC 0.694118
V9      9    0    DC 0.65098
V10     10   0    DC 0.662745
V11     11   0    DC 0.615686
V12     12   0    DC 0.572549
V13     13   0    DC 0.67451
V14     14   0    DC 0.666667
V15     15   0    DC 0.635294
V16     16   0    DC 0.611765
V17     17   0    DC 0.560784
V18     18   0    DC 0.541176
V19     19   0    DC 0.639216
V20     20   0    DC 0.639216
V21     21   0    DC 0.6
V22     22   0    DC 0.584314
V23     23   0    DC 0.545098
V24     24   0    DC 0.537255
V25     25   0    DC 0.666667
V26     26   0    DC 0.635294
V27     27   0    DC 0.588235
V28     28   0    DC 0.568627
V29     29   0    DC 0.537255
V30     30   0    DC 0.513725
V31     31   0    DC 0.654902
V32     32   0    DC 0.619608
V33     33   0    DC 0.572549
V34     34   0    DC 0.560784
V35     35   0    DC 0.521569
V36     36   0    DC 0.501961
V37     37   0    DC 0.737255
V38     38   0    DC 0.709804
V39     39   0    DC 0.694118
V40     40   0    DC 0.698039
V41     41   0    DC 0.658824
V42     42   0    DC 0.619608
V43     43   0    DC 0.713725
V44     44   0    DC 0.694118
V45     45   0    DC 0.65098
V46     46   0    DC 0.662745
V47     47   0    DC 0.615686
V48     48   0    DC 0.572549
V49     49   0    DC 0.67451
V50     50   0    DC 0.666667
V51     51   0    DC 0.635294
V52     52   0    DC 0.611765
V53     53   0    DC 0.560784
V54     54   0    DC 0.541176
V55     55   0    DC 0.639216
V56     56   0    DC 0.639216
V57     57   0    DC 0.6
V58     58   0    DC 0.584314
V59     59   0    DC 0.545098
V60     60   0    DC 0.537255
V61     61   0    DC 0.666667
V62     62   0    DC 0.635294
V63     63   0    DC 0.588235
V64     64   0    DC 0.568627
V65     65   0    DC 0.537255
V66     66   0    DC 0.513725
V67     67   0    DC 0.654902
V68     68   0    DC 0.619608
V69     69   0    DC 0.572549
V70     70   0    DC 0.560784
V71     71   0    DC 0.521569
V72     72   0    DC 0.501961
V73     73   0    DC 0.737255
V74     74   0    DC 0.709804
V75     75   0    DC 0.694118
V76     76   0    DC 0.698039
V77     77   0    DC 0.658824
V78     78   0    DC 0.619608
V79     79   0    DC 0.713725
V80     80   0    DC 0.694118
V81     81   0    DC 0.65098
V82     82   0    DC 0.662745
V83     83   0    DC 0.615686
V84     84   0    DC 0.572549
V85     85   0    DC 0.67451
V86     86   0    DC 0.666667
V87     87   0    DC 0.635294
V88     88   0    DC 0.611765
V89     89   0    DC 0.560784
V90     90   0    DC 0.541176
V91     91   0    DC 0.639216
V92     92   0    DC 0.639216
V93     93   0    DC 0.6
V94     94   0    DC 0.584314
V95     95   0    DC 0.545098
V96     96   0    DC 0.537255
V97     97   0    DC 0.666667
V98     98   0    DC 0.635294
V99     99   0    DC 0.588235
V100    100  0    DC 0.568627

********************************************************************************
********************* General Options for Xyce *********************************
********************************************************************************
* AztecOO should be the linear solver for parallel. However, AztecOO doesn't
* work at this point. KLU is selected for linear solver instead.
********************************************************************************
.OPTIONS LINSOL TYPE=KLU
*.OPTIONS LINSOL use_ifpack_factory=1

********************************************************************************
******************* Parameters for transient analysis **************************
********************************************************************************
* Analysis type         : Transient Analysis
* Time Step             : 1ms
* Number of Simulations : 10000
* Start Transient Time  : 0ms
* Stop Transient Time   : 10000ms (Time Step * Number of Simulation)
* Transient Option      : .TRAN TSTEP TSTOP  <TSTART <TMAX(step)> > <UIC>
********************************************************************************
.TRAN 1ms 2ms 0ms 1ms

********************************************************************************
*************** the sub circuit for the memristor model ************************
********************************************************************************
********************************************************************************
* Biolek, Zden¥k, Dalibor Biolek, and Viera Biolkova. "SPICE model of memristor
* with nonlinear dopant drift." Radioengineering 18, no. 2 (2009): 210-214.
********************************************************************************
.SUBCKT memristor Plus Minus PARAMs: InitStateVar=0.314465409

********************************************************************************
* Ron, Roff - Resistance in ON / OFF States
* Rinit		- Resistance at T=0
* D			- Width of the thin film
* uv		- Migration coefficient
* p			- Parameter of the WINDOW-function for modeling nonlinear
*			  boundary conditions
* x			- W/D Ratio, W is the actual width of the doped area (from 0 to D)
********************************************************************************
.PARAM 	Ron   = 100
.PARAM	Roff  = 16K
.PARAM	Rinit = 11K
.PARAM	D     = 10e-9
.PARAM	uv    = 10e-15
.PARAM	p     = 1
********************************************************************************
* Note: the initial value for the state variable is:
*	w = (Roff-Rinit)/(Roff-Ron) = 0.314465409
********************************************************************************
* STATE EQUATION MODELING *
********************************************************************************
Gx 		0 		x 		value = {I(Emem)*(uv*Ron/D**2)*f(V(x))}
Cx 		x 		0 		1 ; IC = {InitStateVar}
Raux 	x 		0 		1T
********************************************************************************
.IC V(x) = {InitStateVar}
********************************************************************************
* RESISTIVE PORT MODELING *
Emem 	plus 	aux 	value = {-I(Emem)*V(x)*(Roff-Ron)}
R1		aux 	minus 	{Roff}
********************************************************************************
* WINDOW FUNCTION MODELING *
.FUNC f(x) {1-(2*x-1)**2}
********************************************************************************
.ENDS memristor

********************************************************************************
********************* Op Amp LM741 Sub-circuit *********************************
********************************************************************************
* (C) National Semiconductor, Inc.
* Models developed and under copyright by:
* National Semiconductor, Inc.

********************************************************************************
* Legal Notice: This material is intended for free software
* support. The file may be copied, and distributed; however,
* reselling the material is illegal

********************************************************************************
* For ordering or technical information on these models,
* contact:
* National Semiconductor's Customer Response Center
*                 7:00 A.M.--7:00 P.M.  U.S. Central Time
*                                (800) 272-9959
* For Applications support, contact the Internet address:
*  amps-apps@galaxy.nsc.com

********************************************************************************
*LM741 OPERATIONAL AMPLIFIER MACRO-MODEL
********************************************************************************
*
* connections:      non-inverting input
*                   |   inverting input
*                   |   |   positive power supply
*                   |   |   |   negative power supply
*                   |   |   |   |   output
*                   |   |   |   |   |
*                   |   |   |   |   |
********************************************************************************
.SUBCKT LM741       1   2  99  50  28
********************************************************************************
*Features:
*Improved performance over industry standards
*Plug-in replacement for LM709,LM201,MC1439,748
*Input and output overload protection
********************************************************************************
*                       | Vdd (99)
*                   |   |
*     invert (1) ---|-
*                   |        *--- Out (28)
* non-invert (2) ---|+
*                   |   |
*                       | Vss (50)
********************************************************************************
* SUBCKT LM741 inv non-inv Vdd Vss Out
********************************************************************************
********************************************************************************
**************************** INPUT STAGE ***************************************
********************************************************************************
IOS 2 1 20N
*^Input offset current
R1 1 3 250K
R2 3 2 250K
I1 4 50 100U
R3 5 99 517
R4 6 99 517
Q1 5 2 4 QX
Q2 6 7 4 QX
*Fp2=2.55 MHz
C4 5 6 60.3614P

********************************************************************************
*********************** COMMON MODE EFFECT *************************************
********************************************************************************
I2 99 50 1.6MA
*^Quiescent supply current
EOS 7 1 POLY(1) 16 49 1E-3 1
*Input offset voltage.^
R8 99 49 40K
R9 49 50 40K

********************************************************************************
*********************** OUTPUT VOLTAGE LIMITING ********************************
********************************************************************************
V2 99 8 1.63
D1 9 8 DX
D2 10 9 DX
V3 10 50 1.63

********************************************************************************
***************************** SECOND STAGE *************************************
********************************************************************************
EH 99 98 99 49 1
G1 98 9 5 6 2.1E-3
*Fp1=5 Hz
R5 98 9 95.493MEG
C3 98 9 333.33P

********************************************************************************
***************************** POLE STAGE ***************************************
********************************************************************************
*Fp=30 MHz
G3 98 15 9 49 1E-6
R12 98 15 1MEG
C5 98 15 5.3052E-15
********************************************************************************
*********************** COMMON-MODE ZERO STAGE *********************************
********************************************************************************
*Fpcm=300 Hz
G4 98 16 3 49 3.1623E-8
L2 98 17 530.5M
R13 17 16 1K

********************************************************************************
**************************** OUTPUT STAGE **************************************
********************************************************************************
F6 50 99 POLY(1) V6 450U 1
E1 99 23 99 15 1
R16 24 23 25
D5 26 24 DX
V6 26 22 0.65V
R17 23 25 25
D6 25 27 DX
V7 22 27 0.65V
V5 22 21 0.18V
D4 21 15 DX
V4 20 22 0.18V
D3 15 20 DX
L3 22 28 100P
RL3 22 28 100K

********************************************************************************
****************************** MODELS USED *************************************
********************************************************************************
.MODEL DX D(IS=1E-15)
.MODEL QX NPN(BF=625)
********************************************************************************
.ENDS LM741

********************************************************************************
********************** Output Module Sub-circuit *******************************
********************************************************************************
.SUBCKT OutputModule 1 2 PARAMS: Rval=10.0
********************************************************************************
RT    1  2  {Rval}
XOp   0  1   $G_VPlus   $G_VMinus  2 LM741
********************************************************************************
.ENDS OutputModule

********************************************************************************
************************ Network Connection ************************************
********************************************************************************
* Network Type          : Crossbar
* Rows (inputs)         : 100
* Columns (outputs)     : 100
* Number of Modules     : 10000 (X is the memristor subcircuit)
* Output Module         : Xo (R = 100)
* Weights from File     : RandomNormalWeights.csv
********************************************************************************
*------------------- Column 1 -------------------------------------------------
X0      1    101  memristor PARAMS: InitStateVar=0.427425
X100    2    101  memristor PARAMS: InitStateVar=0.173535
X200    3    101  memristor PARAMS: InitStateVar=0.136974
X300    4    101  memristor PARAMS: InitStateVar=0.309758
X400    5    101  memristor PARAMS: InitStateVar=0.206455
X500    6    101  memristor PARAMS: InitStateVar=0.428842
X600    7    101  memristor PARAMS: InitStateVar=0.264785
X700    8    101  memristor PARAMS: InitStateVar=0.384165
X800    9    101  memristor PARAMS: InitStateVar=0.205138
X900    10   101  memristor PARAMS: InitStateVar=0.241587
X1000   11   101  memristor PARAMS: InitStateVar=0.2797
X1100   12   101  memristor PARAMS: InitStateVar=0.428461
X1200   13   101  memristor PARAMS: InitStateVar=0.160462
X1300   14   101  memristor PARAMS: InitStateVar=0.332829
X1400   15   101  memristor PARAMS: InitStateVar=0.390145
X1500   16   101  memristor PARAMS: InitStateVar=0.104352
X1600   17   101  memristor PARAMS: InitStateVar=0.347064
X1700   18   101  memristor PARAMS: InitStateVar=0.319647
X1800   19   101  memristor PARAMS: InitStateVar=0.392776
X1900   20   101  memristor PARAMS: InitStateVar=0.299194
X2000   21   101  memristor PARAMS: InitStateVar=0.451955
X2100   22   101  memristor PARAMS: InitStateVar=0.299848
X2200   23   101  memristor PARAMS: InitStateVar=0.341382
X2300   24   101  memristor PARAMS: InitStateVar=0.197418
X2400   25   101  memristor PARAMS: InitStateVar=0.233296
X2500   26   101  memristor PARAMS: InitStateVar=0.2781
X2600   27   101  memristor PARAMS: InitStateVar=0.373274
X2700   28   101  memristor PARAMS: InitStateVar=0.299613
X2800   29   101  memristor PARAMS: InitStateVar=0.181551
X2900   30   101  memristor PARAMS: InitStateVar=0.453208
X3000   31   101  memristor PARAMS: InitStateVar=0.187906
X3100   32   101  memristor PARAMS: InitStateVar=0.368648
X3200   33   101  memristor PARAMS: InitStateVar=0.393871
X3300   34   101  memristor PARAMS: InitStateVar=0.34644
X3400   35   101  memristor PARAMS: InitStateVar=0.198584
X3500   36   101  memristor PARAMS: InitStateVar=0.366029
X3600   37   101  memristor PARAMS: InitStateVar=0.389287
X3700   38   101  memristor PARAMS: InitStateVar=0.238149
X3800   39   101  memristor PARAMS: InitStateVar=0.182258
X3900   40   101  memristor PARAMS: InitStateVar=0.41687
X4000   41   101  memristor PARAMS: InitStateVar=0.39135
X4100   42   101  memristor PARAMS: InitStateVar=0.210389
X4200   43   101  memristor PARAMS: InitStateVar=0.10432
X4300   44   101  memristor PARAMS: InitStateVar=0.26001
X4400   45   101  memristor PARAMS: InitStateVar=0.500547
X4500   46   101  memristor PARAMS: InitStateVar=0.351968
X4600   47   101  memristor PARAMS: InitStateVar=0.387127
X4700   48   101  memristor PARAMS: InitStateVar=0.418868
X4800   49   101  memristor PARAMS: InitStateVar=0.258529
X4900   50   101  memristor PARAMS: InitStateVar=0.280593
X5000   51   101  memristor PARAMS: InitStateVar=0.123573
X5100   52   101  memristor PARAMS: InitStateVar=0.37176
X5200   53   101  memristor PARAMS: InitStateVar=0.284559
X5300   54   101  memristor PARAMS: InitStateVar=0.280849
X5400   55   101  memristor PARAMS: InitStateVar=0.280262
X5500   56   101  memristor PARAMS: InitStateVar=0.0984165
X5600   57   101  memristor PARAMS: InitStateVar=0.328609
X5700   58   101  memristor PARAMS: InitStateVar=0.193871
X5800   59   101  memristor PARAMS: InitStateVar=0.188521
X5900   60   101  memristor PARAMS: InitStateVar=0.371149
X6000   61   101  memristor PARAMS: InitStateVar=0.362605
X6100   62   101  memristor PARAMS: InitStateVar=0.292833
X6200   63   101  memristor PARAMS: InitStateVar=0.44443
X6300   64   101  memristor PARAMS: InitStateVar=0.0402598
X6400   65   101  memristor PARAMS: InitStateVar=0.407927
X6500   66   101  memristor PARAMS: InitStateVar=0.35985
X6600   67   101  memristor PARAMS: InitStateVar=0.359442
X6700   68   101  memristor PARAMS: InitStateVar=0.447699
X6800   69   101  memristor PARAMS: InitStateVar=0.317091
X6900   70   101  memristor PARAMS: InitStateVar=0.410067
X7000   71   101  memristor PARAMS: InitStateVar=0.250419
X7100   72   101  memristor PARAMS: InitStateVar=0.342573
X7200   73   101  memristor PARAMS: InitStateVar=0.173386
X7300   74   101  memristor PARAMS: InitStateVar=0.285688
X7400   75   101  memristor PARAMS: InitStateVar=0.243574
X7500   76   101  memristor PARAMS: InitStateVar=0.364076
X7600   77   101  memristor PARAMS: InitStateVar=0.156674
X7700   78   101  memristor PARAMS: InitStateVar=0.278507
X7800   79   101  memristor PARAMS: InitStateVar=0.329048
X7900   80   101  memristor PARAMS: InitStateVar=0.221002
X8000   81   101  memristor PARAMS: InitStateVar=0.299554
X8100   82   101  memristor PARAMS: InitStateVar=0.380616
X8200   83   101  memristor PARAMS: InitStateVar=0.329024
X8300   84   101  memristor PARAMS: InitStateVar=0.180964
X8400   85   101  memristor PARAMS: InitStateVar=0.331076
X8500   86   101  memristor PARAMS: InitStateVar=0.375772
X8600   87   101  memristor PARAMS: InitStateVar=0.315622
X8700   88   101  memristor PARAMS: InitStateVar=0.200767
X8800   89   101  memristor PARAMS: InitStateVar=0.344718
X8900   90   101  memristor PARAMS: InitStateVar=0.143867
X9000   91   101  memristor PARAMS: InitStateVar=0.143929
X9100   92   101  memristor PARAMS: InitStateVar=0.425249
X9200   93   101  memristor PARAMS: InitStateVar=0.321357
X9300   94   101  memristor PARAMS: InitStateVar=0.179385
X9400   95   101  memristor PARAMS: InitStateVar=0.492708
X9500   96   101  memristor PARAMS: InitStateVar=0.216569
X9600   97   101  memristor PARAMS: InitStateVar=0.21584
X9700   98   101  memristor PARAMS: InitStateVar=0.379009
X9800   99   101  memristor PARAMS: InitStateVar=0.336559
X9900   100  101  memristor PARAMS: InitStateVar=0.377806
Xo1     101  102  OutputModule PARAMS: Rval=100
*------------------- Column 2 -------------------------------------------------
X1      1    103  memristor PARAMS: InitStateVar=0.225793
X101    2    103  memristor PARAMS: InitStateVar=0.219919
X201    3    103  memristor PARAMS: InitStateVar=0.2672
X301    4    103  memristor PARAMS: InitStateVar=0.319623
X401    5    103  memristor PARAMS: InitStateVar=0.301392
X501    6    103  memristor PARAMS: InitStateVar=0.378385
X601    7    103  memristor PARAMS: InitStateVar=0.339802
X701    8    103  memristor PARAMS: InitStateVar=0.35857
X801    9    103  memristor PARAMS: InitStateVar=0.0586587
X901    10   103  memristor PARAMS: InitStateVar=0.35401
X1001   11   103  memristor PARAMS: InitStateVar=0.204042
X1101   12   103  memristor PARAMS: InitStateVar=0.175373
X1201   13   103  memristor PARAMS: InitStateVar=0.292504
X1301   14   103  memristor PARAMS: InitStateVar=0.274836
X1401   15   103  memristor PARAMS: InitStateVar=0.309132
X1501   16   103  memristor PARAMS: InitStateVar=0.324507
X1601   17   103  memristor PARAMS: InitStateVar=0.18625
X1701   18   103  memristor PARAMS: InitStateVar=0.246583
X1801   19   103  memristor PARAMS: InitStateVar=0.165094
X1901   20   103  memristor PARAMS: InitStateVar=0.233592
X2001   21   103  memristor PARAMS: InitStateVar=0.21557
X2101   22   103  memristor PARAMS: InitStateVar=0.357091
X2201   23   103  memristor PARAMS: InitStateVar=0.563832
X2301   24   103  memristor PARAMS: InitStateVar=0.398009
X2401   25   103  memristor PARAMS: InitStateVar=0.264121
X2501   26   103  memristor PARAMS: InitStateVar=0.168698
X2601   27   103  memristor PARAMS: InitStateVar=0.454098
X2701   28   103  memristor PARAMS: InitStateVar=0.398591
X2801   29   103  memristor PARAMS: InitStateVar=0.19286
X2901   30   103  memristor PARAMS: InitStateVar=0.415064
X3001   31   103  memristor PARAMS: InitStateVar=0.274849
X3101   32   103  memristor PARAMS: InitStateVar=0.386617
X3201   33   103  memristor PARAMS: InitStateVar=0.358045
X3301   34   103  memristor PARAMS: InitStateVar=0.37193
X3401   35   103  memristor PARAMS: InitStateVar=0.320971
X3501   36   103  memristor PARAMS: InitStateVar=0.566132
X3601   37   103  memristor PARAMS: InitStateVar=0.339841
X3701   38   103  memristor PARAMS: InitStateVar=0.273656
X3801   39   103  memristor PARAMS: InitStateVar=0.243697
X3901   40   103  memristor PARAMS: InitStateVar=0.498432
X4001   41   103  memristor PARAMS: InitStateVar=0.289176
X4101   42   103  memristor PARAMS: InitStateVar=0.271765
X4201   43   103  memristor PARAMS: InitStateVar=0.454341
X4301   44   103  memristor PARAMS: InitStateVar=0.184273
X4401   45   103  memristor PARAMS: InitStateVar=0.171502
X4501   46   103  memristor PARAMS: InitStateVar=0.344419
X4601   47   103  memristor PARAMS: InitStateVar=0.293232
X4701   48   103  memristor PARAMS: InitStateVar=0.454875
X4801   49   103  memristor PARAMS: InitStateVar=0.396607
X4901   50   103  memristor PARAMS: InitStateVar=0.253576
X5001   51   103  memristor PARAMS: InitStateVar=0.20862
X5101   52   103  memristor PARAMS: InitStateVar=0.168372
X5201   53   103  memristor PARAMS: InitStateVar=0.256977
X5301   54   103  memristor PARAMS: InitStateVar=0.313407
X5401   55   103  memristor PARAMS: InitStateVar=0.105572
X5501   56   103  memristor PARAMS: InitStateVar=0.166289
X5601   57   103  memristor PARAMS: InitStateVar=0.219829
X5701   58   103  memristor PARAMS: InitStateVar=0.299052
X5801   59   103  memristor PARAMS: InitStateVar=0.310662
X5901   60   103  memristor PARAMS: InitStateVar=0.504619
X6001   61   103  memristor PARAMS: InitStateVar=0.280321
X6101   62   103  memristor PARAMS: InitStateVar=0.32763
X6201   63   103  memristor PARAMS: InitStateVar=0.327383
X6301   64   103  memristor PARAMS: InitStateVar=0.297725
X6401   65   103  memristor PARAMS: InitStateVar=0.327485
X6501   66   103  memristor PARAMS: InitStateVar=0.256518
X6601   67   103  memristor PARAMS: InitStateVar=0.214458
X6701   68   103  memristor PARAMS: InitStateVar=0.288267
X6801   69   103  memristor PARAMS: InitStateVar=0.19027
X6901   70   103  memristor PARAMS: InitStateVar=0.256299
X7001   71   103  memristor PARAMS: InitStateVar=0.310737
X7101   72   103  memristor PARAMS: InitStateVar=0.317835
X7201   73   103  memristor PARAMS: InitStateVar=0.268626
X7301   74   103  memristor PARAMS: InitStateVar=0.339609
X7401   75   103  memristor PARAMS: InitStateVar=0.221779
X7501   76   103  memristor PARAMS: InitStateVar=0.191476
X7601   77   103  memristor PARAMS: InitStateVar=0.195666
X7701   78   103  memristor PARAMS: InitStateVar=0.252155
X7801   79   103  memristor PARAMS: InitStateVar=0.353075
X7901   80   103  memristor PARAMS: InitStateVar=0.445741
X8001   81   103  memristor PARAMS: InitStateVar=0.368095
X8101   82   103  memristor PARAMS: InitStateVar=0.248353
X8201   83   103  memristor PARAMS: InitStateVar=0.280486
X8301   84   103  memristor PARAMS: InitStateVar=0.233141
X8401   85   103  memristor PARAMS: InitStateVar=0.277589
X8501   86   103  memristor PARAMS: InitStateVar=0.281424
X8601   87   103  memristor PARAMS: InitStateVar=0.368266
X8701   88   103  memristor PARAMS: InitStateVar=0.265337
X8801   89   103  memristor PARAMS: InitStateVar=0.493626
X8901   90   103  memristor PARAMS: InitStateVar=0.425294
X9001   91   103  memristor PARAMS: InitStateVar=0.443337
X9101   92   103  memristor PARAMS: InitStateVar=0.260421
X9201   93   103  memristor PARAMS: InitStateVar=-0.0279298
X9301   94   103  memristor PARAMS: InitStateVar=0.499437
X9401   95   103  memristor PARAMS: InitStateVar=0.184553
X9501   96   103  memristor PARAMS: InitStateVar=0.402251
X9601   97   103  memristor PARAMS: InitStateVar=0.454317
X9701   98   103  memristor PARAMS: InitStateVar=0.254806
X9801   99   103  memristor PARAMS: InitStateVar=0.371915
X9901   100  103  memristor PARAMS: InitStateVar=0.217925
Xo2     103  104  OutputModule PARAMS: Rval=100
*------------------- Column 3 -------------------------------------------------
X2      1    105  memristor PARAMS: InitStateVar=0.396565
X102    2    105  memristor PARAMS: InitStateVar=0.444275
X202    3    105  memristor PARAMS: InitStateVar=0.38656
X302    4    105  memristor PARAMS: InitStateVar=0.310181
X402    5    105  memristor PARAMS: InitStateVar=0.27076
X502    6    105  memristor PARAMS: InitStateVar=0.376363
X602    7    105  memristor PARAMS: InitStateVar=0.340172
X702    8    105  memristor PARAMS: InitStateVar=0.211824
X802    9    105  memristor PARAMS: InitStateVar=0.338093
X902    10   105  memristor PARAMS: InitStateVar=0.311007
X1002   11   105  memristor PARAMS: InitStateVar=0.42511
X1102   12   105  memristor PARAMS: InitStateVar=0.346156
X1202   13   105  memristor PARAMS: InitStateVar=0.446586
X1302   14   105  memristor PARAMS: InitStateVar=0.0762495
X1402   15   105  memristor PARAMS: InitStateVar=0.405039
X1502   16   105  memristor PARAMS: InitStateVar=0.427267
X1602   17   105  memristor PARAMS: InitStateVar=0.148618
X1702   18   105  memristor PARAMS: InitStateVar=0.261004
X1802   19   105  memristor PARAMS: InitStateVar=0.133054
X1902   20   105  memristor PARAMS: InitStateVar=0.381209
X2002   21   105  memristor PARAMS: InitStateVar=0.181972
X2102   22   105  memristor PARAMS: InitStateVar=0.251918
X2202   23   105  memristor PARAMS: InitStateVar=0.139178
X2302   24   105  memristor PARAMS: InitStateVar=0.235285
X2402   25   105  memristor PARAMS: InitStateVar=0.266647
X2502   26   105  memristor PARAMS: InitStateVar=0.205785
X2602   27   105  memristor PARAMS: InitStateVar=0.465839
X2702   28   105  memristor PARAMS: InitStateVar=0.0639741
X2802   29   105  memristor PARAMS: InitStateVar=0.393834
X2902   30   105  memristor PARAMS: InitStateVar=0.404048
X3002   31   105  memristor PARAMS: InitStateVar=0.241858
X3102   32   105  memristor PARAMS: InitStateVar=0.361119
X3202   33   105  memristor PARAMS: InitStateVar=0.434852
X3302   34   105  memristor PARAMS: InitStateVar=0.181499
X3402   35   105  memristor PARAMS: InitStateVar=0.279555
X3502   36   105  memristor PARAMS: InitStateVar=0.568273
X3602   37   105  memristor PARAMS: InitStateVar=0.331794
X3702   38   105  memristor PARAMS: InitStateVar=0.369538
X3802   39   105  memristor PARAMS: InitStateVar=0.449998
X3902   40   105  memristor PARAMS: InitStateVar=0.326718
X4002   41   105  memristor PARAMS: InitStateVar=0.414819
X4102   42   105  memristor PARAMS: InitStateVar=0.221379
X4202   43   105  memristor PARAMS: InitStateVar=0.207195
X4302   44   105  memristor PARAMS: InitStateVar=0.229655
X4402   45   105  memristor PARAMS: InitStateVar=0.272423
X4502   46   105  memristor PARAMS: InitStateVar=0.129463
X4602   47   105  memristor PARAMS: InitStateVar=0.390991
X4702   48   105  memristor PARAMS: InitStateVar=0.467704
X4802   49   105  memristor PARAMS: InitStateVar=0.130326
X4902   50   105  memristor PARAMS: InitStateVar=0.392769
X5002   51   105  memristor PARAMS: InitStateVar=0.165978
X5102   52   105  memristor PARAMS: InitStateVar=0.146772
X5202   53   105  memristor PARAMS: InitStateVar=0.274318
X5302   54   105  memristor PARAMS: InitStateVar=0.106851
X5402   55   105  memristor PARAMS: InitStateVar=0.209663
X5502   56   105  memristor PARAMS: InitStateVar=0.468149
X5602   57   105  memristor PARAMS: InitStateVar=0.197087
X5702   58   105  memristor PARAMS: InitStateVar=0.348309
X5802   59   105  memristor PARAMS: InitStateVar=0.43812
X5902   60   105  memristor PARAMS: InitStateVar=0.4514
X6002   61   105  memristor PARAMS: InitStateVar=0.292171
X6102   62   105  memristor PARAMS: InitStateVar=0.133135
X6202   63   105  memristor PARAMS: InitStateVar=0.196691
X6302   64   105  memristor PARAMS: InitStateVar=0.202876
X6402   65   105  memristor PARAMS: InitStateVar=0.22848
X6502   66   105  memristor PARAMS: InitStateVar=0.419036
X6602   67   105  memristor PARAMS: InitStateVar=0.476914
X6702   68   105  memristor PARAMS: InitStateVar=0.378589
X6802   69   105  memristor PARAMS: InitStateVar=0.225877
X6902   70   105  memristor PARAMS: InitStateVar=0.292968
X7002   71   105  memristor PARAMS: InitStateVar=0.400877
X7102   72   105  memristor PARAMS: InitStateVar=0.315446
X7202   73   105  memristor PARAMS: InitStateVar=0.274577
X7302   74   105  memristor PARAMS: InitStateVar=0.228616
X7402   75   105  memristor PARAMS: InitStateVar=0.262536
X7502   76   105  memristor PARAMS: InitStateVar=0.383698
X7602   77   105  memristor PARAMS: InitStateVar=0.292744
X7702   78   105  memristor PARAMS: InitStateVar=0.307955
X7802   79   105  memristor PARAMS: InitStateVar=0.256394
X7902   80   105  memristor PARAMS: InitStateVar=0.212704
X8002   81   105  memristor PARAMS: InitStateVar=0.241265
X8102   82   105  memristor PARAMS: InitStateVar=0.460814
X8202   83   105  memristor PARAMS: InitStateVar=0.0587914
X8302   84   105  memristor PARAMS: InitStateVar=0.376151
X8402   85   105  memristor PARAMS: InitStateVar=0.0731441
X8502   86   105  memristor PARAMS: InitStateVar=0.401671
X8602   87   105  memristor PARAMS: InitStateVar=0.273732
X8702   88   105  memristor PARAMS: InitStateVar=0.051252
X8802   89   105  memristor PARAMS: InitStateVar=0.464822
X8902   90   105  memristor PARAMS: InitStateVar=0.247902
X9002   91   105  memristor PARAMS: InitStateVar=0.213604
X9102   92   105  memristor PARAMS: InitStateVar=0.393378
X9202   93   105  memristor PARAMS: InitStateVar=0.320787
X9302   94   105  memristor PARAMS: InitStateVar=0.229856
X9402   95   105  memristor PARAMS: InitStateVar=0.342466
X9502   96   105  memristor PARAMS: InitStateVar=0.363601
X9602   97   105  memristor PARAMS: InitStateVar=0.26454
X9702   98   105  memristor PARAMS: InitStateVar=0.370834
X9802   99   105  memristor PARAMS: InitStateVar=0.303802
X9902   100  105  memristor PARAMS: InitStateVar=0.342508
Xo3     105  106  OutputModule PARAMS: Rval=100
*------------------- Column 4 -------------------------------------------------
X3      1    107  memristor PARAMS: InitStateVar=0.230923
X103    2    107  memristor PARAMS: InitStateVar=0.474289
X203    3    107  memristor PARAMS: InitStateVar=0.337263
X303    4    107  memristor PARAMS: InitStateVar=0.234207
X403    5    107  memristor PARAMS: InitStateVar=0.321713
X503    6    107  memristor PARAMS: InitStateVar=0.131732
X603    7    107  memristor PARAMS: InitStateVar=0.622104
X703    8    107  memristor PARAMS: InitStateVar=0.247768
X803    9    107  memristor PARAMS: InitStateVar=0.535596
X903    10   107  memristor PARAMS: InitStateVar=0.223033
X1003   11   107  memristor PARAMS: InitStateVar=0.237797
X1103   12   107  memristor PARAMS: InitStateVar=0.300368
X1203   13   107  memristor PARAMS: InitStateVar=0.342428
X1303   14   107  memristor PARAMS: InitStateVar=0.303822
X1403   15   107  memristor PARAMS: InitStateVar=0.440161
X1503   16   107  memristor PARAMS: InitStateVar=0.286574
X1603   17   107  memristor PARAMS: InitStateVar=0.395803
X1703   18   107  memristor PARAMS: InitStateVar=0.364571
X1803   19   107  memristor PARAMS: InitStateVar=0.443056
X1903   20   107  memristor PARAMS: InitStateVar=0.316339
X2003   21   107  memristor PARAMS: InitStateVar=0.322667
X2103   22   107  memristor PARAMS: InitStateVar=0.253549
X2203   23   107  memristor PARAMS: InitStateVar=0.400768
X2303   24   107  memristor PARAMS: InitStateVar=0.45537
X2403   25   107  memristor PARAMS: InitStateVar=0.300205
X2503   26   107  memristor PARAMS: InitStateVar=0.479044
X2603   27   107  memristor PARAMS: InitStateVar=0.269377
X2703   28   107  memristor PARAMS: InitStateVar=0.360701
X2803   29   107  memristor PARAMS: InitStateVar=0.300783
X2903   30   107  memristor PARAMS: InitStateVar=0.611951
X3003   31   107  memristor PARAMS: InitStateVar=0.287803
X3103   32   107  memristor PARAMS: InitStateVar=0.310917
X3203   33   107  memristor PARAMS: InitStateVar=0.291931
X3303   34   107  memristor PARAMS: InitStateVar=0.406081
X3403   35   107  memristor PARAMS: InitStateVar=0.523419
X3503   36   107  memristor PARAMS: InitStateVar=0.0534499
X3603   37   107  memristor PARAMS: InitStateVar=0.303395
X3703   38   107  memristor PARAMS: InitStateVar=0.442726
X3803   39   107  memristor PARAMS: InitStateVar=0.202045
X3903   40   107  memristor PARAMS: InitStateVar=0.347503
X4003   41   107  memristor PARAMS: InitStateVar=0.321959
X4103   42   107  memristor PARAMS: InitStateVar=0.321507
X4203   43   107  memristor PARAMS: InitStateVar=0.317159
X4303   44   107  memristor PARAMS: InitStateVar=0.335717
X4403   45   107  memristor PARAMS: InitStateVar=0.379131
X4503   46   107  memristor PARAMS: InitStateVar=0.446325
X4603   47   107  memristor PARAMS: InitStateVar=0.272228
X4703   48   107  memristor PARAMS: InitStateVar=0.394139
X4803   49   107  memristor PARAMS: InitStateVar=0.291777
X4903   50   107  memristor PARAMS: InitStateVar=0.289438
X5003   51   107  memristor PARAMS: InitStateVar=0.180631
X5103   52   107  memristor PARAMS: InitStateVar=0.380188
X5203   53   107  memristor PARAMS: InitStateVar=0.447736
X5303   54   107  memristor PARAMS: InitStateVar=0.426216
X5403   55   107  memristor PARAMS: InitStateVar=0.185932
X5503   56   107  memristor PARAMS: InitStateVar=0.324822
X5603   57   107  memristor PARAMS: InitStateVar=0.276573
X5703   58   107  memristor PARAMS: InitStateVar=0.198278
X5803   59   107  memristor PARAMS: InitStateVar=0.274085
X5903   60   107  memristor PARAMS: InitStateVar=0.30308
X6003   61   107  memristor PARAMS: InitStateVar=0.292471
X6103   62   107  memristor PARAMS: InitStateVar=0.250827
X6203   63   107  memristor PARAMS: InitStateVar=0.321869
X6303   64   107  memristor PARAMS: InitStateVar=0.376499
X6403   65   107  memristor PARAMS: InitStateVar=0.274808
X6503   66   107  memristor PARAMS: InitStateVar=0.379576
X6603   67   107  memristor PARAMS: InitStateVar=0.253988
X6703   68   107  memristor PARAMS: InitStateVar=0.334523
X6803   69   107  memristor PARAMS: InitStateVar=0.232658
X6903   70   107  memristor PARAMS: InitStateVar=0.378964
X7003   71   107  memristor PARAMS: InitStateVar=0.197209
X7103   72   107  memristor PARAMS: InitStateVar=0.320829
X7203   73   107  memristor PARAMS: InitStateVar=0.358646
X7303   74   107  memristor PARAMS: InitStateVar=0.237335
X7403   75   107  memristor PARAMS: InitStateVar=0.306401
X7503   76   107  memristor PARAMS: InitStateVar=0.237211
X7603   77   107  memristor PARAMS: InitStateVar=0.449771
X7703   78   107  memristor PARAMS: InitStateVar=0.265953
X7803   79   107  memristor PARAMS: InitStateVar=0.31479
X7903   80   107  memristor PARAMS: InitStateVar=0.189504
X8003   81   107  memristor PARAMS: InitStateVar=0.25905
X8103   82   107  memristor PARAMS: InitStateVar=0.366057
X8203   83   107  memristor PARAMS: InitStateVar=0.208836
X8303   84   107  memristor PARAMS: InitStateVar=0.242871
X8403   85   107  memristor PARAMS: InitStateVar=0.268908
X8503   86   107  memristor PARAMS: InitStateVar=0.253343
X8603   87   107  memristor PARAMS: InitStateVar=0.368235
X8703   88   107  memristor PARAMS: InitStateVar=0.309527
X8803   89   107  memristor PARAMS: InitStateVar=0.227799
X8903   90   107  memristor PARAMS: InitStateVar=0.165023
X9003   91   107  memristor PARAMS: InitStateVar=0.336108
X9103   92   107  memristor PARAMS: InitStateVar=0.0935931
X9203   93   107  memristor PARAMS: InitStateVar=0.346174
X9303   94   107  memristor PARAMS: InitStateVar=0.217686
X9403   95   107  memristor PARAMS: InitStateVar=0.306405
X9503   96   107  memristor PARAMS: InitStateVar=0.408663
X9603   97   107  memristor PARAMS: InitStateVar=0.355118
X9703   98   107  memristor PARAMS: InitStateVar=0.194289
X9803   99   107  memristor PARAMS: InitStateVar=0.287482
X9903   100  107  memristor PARAMS: InitStateVar=0.572396
Xo4     107  108  OutputModule PARAMS: Rval=100
*------------------- Column 5 -------------------------------------------------
X4      1    109  memristor PARAMS: InitStateVar=0.311716
X104    2    109  memristor PARAMS: InitStateVar=0.165405
X204    3    109  memristor PARAMS: InitStateVar=0.290437
X304    4    109  memristor PARAMS: InitStateVar=0.301122
X404    5    109  memristor PARAMS: InitStateVar=0.330095
X504    6    109  memristor PARAMS: InitStateVar=0.354567
X604    7    109  memristor PARAMS: InitStateVar=0.458831
X704    8    109  memristor PARAMS: InitStateVar=0.330511
X804    9    109  memristor PARAMS: InitStateVar=0.246512
X904    10   109  memristor PARAMS: InitStateVar=0.198891
X1004   11   109  memristor PARAMS: InitStateVar=0.389152
X1104   12   109  memristor PARAMS: InitStateVar=0.241731
X1204   13   109  memristor PARAMS: InitStateVar=0.202051
X1304   14   109  memristor PARAMS: InitStateVar=0.219325
X1404   15   109  memristor PARAMS: InitStateVar=0.442833
X1504   16   109  memristor PARAMS: InitStateVar=0.300154
X1604   17   109  memristor PARAMS: InitStateVar=0.392014
X1704   18   109  memristor PARAMS: InitStateVar=0.173717
X1804   19   109  memristor PARAMS: InitStateVar=0.421366
X1904   20   109  memristor PARAMS: InitStateVar=0.531114
X2004   21   109  memristor PARAMS: InitStateVar=0.118721
X2104   22   109  memristor PARAMS: InitStateVar=0.244175
X2204   23   109  memristor PARAMS: InitStateVar=0.19139
X2304   24   109  memristor PARAMS: InitStateVar=0.38727
X2404   25   109  memristor PARAMS: InitStateVar=0.277193
X2504   26   109  memristor PARAMS: InitStateVar=0.364077
X2604   27   109  memristor PARAMS: InitStateVar=0.368151
X2704   28   109  memristor PARAMS: InitStateVar=0.126593
X2804   29   109  memristor PARAMS: InitStateVar=0.186513
X2904   30   109  memristor PARAMS: InitStateVar=0.103717
X3004   31   109  memristor PARAMS: InitStateVar=0.248158
X3104   32   109  memristor PARAMS: InitStateVar=0.225121
X3204   33   109  memristor PARAMS: InitStateVar=0.333353
X3304   34   109  memristor PARAMS: InitStateVar=0.268165
X3404   35   109  memristor PARAMS: InitStateVar=0.276393
X3504   36   109  memristor PARAMS: InitStateVar=0.357236
X3604   37   109  memristor PARAMS: InitStateVar=0.26887
X3704   38   109  memristor PARAMS: InitStateVar=0.336019
X3804   39   109  memristor PARAMS: InitStateVar=0.415351
X3904   40   109  memristor PARAMS: InitStateVar=0.263743
X4004   41   109  memristor PARAMS: InitStateVar=0.17231
X4104   42   109  memristor PARAMS: InitStateVar=0.354958
X4204   43   109  memristor PARAMS: InitStateVar=0.47489
X4304   44   109  memristor PARAMS: InitStateVar=0.439124
X4404   45   109  memristor PARAMS: InitStateVar=0.285148
X4504   46   109  memristor PARAMS: InitStateVar=0.447112
X4604   47   109  memristor PARAMS: InitStateVar=0.47918
X4704   48   109  memristor PARAMS: InitStateVar=0.3773
X4804   49   109  memristor PARAMS: InitStateVar=0.250648
X4904   50   109  memristor PARAMS: InitStateVar=0.0964409
X5004   51   109  memristor PARAMS: InitStateVar=0.326782
X5104   52   109  memristor PARAMS: InitStateVar=0.327792
X5204   53   109  memristor PARAMS: InitStateVar=0.215678
X5304   54   109  memristor PARAMS: InitStateVar=0.16467
X5404   55   109  memristor PARAMS: InitStateVar=0.215217
X5504   56   109  memristor PARAMS: InitStateVar=0.182023
X5604   57   109  memristor PARAMS: InitStateVar=0.472147
X5704   58   109  memristor PARAMS: InitStateVar=0.129437
X5804   59   109  memristor PARAMS: InitStateVar=0.171268
X5904   60   109  memristor PARAMS: InitStateVar=0.329987
X6004   61   109  memristor PARAMS: InitStateVar=0.378192
X6104   62   109  memristor PARAMS: InitStateVar=0.165126
X6204   63   109  memristor PARAMS: InitStateVar=0.205052
X6304   64   109  memristor PARAMS: InitStateVar=0.197147
X6404   65   109  memristor PARAMS: InitStateVar=0.365971
X6504   66   109  memristor PARAMS: InitStateVar=0.244407
X6604   67   109  memristor PARAMS: InitStateVar=0.368562
X6704   68   109  memristor PARAMS: InitStateVar=0.371779
X6804   69   109  memristor PARAMS: InitStateVar=0.431098
X6904   70   109  memristor PARAMS: InitStateVar=0.393621
X7004   71   109  memristor PARAMS: InitStateVar=0.516418
X7104   72   109  memristor PARAMS: InitStateVar=0.343527
X7204   73   109  memristor PARAMS: InitStateVar=0.396868
X7304   74   109  memristor PARAMS: InitStateVar=0.5555
X7404   75   109  memristor PARAMS: InitStateVar=0.222205
X7504   76   109  memristor PARAMS: InitStateVar=0.153431
X7604   77   109  memristor PARAMS: InitStateVar=0.187296
X7704   78   109  memristor PARAMS: InitStateVar=0.349549
X7804   79   109  memristor PARAMS: InitStateVar=0.290926
X7904   80   109  memristor PARAMS: InitStateVar=0.361473
X8004   81   109  memristor PARAMS: InitStateVar=0.278057
X8104   82   109  memristor PARAMS: InitStateVar=0.301734
X8204   83   109  memristor PARAMS: InitStateVar=0.222683
X8304   84   109  memristor PARAMS: InitStateVar=0.398005
X8404   85   109  memristor PARAMS: InitStateVar=0.102957
X8504   86   109  memristor PARAMS: InitStateVar=0.315229
X8604   87   109  memristor PARAMS: InitStateVar=0.384451
X8704   88   109  memristor PARAMS: InitStateVar=0.465227
X8804   89   109  memristor PARAMS: InitStateVar=0.300587
X8904   90   109  memristor PARAMS: InitStateVar=0.178157
X9004   91   109  memristor PARAMS: InitStateVar=0.306306
X9104   92   109  memristor PARAMS: InitStateVar=0.281046
X9204   93   109  memristor PARAMS: InitStateVar=0.192024
X9304   94   109  memristor PARAMS: InitStateVar=0.229247
X9404   95   109  memristor PARAMS: InitStateVar=0.334802
X9504   96   109  memristor PARAMS: InitStateVar=0.344208
X9604   97   109  memristor PARAMS: InitStateVar=0.332303
X9704   98   109  memristor PARAMS: InitStateVar=0.256103
X9804   99   109  memristor PARAMS: InitStateVar=0.318287
X9904   100  109  memristor PARAMS: InitStateVar=0.373456
Xo5     109  110  OutputModule PARAMS: Rval=100
*------------------- Column 6 -------------------------------------------------
X5      1    111  memristor PARAMS: InitStateVar=0.314885
X105    2    111  memristor PARAMS: InitStateVar=0.152187
X205    3    111  memristor PARAMS: InitStateVar=0.510317
X305    4    111  memristor PARAMS: InitStateVar=0.362018
X405    5    111  memristor PARAMS: InitStateVar=0.217512
X505    6    111  memristor PARAMS: InitStateVar=0.416603
X605    7    111  memristor PARAMS: InitStateVar=0.320701
X705    8    111  memristor PARAMS: InitStateVar=0.42467
X805    9    111  memristor PARAMS: InitStateVar=0.257179
X905    10   111  memristor PARAMS: InitStateVar=0.439622
X1005   11   111  memristor PARAMS: InitStateVar=0.256441
X1105   12   111  memristor PARAMS: InitStateVar=0.328734
X1205   13   111  memristor PARAMS: InitStateVar=0.250701
X1305   14   111  memristor PARAMS: InitStateVar=0.40606
X1405   15   111  memristor PARAMS: InitStateVar=0.476144
X1505   16   111  memristor PARAMS: InitStateVar=0.346917
X1605   17   111  memristor PARAMS: InitStateVar=0.357569
X1705   18   111  memristor PARAMS: InitStateVar=0.499417
X1805   19   111  memristor PARAMS: InitStateVar=0.339746
X1905   20   111  memristor PARAMS: InitStateVar=0.239277
X2005   21   111  memristor PARAMS: InitStateVar=0.285813
X2105   22   111  memristor PARAMS: InitStateVar=0.247061
X2205   23   111  memristor PARAMS: InitStateVar=0.390627
X2305   24   111  memristor PARAMS: InitStateVar=0.555622
X2405   25   111  memristor PARAMS: InitStateVar=0.281302
X2505   26   111  memristor PARAMS: InitStateVar=0.315439
X2605   27   111  memristor PARAMS: InitStateVar=0.328939
X2705   28   111  memristor PARAMS: InitStateVar=0.251979
X2805   29   111  memristor PARAMS: InitStateVar=0.190713
X2905   30   111  memristor PARAMS: InitStateVar=0.355035
X3005   31   111  memristor PARAMS: InitStateVar=0.44268
X3105   32   111  memristor PARAMS: InitStateVar=0.308357
X3205   33   111  memristor PARAMS: InitStateVar=0.274417
X3305   34   111  memristor PARAMS: InitStateVar=0.352934
X3405   35   111  memristor PARAMS: InitStateVar=0.313066
X3505   36   111  memristor PARAMS: InitStateVar=0.290072
X3605   37   111  memristor PARAMS: InitStateVar=0.386672
X3705   38   111  memristor PARAMS: InitStateVar=0.262693
X3805   39   111  memristor PARAMS: InitStateVar=0.352255
X3905   40   111  memristor PARAMS: InitStateVar=0.365422
X4005   41   111  memristor PARAMS: InitStateVar=0.241096
X4105   42   111  memristor PARAMS: InitStateVar=0.341705
X4205   43   111  memristor PARAMS: InitStateVar=0.228954
X4305   44   111  memristor PARAMS: InitStateVar=0.349436
X4405   45   111  memristor PARAMS: InitStateVar=0.351232
X4505   46   111  memristor PARAMS: InitStateVar=0.241068
X4605   47   111  memristor PARAMS: InitStateVar=0.306746
X4705   48   111  memristor PARAMS: InitStateVar=0.327856
X4805   49   111  memristor PARAMS: InitStateVar=0.375751
X4905   50   111  memristor PARAMS: InitStateVar=0.381481
X5005   51   111  memristor PARAMS: InitStateVar=0.294294
X5105   52   111  memristor PARAMS: InitStateVar=0.359841
X5205   53   111  memristor PARAMS: InitStateVar=0.298195
X5305   54   111  memristor PARAMS: InitStateVar=0.332265
X5405   55   111  memristor PARAMS: InitStateVar=0.351035
X5505   56   111  memristor PARAMS: InitStateVar=0.196367
X5605   57   111  memristor PARAMS: InitStateVar=0.187695
X5705   58   111  memristor PARAMS: InitStateVar=0.227858
X5805   59   111  memristor PARAMS: InitStateVar=0.449729
X5905   60   111  memristor PARAMS: InitStateVar=0.469049
X6005   61   111  memristor PARAMS: InitStateVar=0.38787
X6105   62   111  memristor PARAMS: InitStateVar=0.186285
X6205   63   111  memristor PARAMS: InitStateVar=0.21697
X6305   64   111  memristor PARAMS: InitStateVar=0.0392754
X6405   65   111  memristor PARAMS: InitStateVar=0.213262
X6505   66   111  memristor PARAMS: InitStateVar=0.355412
X6605   67   111  memristor PARAMS: InitStateVar=0.213698
X6705   68   111  memristor PARAMS: InitStateVar=0.255632
X6805   69   111  memristor PARAMS: InitStateVar=0.375978
X6905   70   111  memristor PARAMS: InitStateVar=0.176178
X7005   71   111  memristor PARAMS: InitStateVar=0.214006
X7105   72   111  memristor PARAMS: InitStateVar=0.450824
X7205   73   111  memristor PARAMS: InitStateVar=0.317453
X7305   74   111  memristor PARAMS: InitStateVar=0.208703
X7405   75   111  memristor PARAMS: InitStateVar=0.247289
X7505   76   111  memristor PARAMS: InitStateVar=0.262677
X7605   77   111  memristor PARAMS: InitStateVar=0.231866
X7705   78   111  memristor PARAMS: InitStateVar=0.176278
X7805   79   111  memristor PARAMS: InitStateVar=0.269435
X7905   80   111  memristor PARAMS: InitStateVar=0.328715
X8005   81   111  memristor PARAMS: InitStateVar=0.32878
X8105   82   111  memristor PARAMS: InitStateVar=0.285664
X8205   83   111  memristor PARAMS: InitStateVar=0.378553
X8305   84   111  memristor PARAMS: InitStateVar=0.262292
X8405   85   111  memristor PARAMS: InitStateVar=0.448544
X8505   86   111  memristor PARAMS: InitStateVar=0.256607
X8605   87   111  memristor PARAMS: InitStateVar=0.407723
X8705   88   111  memristor PARAMS: InitStateVar=0.124244
X8805   89   111  memristor PARAMS: InitStateVar=0.378208
X8905   90   111  memristor PARAMS: InitStateVar=0.228548
X9005   91   111  memristor PARAMS: InitStateVar=0.110488
X9105   92   111  memristor PARAMS: InitStateVar=0.236686
X9205   93   111  memristor PARAMS: InitStateVar=0.337374
X9305   94   111  memristor PARAMS: InitStateVar=0.464577
X9405   95   111  memristor PARAMS: InitStateVar=0.136756
X9505   96   111  memristor PARAMS: InitStateVar=0.353075
X9605   97   111  memristor PARAMS: InitStateVar=0.374549
X9705   98   111  memristor PARAMS: InitStateVar=0.323683
X9805   99   111  memristor PARAMS: InitStateVar=0.275774
X9905   100  111  memristor PARAMS: InitStateVar=0.424972
Xo6     111  112  OutputModule PARAMS: Rval=100
*------------------- Column 7 -------------------------------------------------
X6      1    113  memristor PARAMS: InitStateVar=0.296092
X106    2    113  memristor PARAMS: InitStateVar=0.521324
X206    3    113  memristor PARAMS: InitStateVar=0.326367
X306    4    113  memristor PARAMS: InitStateVar=0.243754
X406    5    113  memristor PARAMS: InitStateVar=0.503495
X506    6    113  memristor PARAMS: InitStateVar=0.346948
X606    7    113  memristor PARAMS: InitStateVar=0.417199
X706    8    113  memristor PARAMS: InitStateVar=0.252087
X806    9    113  memristor PARAMS: InitStateVar=0.213069
X906    10   113  memristor PARAMS: InitStateVar=0.293924
X1006   11   113  memristor PARAMS: InitStateVar=0.159259
X1106   12   113  memristor PARAMS: InitStateVar=0.2792
X1206   13   113  memristor PARAMS: InitStateVar=0.28833
X1306   14   113  memristor PARAMS: InitStateVar=0.189383
X1406   15   113  memristor PARAMS: InitStateVar=0.324721
X1506   16   113  memristor PARAMS: InitStateVar=0.310479
X1606   17   113  memristor PARAMS: InitStateVar=0.257931
X1706   18   113  memristor PARAMS: InitStateVar=0.304546
X1806   19   113  memristor PARAMS: InitStateVar=0.362756
X1906   20   113  memristor PARAMS: InitStateVar=0.243562
X2006   21   113  memristor PARAMS: InitStateVar=0.124138
X2106   22   113  memristor PARAMS: InitStateVar=0.470448
X2206   23   113  memristor PARAMS: InitStateVar=0.28094
X2306   24   113  memristor PARAMS: InitStateVar=0.0761131
X2406   25   113  memristor PARAMS: InitStateVar=0.144085
X2506   26   113  memristor PARAMS: InitStateVar=0.34663
X2606   27   113  memristor PARAMS: InitStateVar=0.253121
X2706   28   113  memristor PARAMS: InitStateVar=0.372836
X2806   29   113  memristor PARAMS: InitStateVar=0.49228
X2906   30   113  memristor PARAMS: InitStateVar=0.0708513
X3006   31   113  memristor PARAMS: InitStateVar=0.288994
X3106   32   113  memristor PARAMS: InitStateVar=0.387943
X3206   33   113  memristor PARAMS: InitStateVar=0.197298
X3306   34   113  memristor PARAMS: InitStateVar=0.16923
X3406   35   113  memristor PARAMS: InitStateVar=0.287786
X3506   36   113  memristor PARAMS: InitStateVar=0.142448
X3606   37   113  memristor PARAMS: InitStateVar=0.408543
X3706   38   113  memristor PARAMS: InitStateVar=0.228548
X3806   39   113  memristor PARAMS: InitStateVar=0.353911
X3906   40   113  memristor PARAMS: InitStateVar=0.279391
X4006   41   113  memristor PARAMS: InitStateVar=0.424106
X4106   42   113  memristor PARAMS: InitStateVar=0.299302
X4206   43   113  memristor PARAMS: InitStateVar=0.355851
X4306   44   113  memristor PARAMS: InitStateVar=0.321405
X4406   45   113  memristor PARAMS: InitStateVar=0.187685
X4506   46   113  memristor PARAMS: InitStateVar=0.168146
X4606   47   113  memristor PARAMS: InitStateVar=0.458305
X4706   48   113  memristor PARAMS: InitStateVar=0.259306
X4806   49   113  memristor PARAMS: InitStateVar=0.393334
X4906   50   113  memristor PARAMS: InitStateVar=0.267457
X5006   51   113  memristor PARAMS: InitStateVar=0.461897
X5106   52   113  memristor PARAMS: InitStateVar=0.410678
X5206   53   113  memristor PARAMS: InitStateVar=0.196073
X5306   54   113  memristor PARAMS: InitStateVar=0.360662
X5406   55   113  memristor PARAMS: InitStateVar=0.144411
X5506   56   113  memristor PARAMS: InitStateVar=0.24352
X5606   57   113  memristor PARAMS: InitStateVar=0.17892
X5706   58   113  memristor PARAMS: InitStateVar=0.240154
X5806   59   113  memristor PARAMS: InitStateVar=0.311716
X5906   60   113  memristor PARAMS: InitStateVar=0.144104
X6006   61   113  memristor PARAMS: InitStateVar=0.470993
X6106   62   113  memristor PARAMS: InitStateVar=0.306993
X6206   63   113  memristor PARAMS: InitStateVar=0.220899
X6306   64   113  memristor PARAMS: InitStateVar=0.392896
X6406   65   113  memristor PARAMS: InitStateVar=0.129956
X6506   66   113  memristor PARAMS: InitStateVar=0.270351
X6606   67   113  memristor PARAMS: InitStateVar=0.217162
X6706   68   113  memristor PARAMS: InitStateVar=0.236784
X6806   69   113  memristor PARAMS: InitStateVar=0.269949
X6906   70   113  memristor PARAMS: InitStateVar=0.405772
X7006   71   113  memristor PARAMS: InitStateVar=0.328752
X7106   72   113  memristor PARAMS: InitStateVar=0.210219
X7206   73   113  memristor PARAMS: InitStateVar=0.188655
X7306   74   113  memristor PARAMS: InitStateVar=0.334388
X7406   75   113  memristor PARAMS: InitStateVar=0.259626
X7506   76   113  memristor PARAMS: InitStateVar=0.38697
X7606   77   113  memristor PARAMS: InitStateVar=0.335942
X7706   78   113  memristor PARAMS: InitStateVar=0.303773
X7806   79   113  memristor PARAMS: InitStateVar=0.433109
X7906   80   113  memristor PARAMS: InitStateVar=0.40274
X8006   81   113  memristor PARAMS: InitStateVar=0.393335
X8106   82   113  memristor PARAMS: InitStateVar=0.386233
X8206   83   113  memristor PARAMS: InitStateVar=0.327412
X8306   84   113  memristor PARAMS: InitStateVar=0.36131
X8406   85   113  memristor PARAMS: InitStateVar=0.336966
X8506   86   113  memristor PARAMS: InitStateVar=0.111052
X8606   87   113  memristor PARAMS: InitStateVar=0.252605
X8706   88   113  memristor PARAMS: InitStateVar=0.433822
X8806   89   113  memristor PARAMS: InitStateVar=0.227965
X8906   90   113  memristor PARAMS: InitStateVar=0.223219
X9006   91   113  memristor PARAMS: InitStateVar=0.518436
X9106   92   113  memristor PARAMS: InitStateVar=0.38286
X9206   93   113  memristor PARAMS: InitStateVar=0.276266
X9306   94   113  memristor PARAMS: InitStateVar=0.294133
X9406   95   113  memristor PARAMS: InitStateVar=0.320912
X9506   96   113  memristor PARAMS: InitStateVar=0.486765
X9606   97   113  memristor PARAMS: InitStateVar=0.215766
X9706   98   113  memristor PARAMS: InitStateVar=0.363333
X9806   99   113  memristor PARAMS: InitStateVar=0.237512
X9906   100  113  memristor PARAMS: InitStateVar=0.236185
Xo7     113  114  OutputModule PARAMS: Rval=100
*------------------- Column 8 -------------------------------------------------
X7      1    115  memristor PARAMS: InitStateVar=0.32918
X107    2    115  memristor PARAMS: InitStateVar=0.266976
X207    3    115  memristor PARAMS: InitStateVar=0.366051
X307    4    115  memristor PARAMS: InitStateVar=0.257736
X407    5    115  memristor PARAMS: InitStateVar=0.212108
X507    6    115  memristor PARAMS: InitStateVar=0.370186
X607    7    115  memristor PARAMS: InitStateVar=0.301791
X707    8    115  memristor PARAMS: InitStateVar=0.340239
X807    9    115  memristor PARAMS: InitStateVar=0.317983
X907    10   115  memristor PARAMS: InitStateVar=0.122696
X1007   11   115  memristor PARAMS: InitStateVar=0.204955
X1107   12   115  memristor PARAMS: InitStateVar=0.166631
X1207   13   115  memristor PARAMS: InitStateVar=0.168185
X1307   14   115  memristor PARAMS: InitStateVar=0.174941
X1407   15   115  memristor PARAMS: InitStateVar=0.257858
X1507   16   115  memristor PARAMS: InitStateVar=0.27703
X1607   17   115  memristor PARAMS: InitStateVar=0.162959
X1707   18   115  memristor PARAMS: InitStateVar=0.171422
X1807   19   115  memristor PARAMS: InitStateVar=0.170154
X1907   20   115  memristor PARAMS: InitStateVar=0.234834
X2007   21   115  memristor PARAMS: InitStateVar=0.379807
X2107   22   115  memristor PARAMS: InitStateVar=0.37006
X2207   23   115  memristor PARAMS: InitStateVar=0.293597
X2307   24   115  memristor PARAMS: InitStateVar=0.250569
X2407   25   115  memristor PARAMS: InitStateVar=0.357244
X2507   26   115  memristor PARAMS: InitStateVar=0.29572
X2607   27   115  memristor PARAMS: InitStateVar=0.185015
X2707   28   115  memristor PARAMS: InitStateVar=0.216988
X2807   29   115  memristor PARAMS: InitStateVar=0.336867
X2907   30   115  memristor PARAMS: InitStateVar=0.333784
X3007   31   115  memristor PARAMS: InitStateVar=0.160063
X3107   32   115  memristor PARAMS: InitStateVar=0.409347
X3207   33   115  memristor PARAMS: InitStateVar=0.205839
X3307   34   115  memristor PARAMS: InitStateVar=0.341691
X3407   35   115  memristor PARAMS: InitStateVar=0.308294
X3507   36   115  memristor PARAMS: InitStateVar=0.427198
X3607   37   115  memristor PARAMS: InitStateVar=0.19608
X3707   38   115  memristor PARAMS: InitStateVar=0.415231
X3807   39   115  memristor PARAMS: InitStateVar=0.280641
X3907   40   115  memristor PARAMS: InitStateVar=0.303199
X4007   41   115  memristor PARAMS: InitStateVar=0.40671
X4107   42   115  memristor PARAMS: InitStateVar=0.347628
X4207   43   115  memristor PARAMS: InitStateVar=0.447242
X4307   44   115  memristor PARAMS: InitStateVar=0.306996
X4407   45   115  memristor PARAMS: InitStateVar=0.194532
X4507   46   115  memristor PARAMS: InitStateVar=0.309441
X4607   47   115  memristor PARAMS: InitStateVar=0.371951
X4707   48   115  memristor PARAMS: InitStateVar=0.29896
X4807   49   115  memristor PARAMS: InitStateVar=0.222768
X4907   50   115  memristor PARAMS: InitStateVar=0.336304
X5007   51   115  memristor PARAMS: InitStateVar=0.204251
X5107   52   115  memristor PARAMS: InitStateVar=0.224611
X5207   53   115  memristor PARAMS: InitStateVar=0.306615
X5307   54   115  memristor PARAMS: InitStateVar=0.178602
X5407   55   115  memristor PARAMS: InitStateVar=0.33341
X5507   56   115  memristor PARAMS: InitStateVar=0.346702
X5607   57   115  memristor PARAMS: InitStateVar=0.175726
X5707   58   115  memristor PARAMS: InitStateVar=0.134696
X5807   59   115  memristor PARAMS: InitStateVar=0.18967
X5907   60   115  memristor PARAMS: InitStateVar=0.326555
X6007   61   115  memristor PARAMS: InitStateVar=0.516275
X6107   62   115  memristor PARAMS: InitStateVar=0.322803
X6207   63   115  memristor PARAMS: InitStateVar=0.428446
X6307   64   115  memristor PARAMS: InitStateVar=0.58256
X6407   65   115  memristor PARAMS: InitStateVar=0.287809
X6507   66   115  memristor PARAMS: InitStateVar=0.337898
X6607   67   115  memristor PARAMS: InitStateVar=0.187654
X6707   68   115  memristor PARAMS: InitStateVar=0.381263
X6807   69   115  memristor PARAMS: InitStateVar=0.509207
X6907   70   115  memristor PARAMS: InitStateVar=0.401749
X7007   71   115  memristor PARAMS: InitStateVar=0.289617
X7107   72   115  memristor PARAMS: InitStateVar=0.372909
X7207   73   115  memristor PARAMS: InitStateVar=0.182601
X7307   74   115  memristor PARAMS: InitStateVar=0.171748
X7407   75   115  memristor PARAMS: InitStateVar=0.192288
X7507   76   115  memristor PARAMS: InitStateVar=0.282641
X7607   77   115  memristor PARAMS: InitStateVar=0.344542
X7707   78   115  memristor PARAMS: InitStateVar=0.370675
X7807   79   115  memristor PARAMS: InitStateVar=0.220614
X7907   80   115  memristor PARAMS: InitStateVar=0.485653
X8007   81   115  memristor PARAMS: InitStateVar=0.108001
X8107   82   115  memristor PARAMS: InitStateVar=0.450885
X8207   83   115  memristor PARAMS: InitStateVar=0.335691
X8307   84   115  memristor PARAMS: InitStateVar=0.287707
X8407   85   115  memristor PARAMS: InitStateVar=0.19036
X8507   86   115  memristor PARAMS: InitStateVar=0.311964
X8607   87   115  memristor PARAMS: InitStateVar=0.292667
X8707   88   115  memristor PARAMS: InitStateVar=0.351762
X8807   89   115  memristor PARAMS: InitStateVar=0.383484
X8907   90   115  memristor PARAMS: InitStateVar=0.174615
X9007   91   115  memristor PARAMS: InitStateVar=0.255958
X9107   92   115  memristor PARAMS: InitStateVar=0.196198
X9207   93   115  memristor PARAMS: InitStateVar=0.385214
X9307   94   115  memristor PARAMS: InitStateVar=0.323188
X9407   95   115  memristor PARAMS: InitStateVar=0.386604
X9507   96   115  memristor PARAMS: InitStateVar=0.3308
X9607   97   115  memristor PARAMS: InitStateVar=0.367401
X9707   98   115  memristor PARAMS: InitStateVar=0.436457
X9807   99   115  memristor PARAMS: InitStateVar=0.199254
X9907   100  115  memristor PARAMS: InitStateVar=0.354761
Xo8     115  116  OutputModule PARAMS: Rval=100
*------------------- Column 9 -------------------------------------------------
X8      1    117  memristor PARAMS: InitStateVar=0.287249
X108    2    117  memristor PARAMS: InitStateVar=0.231439
X208    3    117  memristor PARAMS: InitStateVar=0.143022
X308    4    117  memristor PARAMS: InitStateVar=0.335078
X408    5    117  memristor PARAMS: InitStateVar=0.0452935
X508    6    117  memristor PARAMS: InitStateVar=0.242768
X608    7    117  memristor PARAMS: InitStateVar=0.399568
X708    8    117  memristor PARAMS: InitStateVar=0.161407
X808    9    117  memristor PARAMS: InitStateVar=0.306896
X908    10   117  memristor PARAMS: InitStateVar=0.366378
X1008   11   117  memristor PARAMS: InitStateVar=0.309339
X1108   12   117  memristor PARAMS: InitStateVar=0.379756
X1208   13   117  memristor PARAMS: InitStateVar=0.108788
X1308   14   117  memristor PARAMS: InitStateVar=0.267935
X1408   15   117  memristor PARAMS: InitStateVar=0.263784
X1508   16   117  memristor PARAMS: InitStateVar=0.188958
X1608   17   117  memristor PARAMS: InitStateVar=0.133892
X1708   18   117  memristor PARAMS: InitStateVar=0.137672
X1808   19   117  memristor PARAMS: InitStateVar=0.425615
X1908   20   117  memristor PARAMS: InitStateVar=0.140812
X2008   21   117  memristor PARAMS: InitStateVar=0.297277
X2108   22   117  memristor PARAMS: InitStateVar=0.334731
X2208   23   117  memristor PARAMS: InitStateVar=0.281797
X2308   24   117  memristor PARAMS: InitStateVar=0.349202
X2408   25   117  memristor PARAMS: InitStateVar=0.323554
X2508   26   117  memristor PARAMS: InitStateVar=0.277514
X2608   27   117  memristor PARAMS: InitStateVar=0.317248
X2708   28   117  memristor PARAMS: InitStateVar=0.204793
X2808   29   117  memristor PARAMS: InitStateVar=0.375375
X2908   30   117  memristor PARAMS: InitStateVar=0.136573
X3008   31   117  memristor PARAMS: InitStateVar=0.259595
X3108   32   117  memristor PARAMS: InitStateVar=0.323463
X3208   33   117  memristor PARAMS: InitStateVar=0.296269
X3308   34   117  memristor PARAMS: InitStateVar=0.402546
X3408   35   117  memristor PARAMS: InitStateVar=0.289122
X3508   36   117  memristor PARAMS: InitStateVar=0.266378
X3608   37   117  memristor PARAMS: InitStateVar=0.498323
X3708   38   117  memristor PARAMS: InitStateVar=0.399375
X3808   39   117  memristor PARAMS: InitStateVar=0.196816
X3908   40   117  memristor PARAMS: InitStateVar=0.272808
X4008   41   117  memristor PARAMS: InitStateVar=0.414596
X4108   42   117  memristor PARAMS: InitStateVar=0.348163
X4208   43   117  memristor PARAMS: InitStateVar=0.559465
X4308   44   117  memristor PARAMS: InitStateVar=0.279507
X4408   45   117  memristor PARAMS: InitStateVar=0.414232
X4508   46   117  memristor PARAMS: InitStateVar=0.271876
X4608   47   117  memristor PARAMS: InitStateVar=0.491195
X4708   48   117  memristor PARAMS: InitStateVar=0.133967
X4808   49   117  memristor PARAMS: InitStateVar=0.283359
X4908   50   117  memristor PARAMS: InitStateVar=0.269759
X5008   51   117  memristor PARAMS: InitStateVar=0.295094
X5108   52   117  memristor PARAMS: InitStateVar=0.313359
X5208   53   117  memristor PARAMS: InitStateVar=0.360276
X5308   54   117  memristor PARAMS: InitStateVar=0.330419
X5408   55   117  memristor PARAMS: InitStateVar=0.588678
X5508   56   117  memristor PARAMS: InitStateVar=0.294068
X5608   57   117  memristor PARAMS: InitStateVar=0.297547
X5708   58   117  memristor PARAMS: InitStateVar=0.198742
X5808   59   117  memristor PARAMS: InitStateVar=0.277952
X5908   60   117  memristor PARAMS: InitStateVar=0.157622
X6008   61   117  memristor PARAMS: InitStateVar=0.37675
X6108   62   117  memristor PARAMS: InitStateVar=0.335979
X6208   63   117  memristor PARAMS: InitStateVar=0.335223
X6308   64   117  memristor PARAMS: InitStateVar=0.260049
X6408   65   117  memristor PARAMS: InitStateVar=0.26798
X6508   66   117  memristor PARAMS: InitStateVar=0.375824
X6608   67   117  memristor PARAMS: InitStateVar=0.336446
X6708   68   117  memristor PARAMS: InitStateVar=0.431527
X6808   69   117  memristor PARAMS: InitStateVar=0.476747
X6908   70   117  memristor PARAMS: InitStateVar=0.253689
X7008   71   117  memristor PARAMS: InitStateVar=0.26566
X7108   72   117  memristor PARAMS: InitStateVar=0.218731
X7208   73   117  memristor PARAMS: InitStateVar=0.287005
X7308   74   117  memristor PARAMS: InitStateVar=0.340544
X7408   75   117  memristor PARAMS: InitStateVar=0.227576
X7508   76   117  memristor PARAMS: InitStateVar=0.282137
X7608   77   117  memristor PARAMS: InitStateVar=0.250378
X7708   78   117  memristor PARAMS: InitStateVar=0.100609
X7808   79   117  memristor PARAMS: InitStateVar=0.361946
X7908   80   117  memristor PARAMS: InitStateVar=0.318717
X8008   81   117  memristor PARAMS: InitStateVar=0.429762
X8108   82   117  memristor PARAMS: InitStateVar=0.208962
X8208   83   117  memristor PARAMS: InitStateVar=0.338199
X8308   84   117  memristor PARAMS: InitStateVar=0.314768
X8408   85   117  memristor PARAMS: InitStateVar=0.29299
X8508   86   117  memristor PARAMS: InitStateVar=0.338733
X8608   87   117  memristor PARAMS: InitStateVar=0.232652
X8708   88   117  memristor PARAMS: InitStateVar=0.438972
X8808   89   117  memristor PARAMS: InitStateVar=0.0959095
X8908   90   117  memristor PARAMS: InitStateVar=0.634743
X9008   91   117  memristor PARAMS: InitStateVar=0.309387
X9108   92   117  memristor PARAMS: InitStateVar=0.355894
X9208   93   117  memristor PARAMS: InitStateVar=0.309819
X9308   94   117  memristor PARAMS: InitStateVar=0.375037
X9408   95   117  memristor PARAMS: InitStateVar=0.229376
X9508   96   117  memristor PARAMS: InitStateVar=0.3851
X9608   97   117  memristor PARAMS: InitStateVar=0.474994
X9708   98   117  memristor PARAMS: InitStateVar=0.34242
X9808   99   117  memristor PARAMS: InitStateVar=0.135463
X9908   100  117  memristor PARAMS: InitStateVar=0.334668
Xo9     117  118  OutputModule PARAMS: Rval=100
*------------------- Column 10 -------------------------------------------------
X9      1    119  memristor PARAMS: InitStateVar=0.415005
X109    2    119  memristor PARAMS: InitStateVar=0.250115
X209    3    119  memristor PARAMS: InitStateVar=0.314243
X309    4    119  memristor PARAMS: InitStateVar=0.297121
X409    5    119  memristor PARAMS: InitStateVar=0.305268
X509    6    119  memristor PARAMS: InitStateVar=0.293267
X609    7    119  memristor PARAMS: InitStateVar=0.240882
X709    8    119  memristor PARAMS: InitStateVar=0.345121
X809    9    119  memristor PARAMS: InitStateVar=0.15036
X909    10   119  memristor PARAMS: InitStateVar=0.304718
X1009   11   119  memristor PARAMS: InitStateVar=0.432678
X1109   12   119  memristor PARAMS: InitStateVar=0.4851
X1209   13   119  memristor PARAMS: InitStateVar=0.308283
X1309   14   119  memristor PARAMS: InitStateVar=0.389665
X1409   15   119  memristor PARAMS: InitStateVar=0.247591
X1509   16   119  memristor PARAMS: InitStateVar=0.471386
X1609   17   119  memristor PARAMS: InitStateVar=0.206883
X1709   18   119  memristor PARAMS: InitStateVar=0.288645
X1809   19   119  memristor PARAMS: InitStateVar=0.305225
X1909   20   119  memristor PARAMS: InitStateVar=0.27815
X2009   21   119  memristor PARAMS: InitStateVar=0.461374
X2109   22   119  memristor PARAMS: InitStateVar=0.301816
X2209   23   119  memristor PARAMS: InitStateVar=0.3408
X2309   24   119  memristor PARAMS: InitStateVar=0.24556
X2409   25   119  memristor PARAMS: InitStateVar=0.362299
X2509   26   119  memristor PARAMS: InitStateVar=0.407134
X2609   27   119  memristor PARAMS: InitStateVar=0.273995
X2709   28   119  memristor PARAMS: InitStateVar=0.345589
X2809   29   119  memristor PARAMS: InitStateVar=0.352855
X2909   30   119  memristor PARAMS: InitStateVar=0.381172
X3009   31   119  memristor PARAMS: InitStateVar=0.362079
X3109   32   119  memristor PARAMS: InitStateVar=0.388529
X3209   33   119  memristor PARAMS: InitStateVar=0.19684
X3309   34   119  memristor PARAMS: InitStateVar=0.360327
X3409   35   119  memristor PARAMS: InitStateVar=0.222514
X3509   36   119  memristor PARAMS: InitStateVar=0.495713
X3609   37   119  memristor PARAMS: InitStateVar=0.330179
X3709   38   119  memristor PARAMS: InitStateVar=0.351808
X3809   39   119  memristor PARAMS: InitStateVar=0.164824
X3909   40   119  memristor PARAMS: InitStateVar=0.383915
X4009   41   119  memristor PARAMS: InitStateVar=0.241122
X4109   42   119  memristor PARAMS: InitStateVar=0.320236
X4209   43   119  memristor PARAMS: InitStateVar=0.143094
X4309   44   119  memristor PARAMS: InitStateVar=0.326983
X4409   45   119  memristor PARAMS: InitStateVar=0.592875
X4509   46   119  memristor PARAMS: InitStateVar=0.438641
X4609   47   119  memristor PARAMS: InitStateVar=0.229861
X4709   48   119  memristor PARAMS: InitStateVar=0.326059
X4809   49   119  memristor PARAMS: InitStateVar=0.344895
X4909   50   119  memristor PARAMS: InitStateVar=0.27839
X5009   51   119  memristor PARAMS: InitStateVar=0.0701154
X5109   52   119  memristor PARAMS: InitStateVar=0.131922
X5209   53   119  memristor PARAMS: InitStateVar=0.245175
X5309   54   119  memristor PARAMS: InitStateVar=0.106874
X5409   55   119  memristor PARAMS: InitStateVar=0.281401
X5509   56   119  memristor PARAMS: InitStateVar=0.547186
X5609   57   119  memristor PARAMS: InitStateVar=0.238795
X5709   58   119  memristor PARAMS: InitStateVar=0.258328
X5809   59   119  memristor PARAMS: InitStateVar=0.25879
X5909   60   119  memristor PARAMS: InitStateVar=0.169902
X6009   61   119  memristor PARAMS: InitStateVar=0.289875
X6109   62   119  memristor PARAMS: InitStateVar=0.237582
X6209   63   119  memristor PARAMS: InitStateVar=0.33845
X6309   64   119  memristor PARAMS: InitStateVar=0.339895
X6409   65   119  memristor PARAMS: InitStateVar=0.418652
X6509   66   119  memristor PARAMS: InitStateVar=0.232056
X6609   67   119  memristor PARAMS: InitStateVar=0.224945
X6709   68   119  memristor PARAMS: InitStateVar=0.250438
X6809   69   119  memristor PARAMS: InitStateVar=0.33802
X6909   70   119  memristor PARAMS: InitStateVar=0.302943
X7009   71   119  memristor PARAMS: InitStateVar=0.250558
X7109   72   119  memristor PARAMS: InitStateVar=0.25201
X7209   73   119  memristor PARAMS: InitStateVar=0.360188
X7309   74   119  memristor PARAMS: InitStateVar=0.265137
X7409   75   119  memristor PARAMS: InitStateVar=0.268313
X7509   76   119  memristor PARAMS: InitStateVar=0.426532
X7609   77   119  memristor PARAMS: InitStateVar=0.183373
X7709   78   119  memristor PARAMS: InitStateVar=0.226325
X7809   79   119  memristor PARAMS: InitStateVar=0.276117
X7909   80   119  memristor PARAMS: InitStateVar=0.200837
X8009   81   119  memristor PARAMS: InitStateVar=0.0302155
X8109   82   119  memristor PARAMS: InitStateVar=0.300643
X8209   83   119  memristor PARAMS: InitStateVar=0.283937
X8309   84   119  memristor PARAMS: InitStateVar=0.248952
X8409   85   119  memristor PARAMS: InitStateVar=0.281275
X8509   86   119  memristor PARAMS: InitStateVar=0.191208
X8609   87   119  memristor PARAMS: InitStateVar=0.172091
X8709   88   119  memristor PARAMS: InitStateVar=0.369294
X8809   89   119  memristor PARAMS: InitStateVar=0.263411
X8909   90   119  memristor PARAMS: InitStateVar=0.474921
X9009   91   119  memristor PARAMS: InitStateVar=0.430492
X9109   92   119  memristor PARAMS: InitStateVar=0.253217
X9209   93   119  memristor PARAMS: InitStateVar=0.313608
X9309   94   119  memristor PARAMS: InitStateVar=0.375807
X9409   95   119  memristor PARAMS: InitStateVar=0.457722
X9509   96   119  memristor PARAMS: InitStateVar=0.318368
X9609   97   119  memristor PARAMS: InitStateVar=0.274262
X9709   98   119  memristor PARAMS: InitStateVar=0.450392
X9809   99   119  memristor PARAMS: InitStateVar=0.203376
X9909   100  119  memristor PARAMS: InitStateVar=0.220427
Xo10    119  120  OutputModule PARAMS: Rval=100
*------------------- Column 11 -------------------------------------------------
X10     1    121  memristor PARAMS: InitStateVar=0.607831
X110    2    121  memristor PARAMS: InitStateVar=0.339565
X210    3    121  memristor PARAMS: InitStateVar=0.186084
X310    4    121  memristor PARAMS: InitStateVar=0.392096
X410    5    121  memristor PARAMS: InitStateVar=0.137942
X510    6    121  memristor PARAMS: InitStateVar=0.343758
X610    7    121  memristor PARAMS: InitStateVar=0.370118
X710    8    121  memristor PARAMS: InitStateVar=0.213145
X810    9    121  memristor PARAMS: InitStateVar=0.126565
X910    10   121  memristor PARAMS: InitStateVar=0.243247
X1010   11   121  memristor PARAMS: InitStateVar=0.260784
X1110   12   121  memristor PARAMS: InitStateVar=0.252029
X1210   13   121  memristor PARAMS: InitStateVar=0.109922
X1310   14   121  memristor PARAMS: InitStateVar=0.371157
X1410   15   121  memristor PARAMS: InitStateVar=0.412843
X1510   16   121  memristor PARAMS: InitStateVar=0.364793
X1610   17   121  memristor PARAMS: InitStateVar=0.353813
X1710   18   121  memristor PARAMS: InitStateVar=0.0901912
X1810   19   121  memristor PARAMS: InitStateVar=0.300126
X1910   20   121  memristor PARAMS: InitStateVar=0.00914514
X2010   21   121  memristor PARAMS: InitStateVar=0.249545
X2110   22   121  memristor PARAMS: InitStateVar=0.186632
X2210   23   121  memristor PARAMS: InitStateVar=0.287722
X2310   24   121  memristor PARAMS: InitStateVar=0.202684
X2410   25   121  memristor PARAMS: InitStateVar=0.267451
X2510   26   121  memristor PARAMS: InitStateVar=0.22058
X2610   27   121  memristor PARAMS: InitStateVar=0.297421
X2710   28   121  memristor PARAMS: InitStateVar=0.249058
X2810   29   121  memristor PARAMS: InitStateVar=0.148087
X2910   30   121  memristor PARAMS: InitStateVar=0.326202
X3010   31   121  memristor PARAMS: InitStateVar=0.213993
X3110   32   121  memristor PARAMS: InitStateVar=0.420608
X3210   33   121  memristor PARAMS: InitStateVar=0.284801
X3310   34   121  memristor PARAMS: InitStateVar=0.0617697
X3410   35   121  memristor PARAMS: InitStateVar=0.500751
X3510   36   121  memristor PARAMS: InitStateVar=0.122273
X3610   37   121  memristor PARAMS: InitStateVar=0.173444
X3710   38   121  memristor PARAMS: InitStateVar=0.502947
X3810   39   121  memristor PARAMS: InitStateVar=0.3215
X3910   40   121  memristor PARAMS: InitStateVar=0.333932
X4010   41   121  memristor PARAMS: InitStateVar=0.495414
X4110   42   121  memristor PARAMS: InitStateVar=0.209649
X4210   43   121  memristor PARAMS: InitStateVar=0.318415
X4310   44   121  memristor PARAMS: InitStateVar=0.5398
X4410   45   121  memristor PARAMS: InitStateVar=0.422531
X4510   46   121  memristor PARAMS: InitStateVar=0.344042
X4610   47   121  memristor PARAMS: InitStateVar=0.225008
X4710   48   121  memristor PARAMS: InitStateVar=0.226135
X4810   49   121  memristor PARAMS: InitStateVar=0.396671
X4910   50   121  memristor PARAMS: InitStateVar=0.167089
X5010   51   121  memristor PARAMS: InitStateVar=0.412336
X5110   52   121  memristor PARAMS: InitStateVar=0.311323
X5210   53   121  memristor PARAMS: InitStateVar=0.364785
X5310   54   121  memristor PARAMS: InitStateVar=0.220432
X5410   55   121  memristor PARAMS: InitStateVar=0.156334
X5510   56   121  memristor PARAMS: InitStateVar=0.363939
X5610   57   121  memristor PARAMS: InitStateVar=0.300849
X5710   58   121  memristor PARAMS: InitStateVar=0.258962
X5810   59   121  memristor PARAMS: InitStateVar=0.308966
X5910   60   121  memristor PARAMS: InitStateVar=0.283737
X6010   61   121  memristor PARAMS: InitStateVar=0.210615
X6110   62   121  memristor PARAMS: InitStateVar=0.279196
X6210   63   121  memristor PARAMS: InitStateVar=0.280247
X6310   64   121  memristor PARAMS: InitStateVar=0.133383
X6410   65   121  memristor PARAMS: InitStateVar=0.261011
X6510   66   121  memristor PARAMS: InitStateVar=0.258332
X6610   67   121  memristor PARAMS: InitStateVar=0.289792
X6710   68   121  memristor PARAMS: InitStateVar=0.370243
X6810   69   121  memristor PARAMS: InitStateVar=0.355483
X6910   70   121  memristor PARAMS: InitStateVar=0.268659
X7010   71   121  memristor PARAMS: InitStateVar=0.316719
X7110   72   121  memristor PARAMS: InitStateVar=0.264178
X7210   73   121  memristor PARAMS: InitStateVar=0.430703
X7310   74   121  memristor PARAMS: InitStateVar=0.229734
X7410   75   121  memristor PARAMS: InitStateVar=0.146533
X7510   76   121  memristor PARAMS: InitStateVar=0.321381
X7610   77   121  memristor PARAMS: InitStateVar=0.3049
X7710   78   121  memristor PARAMS: InitStateVar=0.253603
X7810   79   121  memristor PARAMS: InitStateVar=0.327285
X7910   80   121  memristor PARAMS: InitStateVar=0.403645
X8010   81   121  memristor PARAMS: InitStateVar=0.464969
X8110   82   121  memristor PARAMS: InitStateVar=0.202264
X8210   83   121  memristor PARAMS: InitStateVar=0.256378
X8310   84   121  memristor PARAMS: InitStateVar=0.3164
X8410   85   121  memristor PARAMS: InitStateVar=0.126944
X8510   86   121  memristor PARAMS: InitStateVar=0.334656
X8610   87   121  memristor PARAMS: InitStateVar=0.362038
X8710   88   121  memristor PARAMS: InitStateVar=0.544585
X8810   89   121  memristor PARAMS: InitStateVar=0.270298
X8910   90   121  memristor PARAMS: InitStateVar=0.320299
X9010   91   121  memristor PARAMS: InitStateVar=0.102402
X9110   92   121  memristor PARAMS: InitStateVar=0.288984
X9210   93   121  memristor PARAMS: InitStateVar=0.399752
X9310   94   121  memristor PARAMS: InitStateVar=0.178926
X9410   95   121  memristor PARAMS: InitStateVar=0.292455
X9510   96   121  memristor PARAMS: InitStateVar=0.290209
X9610   97   121  memristor PARAMS: InitStateVar=0.365533
X9710   98   121  memristor PARAMS: InitStateVar=0.314173
X9810   99   121  memristor PARAMS: InitStateVar=0.487287
X9910   100  121  memristor PARAMS: InitStateVar=0.34734
Xo11    121  122  OutputModule PARAMS: Rval=100
*------------------- Column 12 -------------------------------------------------
X11     1    123  memristor PARAMS: InitStateVar=0.242686
X111    2    123  memristor PARAMS: InitStateVar=0.266903
X211    3    123  memristor PARAMS: InitStateVar=0.457446
X311    4    123  memristor PARAMS: InitStateVar=0.195082
X411    5    123  memristor PARAMS: InitStateVar=0.402654
X511    6    123  memristor PARAMS: InitStateVar=0.238563
X611    7    123  memristor PARAMS: InitStateVar=0.388016
X711    8    123  memristor PARAMS: InitStateVar=0.266261
X811    9    123  memristor PARAMS: InitStateVar=0.536367
X911    10   123  memristor PARAMS: InitStateVar=0.250422
X1011   11   123  memristor PARAMS: InitStateVar=0.406028
X1111   12   123  memristor PARAMS: InitStateVar=0.353666
X1211   13   123  memristor PARAMS: InitStateVar=0.308499
X1311   14   123  memristor PARAMS: InitStateVar=0.474341
X1411   15   123  memristor PARAMS: InitStateVar=0.278334
X1511   16   123  memristor PARAMS: InitStateVar=0.136984
X1611   17   123  memristor PARAMS: InitStateVar=0.430523
X1711   18   123  memristor PARAMS: InitStateVar=0.196241
X1811   19   123  memristor PARAMS: InitStateVar=0.293829
X1911   20   123  memristor PARAMS: InitStateVar=0.340797
X2011   21   123  memristor PARAMS: InitStateVar=0.281636
X2111   22   123  memristor PARAMS: InitStateVar=0.122015
X2211   23   123  memristor PARAMS: InitStateVar=0.455438
X2311   24   123  memristor PARAMS: InitStateVar=0.192025
X2411   25   123  memristor PARAMS: InitStateVar=0.146759
X2511   26   123  memristor PARAMS: InitStateVar=0.130922
X2611   27   123  memristor PARAMS: InitStateVar=0.353175
X2711   28   123  memristor PARAMS: InitStateVar=0.363702
X2811   29   123  memristor PARAMS: InitStateVar=0.387994
X2911   30   123  memristor PARAMS: InitStateVar=0.511931
X3011   31   123  memristor PARAMS: InitStateVar=0.485123
X3111   32   123  memristor PARAMS: InitStateVar=0.265572
X3211   33   123  memristor PARAMS: InitStateVar=0.453027
X3311   34   123  memristor PARAMS: InitStateVar=0.339879
X3411   35   123  memristor PARAMS: InitStateVar=0.161373
X3511   36   123  memristor PARAMS: InitStateVar=0.547496
X3611   37   123  memristor PARAMS: InitStateVar=0.0442912
X3711   38   123  memristor PARAMS: InitStateVar=0.231942
X3811   39   123  memristor PARAMS: InitStateVar=0.437387
X3911   40   123  memristor PARAMS: InitStateVar=0.322133
X4011   41   123  memristor PARAMS: InitStateVar=0.233288
X4111   42   123  memristor PARAMS: InitStateVar=0.262035
X4211   43   123  memristor PARAMS: InitStateVar=0.31522
X4311   44   123  memristor PARAMS: InitStateVar=0.215673
X4411   45   123  memristor PARAMS: InitStateVar=0.350132
X4511   46   123  memristor PARAMS: InitStateVar=0.295193
X4611   47   123  memristor PARAMS: InitStateVar=0.373321
X4711   48   123  memristor PARAMS: InitStateVar=0.302524
X4811   49   123  memristor PARAMS: InitStateVar=0.191664
X4911   50   123  memristor PARAMS: InitStateVar=0.35218
X5011   51   123  memristor PARAMS: InitStateVar=0.298147
X5111   52   123  memristor PARAMS: InitStateVar=0.326687
X5211   53   123  memristor PARAMS: InitStateVar=0.353012
X5311   54   123  memristor PARAMS: InitStateVar=0.246449
X5411   55   123  memristor PARAMS: InitStateVar=0.189313
X5511   56   123  memristor PARAMS: InitStateVar=0.37093
X5611   57   123  memristor PARAMS: InitStateVar=0.288492
X5711   58   123  memristor PARAMS: InitStateVar=0.570027
X5811   59   123  memristor PARAMS: InitStateVar=0.350507
X5911   60   123  memristor PARAMS: InitStateVar=0.208534
X6011   61   123  memristor PARAMS: InitStateVar=0.350844
X6111   62   123  memristor PARAMS: InitStateVar=0.269942
X6211   63   123  memristor PARAMS: InitStateVar=0.341054
X6311   64   123  memristor PARAMS: InitStateVar=0.273964
X6411   65   123  memristor PARAMS: InitStateVar=0.401203
X6511   66   123  memristor PARAMS: InitStateVar=0.356853
X6611   67   123  memristor PARAMS: InitStateVar=0.395642
X6711   68   123  memristor PARAMS: InitStateVar=0.206585
X6811   69   123  memristor PARAMS: InitStateVar=0.235921
X6911   70   123  memristor PARAMS: InitStateVar=0.173941
X7011   71   123  memristor PARAMS: InitStateVar=0.545578
X7111   72   123  memristor PARAMS: InitStateVar=0.39756
X7211   73   123  memristor PARAMS: InitStateVar=0.233513
X7311   74   123  memristor PARAMS: InitStateVar=0.262391
X7411   75   123  memristor PARAMS: InitStateVar=0.38403
X7511   76   123  memristor PARAMS: InitStateVar=0.350061
X7611   77   123  memristor PARAMS: InitStateVar=0.408613
X7711   78   123  memristor PARAMS: InitStateVar=0.206565
X7811   79   123  memristor PARAMS: InitStateVar=0.204253
X7911   80   123  memristor PARAMS: InitStateVar=0.330513
X8011   81   123  memristor PARAMS: InitStateVar=0.264837
X8111   82   123  memristor PARAMS: InitStateVar=0.240761
X8211   83   123  memristor PARAMS: InitStateVar=0.237473
X8311   84   123  memristor PARAMS: InitStateVar=0.194367
X8411   85   123  memristor PARAMS: InitStateVar=0.332109
X8511   86   123  memristor PARAMS: InitStateVar=0.239159
X8611   87   123  memristor PARAMS: InitStateVar=0.273925
X8711   88   123  memristor PARAMS: InitStateVar=0.197677
X8811   89   123  memristor PARAMS: InitStateVar=0.305487
X8911   90   123  memristor PARAMS: InitStateVar=0.226348
X9011   91   123  memristor PARAMS: InitStateVar=0.261137
X9111   92   123  memristor PARAMS: InitStateVar=0.402643
X9211   93   123  memristor PARAMS: InitStateVar=0.331941
X9311   94   123  memristor PARAMS: InitStateVar=0.256143
X9411   95   123  memristor PARAMS: InitStateVar=0.375519
X9511   96   123  memristor PARAMS: InitStateVar=0.398236
X9611   97   123  memristor PARAMS: InitStateVar=0.219191
X9711   98   123  memristor PARAMS: InitStateVar=0.483661
X9811   99   123  memristor PARAMS: InitStateVar=0.187819
X9911   100  123  memristor PARAMS: InitStateVar=0.273273
Xo12    123  124  OutputModule PARAMS: Rval=100
*------------------- Column 13 -------------------------------------------------
X12     1    125  memristor PARAMS: InitStateVar=0.2333
X112    2    125  memristor PARAMS: InitStateVar=0.303129
X212    3    125  memristor PARAMS: InitStateVar=0.176651
X312    4    125  memristor PARAMS: InitStateVar=0.342087
X412    5    125  memristor PARAMS: InitStateVar=0.281313
X512    6    125  memristor PARAMS: InitStateVar=0.210392
X612    7    125  memristor PARAMS: InitStateVar=0.167359
X712    8    125  memristor PARAMS: InitStateVar=0.110048
X812    9    125  memristor PARAMS: InitStateVar=0.338832
X912    10   125  memristor PARAMS: InitStateVar=0.345153
X1012   11   125  memristor PARAMS: InitStateVar=0.249569
X1112   12   125  memristor PARAMS: InitStateVar=0.386352
X1212   13   125  memristor PARAMS: InitStateVar=0.290234
X1312   14   125  memristor PARAMS: InitStateVar=0.227986
X1412   15   125  memristor PARAMS: InitStateVar=0.417701
X1512   16   125  memristor PARAMS: InitStateVar=0.449909
X1612   17   125  memristor PARAMS: InitStateVar=0.309059
X1712   18   125  memristor PARAMS: InitStateVar=0.412483
X1812   19   125  memristor PARAMS: InitStateVar=0.404064
X1912   20   125  memristor PARAMS: InitStateVar=0.134828
X2012   21   125  memristor PARAMS: InitStateVar=0.221298
X2112   22   125  memristor PARAMS: InitStateVar=0.193966
X2212   23   125  memristor PARAMS: InitStateVar=0.370153
X2312   24   125  memristor PARAMS: InitStateVar=0.56823
X2412   25   125  memristor PARAMS: InitStateVar=0.358752
X2512   26   125  memristor PARAMS: InitStateVar=0.188829
X2612   27   125  memristor PARAMS: InitStateVar=0.384335
X2712   28   125  memristor PARAMS: InitStateVar=0.22566
X2812   29   125  memristor PARAMS: InitStateVar=0.375561
X2912   30   125  memristor PARAMS: InitStateVar=0.258286
X3012   31   125  memristor PARAMS: InitStateVar=0.300902
X3112   32   125  memristor PARAMS: InitStateVar=0.453234
X3212   33   125  memristor PARAMS: InitStateVar=0.246317
X3312   34   125  memristor PARAMS: InitStateVar=0.327074
X3412   35   125  memristor PARAMS: InitStateVar=0.424163
X3512   36   125  memristor PARAMS: InitStateVar=0.304282
X3612   37   125  memristor PARAMS: InitStateVar=0.228075
X3712   38   125  memristor PARAMS: InitStateVar=0.347759
X3812   39   125  memristor PARAMS: InitStateVar=0.261751
X3912   40   125  memristor PARAMS: InitStateVar=0.102662
X4012   41   125  memristor PARAMS: InitStateVar=0.243641
X4112   42   125  memristor PARAMS: InitStateVar=0.225186
X4212   43   125  memristor PARAMS: InitStateVar=0.454377
X4312   44   125  memristor PARAMS: InitStateVar=0.389315
X4412   45   125  memristor PARAMS: InitStateVar=0.413757
X4512   46   125  memristor PARAMS: InitStateVar=0.29791
X4612   47   125  memristor PARAMS: InitStateVar=0.401739
X4712   48   125  memristor PARAMS: InitStateVar=0.367771
X4812   49   125  memristor PARAMS: InitStateVar=0.199141
X4912   50   125  memristor PARAMS: InitStateVar=0.31293
X5012   51   125  memristor PARAMS: InitStateVar=0.282606
X5112   52   125  memristor PARAMS: InitStateVar=0.337111
X5212   53   125  memristor PARAMS: InitStateVar=0.322312
X5312   54   125  memristor PARAMS: InitStateVar=0.214291
X5412   55   125  memristor PARAMS: InitStateVar=0.348299
X5512   56   125  memristor PARAMS: InitStateVar=0.416575
X5612   57   125  memristor PARAMS: InitStateVar=0.160461
X5712   58   125  memristor PARAMS: InitStateVar=0.11561
X5812   59   125  memristor PARAMS: InitStateVar=0.501548
X5912   60   125  memristor PARAMS: InitStateVar=0.253027
X6012   61   125  memristor PARAMS: InitStateVar=0.381639
X6112   62   125  memristor PARAMS: InitStateVar=0.152868
X6212   63   125  memristor PARAMS: InitStateVar=0.386507
X6312   64   125  memristor PARAMS: InitStateVar=0.447395
X6412   65   125  memristor PARAMS: InitStateVar=0.17513
X6512   66   125  memristor PARAMS: InitStateVar=0.382502
X6612   67   125  memristor PARAMS: InitStateVar=0.394241
X6712   68   125  memristor PARAMS: InitStateVar=0.327762
X6812   69   125  memristor PARAMS: InitStateVar=0.318482
X6912   70   125  memristor PARAMS: InitStateVar=0.271061
X7012   71   125  memristor PARAMS: InitStateVar=0.418888
X7112   72   125  memristor PARAMS: InitStateVar=0.403886
X7212   73   125  memristor PARAMS: InitStateVar=0.13898
X7312   74   125  memristor PARAMS: InitStateVar=0.372884
X7412   75   125  memristor PARAMS: InitStateVar=0.345965
X7512   76   125  memristor PARAMS: InitStateVar=0.33461
X7612   77   125  memristor PARAMS: InitStateVar=0.199945
X7712   78   125  memristor PARAMS: InitStateVar=0.20853
X7812   79   125  memristor PARAMS: InitStateVar=0.188997
X7912   80   125  memristor PARAMS: InitStateVar=0.269824
X8012   81   125  memristor PARAMS: InitStateVar=0.446028
X8112   82   125  memristor PARAMS: InitStateVar=0.373173
X8212   83   125  memristor PARAMS: InitStateVar=0.437448
X8312   84   125  memristor PARAMS: InitStateVar=0.517271
X8412   85   125  memristor PARAMS: InitStateVar=0.302277
X8512   86   125  memristor PARAMS: InitStateVar=0.295327
X8612   87   125  memristor PARAMS: InitStateVar=0.200728
X8712   88   125  memristor PARAMS: InitStateVar=0.287457
X8812   89   125  memristor PARAMS: InitStateVar=0.252388
X8912   90   125  memristor PARAMS: InitStateVar=0.326273
X9012   91   125  memristor PARAMS: InitStateVar=0.293101
X9112   92   125  memristor PARAMS: InitStateVar=0.268204
X9212   93   125  memristor PARAMS: InitStateVar=0.229652
X9312   94   125  memristor PARAMS: InitStateVar=0.253655
X9412   95   125  memristor PARAMS: InitStateVar=0.265327
X9512   96   125  memristor PARAMS: InitStateVar=0.217516
X9612   97   125  memristor PARAMS: InitStateVar=0.317772
X9712   98   125  memristor PARAMS: InitStateVar=0.37387
X9812   99   125  memristor PARAMS: InitStateVar=0.128047
X9912   100  125  memristor PARAMS: InitStateVar=0.413238
Xo13    125  126  OutputModule PARAMS: Rval=100
*------------------- Column 14 -------------------------------------------------
X13     1    127  memristor PARAMS: InitStateVar=0.26975
X113    2    127  memristor PARAMS: InitStateVar=0.186233
X213    3    127  memristor PARAMS: InitStateVar=0.427562
X313    4    127  memristor PARAMS: InitStateVar=0.329142
X413    5    127  memristor PARAMS: InitStateVar=0.315465
X513    6    127  memristor PARAMS: InitStateVar=0.28907
X613    7    127  memristor PARAMS: InitStateVar=0.358894
X713    8    127  memristor PARAMS: InitStateVar=0.516773
X813    9    127  memristor PARAMS: InitStateVar=0.315495
X913    10   127  memristor PARAMS: InitStateVar=0.100475
X1013   11   127  memristor PARAMS: InitStateVar=0.308932
X1113   12   127  memristor PARAMS: InitStateVar=0.276848
X1213   13   127  memristor PARAMS: InitStateVar=0.352767
X1313   14   127  memristor PARAMS: InitStateVar=0.218744
X1413   15   127  memristor PARAMS: InitStateVar=0.169182
X1513   16   127  memristor PARAMS: InitStateVar=0.329115
X1613   17   127  memristor PARAMS: InitStateVar=0.534388
X1713   18   127  memristor PARAMS: InitStateVar=0.277873
X1813   19   127  memristor PARAMS: InitStateVar=0.296917
X1913   20   127  memristor PARAMS: InitStateVar=0.0906863
X2013   21   127  memristor PARAMS: InitStateVar=0.133377
X2113   22   127  memristor PARAMS: InitStateVar=0.370989
X2213   23   127  memristor PARAMS: InitStateVar=0.378423
X2313   24   127  memristor PARAMS: InitStateVar=0.376823
X2413   25   127  memristor PARAMS: InitStateVar=0.300409
X2513   26   127  memristor PARAMS: InitStateVar=0.187313
X2613   27   127  memristor PARAMS: InitStateVar=0.229733
X2713   28   127  memristor PARAMS: InitStateVar=0.157877
X2813   29   127  memristor PARAMS: InitStateVar=0.332325
X2913   30   127  memristor PARAMS: InitStateVar=0.155255
X3013   31   127  memristor PARAMS: InitStateVar=0.447655
X3113   32   127  memristor PARAMS: InitStateVar=0.447373
X3213   33   127  memristor PARAMS: InitStateVar=0.11785
X3313   34   127  memristor PARAMS: InitStateVar=0.240453
X3413   35   127  memristor PARAMS: InitStateVar=0.15983
X3513   36   127  memristor PARAMS: InitStateVar=0.379811
X3613   37   127  memristor PARAMS: InitStateVar=0.279137
X3713   38   127  memristor PARAMS: InitStateVar=0.237049
X3813   39   127  memristor PARAMS: InitStateVar=0.297772
X3913   40   127  memristor PARAMS: InitStateVar=0.198384
X4013   41   127  memristor PARAMS: InitStateVar=0.312911
X4113   42   127  memristor PARAMS: InitStateVar=0.135242
X4213   43   127  memristor PARAMS: InitStateVar=0.220917
X4313   44   127  memristor PARAMS: InitStateVar=0.247408
X4413   45   127  memristor PARAMS: InitStateVar=0.296686
X4513   46   127  memristor PARAMS: InitStateVar=0.27144
X4613   47   127  memristor PARAMS: InitStateVar=0.263756
X4713   48   127  memristor PARAMS: InitStateVar=0.350123
X4813   49   127  memristor PARAMS: InitStateVar=0.307027
X4913   50   127  memristor PARAMS: InitStateVar=0.121038
X5013   51   127  memristor PARAMS: InitStateVar=0.348225
X5113   52   127  memristor PARAMS: InitStateVar=0.262332
X5213   53   127  memristor PARAMS: InitStateVar=0.197019
X5313   54   127  memristor PARAMS: InitStateVar=0.369947
X5413   55   127  memristor PARAMS: InitStateVar=0.241328
X5513   56   127  memristor PARAMS: InitStateVar=0.263433
X5613   57   127  memristor PARAMS: InitStateVar=0.252244
X5713   58   127  memristor PARAMS: InitStateVar=0.0862058
X5813   59   127  memristor PARAMS: InitStateVar=0.112408
X5913   60   127  memristor PARAMS: InitStateVar=0.286948
X6013   61   127  memristor PARAMS: InitStateVar=0.326805
X6113   62   127  memristor PARAMS: InitStateVar=0.466703
X6213   63   127  memristor PARAMS: InitStateVar=0.153583
X6313   64   127  memristor PARAMS: InitStateVar=0.344471
X6413   65   127  memristor PARAMS: InitStateVar=0.235022
X6513   66   127  memristor PARAMS: InitStateVar=0.28059
X6613   67   127  memristor PARAMS: InitStateVar=0.18916
X6713   68   127  memristor PARAMS: InitStateVar=0.251611
X6813   69   127  memristor PARAMS: InitStateVar=0.417002
X6913   70   127  memristor PARAMS: InitStateVar=0.278316
X7013   71   127  memristor PARAMS: InitStateVar=0.444122
X7113   72   127  memristor PARAMS: InitStateVar=0.448984
X7213   73   127  memristor PARAMS: InitStateVar=0.366117
X7313   74   127  memristor PARAMS: InitStateVar=0.313805
X7413   75   127  memristor PARAMS: InitStateVar=0.326242
X7513   76   127  memristor PARAMS: InitStateVar=0.142189
X7613   77   127  memristor PARAMS: InitStateVar=0.249503
X7713   78   127  memristor PARAMS: InitStateVar=0.309743
X7813   79   127  memristor PARAMS: InitStateVar=0.198013
X7913   80   127  memristor PARAMS: InitStateVar=0.266252
X8013   81   127  memristor PARAMS: InitStateVar=0.229104
X8113   82   127  memristor PARAMS: InitStateVar=0.256959
X8213   83   127  memristor PARAMS: InitStateVar=0.214813
X8313   84   127  memristor PARAMS: InitStateVar=0.160736
X8413   85   127  memristor PARAMS: InitStateVar=0.207156
X8513   86   127  memristor PARAMS: InitStateVar=0.320866
X8613   87   127  memristor PARAMS: InitStateVar=0.396268
X8713   88   127  memristor PARAMS: InitStateVar=0.0945822
X8813   89   127  memristor PARAMS: InitStateVar=0.334025
X8913   90   127  memristor PARAMS: InitStateVar=0.517811
X9013   91   127  memristor PARAMS: InitStateVar=0.268696
X9113   92   127  memristor PARAMS: InitStateVar=0.387625
X9213   93   127  memristor PARAMS: InitStateVar=0.312383
X9313   94   127  memristor PARAMS: InitStateVar=0.319062
X9413   95   127  memristor PARAMS: InitStateVar=0.213318
X9513   96   127  memristor PARAMS: InitStateVar=0.396741
X9613   97   127  memristor PARAMS: InitStateVar=0.121335
X9713   98   127  memristor PARAMS: InitStateVar=0.213721
X9813   99   127  memristor PARAMS: InitStateVar=0.240139
X9913   100  127  memristor PARAMS: InitStateVar=0.344536
Xo14    127  128  OutputModule PARAMS: Rval=100
*------------------- Column 15 -------------------------------------------------
X14     1    129  memristor PARAMS: InitStateVar=0.477494
X114    2    129  memristor PARAMS: InitStateVar=0.22335
X214    3    129  memristor PARAMS: InitStateVar=0.222524
X314    4    129  memristor PARAMS: InitStateVar=0.380195
X414    5    129  memristor PARAMS: InitStateVar=0.215807
X514    6    129  memristor PARAMS: InitStateVar=0.514691
X614    7    129  memristor PARAMS: InitStateVar=0.243863
X714    8    129  memristor PARAMS: InitStateVar=0.406124
X814    9    129  memristor PARAMS: InitStateVar=0.293381
X914    10   129  memristor PARAMS: InitStateVar=0.104574
X1014   11   129  memristor PARAMS: InitStateVar=0.192366
X1114   12   129  memristor PARAMS: InitStateVar=0.286997
X1214   13   129  memristor PARAMS: InitStateVar=0.486813
X1314   14   129  memristor PARAMS: InitStateVar=0.332003
X1414   15   129  memristor PARAMS: InitStateVar=0.223138
X1514   16   129  memristor PARAMS: InitStateVar=0.186222
X1614   17   129  memristor PARAMS: InitStateVar=0.444898
X1714   18   129  memristor PARAMS: InitStateVar=0.298694
X1814   19   129  memristor PARAMS: InitStateVar=0.322986
X1914   20   129  memristor PARAMS: InitStateVar=0.332357
X2014   21   129  memristor PARAMS: InitStateVar=0.269388
X2114   22   129  memristor PARAMS: InitStateVar=0.379969
X2214   23   129  memristor PARAMS: InitStateVar=0.237376
X2314   24   129  memristor PARAMS: InitStateVar=0.338247
X2414   25   129  memristor PARAMS: InitStateVar=0.333476
X2514   26   129  memristor PARAMS: InitStateVar=0.287604
X2614   27   129  memristor PARAMS: InitStateVar=0.229249
X2714   28   129  memristor PARAMS: InitStateVar=0.320612
X2814   29   129  memristor PARAMS: InitStateVar=0.153273
X2914   30   129  memristor PARAMS: InitStateVar=0.100334
X3014   31   129  memristor PARAMS: InitStateVar=0.423172
X3114   32   129  memristor PARAMS: InitStateVar=0.287244
X3214   33   129  memristor PARAMS: InitStateVar=0.338262
X3314   34   129  memristor PARAMS: InitStateVar=0.483753
X3414   35   129  memristor PARAMS: InitStateVar=0.270337
X3514   36   129  memristor PARAMS: InitStateVar=0.387211
X3614   37   129  memristor PARAMS: InitStateVar=0.267293
X3714   38   129  memristor PARAMS: InitStateVar=0.470891
X3814   39   129  memristor PARAMS: InitStateVar=0.149976
X3914   40   129  memristor PARAMS: InitStateVar=0.308279
X4014   41   129  memristor PARAMS: InitStateVar=0.213011
X4114   42   129  memristor PARAMS: InitStateVar=0.122343
X4214   43   129  memristor PARAMS: InitStateVar=0.198299
X4314   44   129  memristor PARAMS: InitStateVar=0.30277
X4414   45   129  memristor PARAMS: InitStateVar=0.328774
X4514   46   129  memristor PARAMS: InitStateVar=0.42771
X4614   47   129  memristor PARAMS: InitStateVar=0.230385
X4714   48   129  memristor PARAMS: InitStateVar=0.21351
X4814   49   129  memristor PARAMS: InitStateVar=0.163314
X4914   50   129  memristor PARAMS: InitStateVar=0.387994
X5014   51   129  memristor PARAMS: InitStateVar=0.319951
X5114   52   129  memristor PARAMS: InitStateVar=0.454784
X5214   53   129  memristor PARAMS: InitStateVar=0.313293
X5314   54   129  memristor PARAMS: InitStateVar=0.227746
X5414   55   129  memristor PARAMS: InitStateVar=0.222951
X5514   56   129  memristor PARAMS: InitStateVar=0.251594
X5614   57   129  memristor PARAMS: InitStateVar=0.423567
X5714   58   129  memristor PARAMS: InitStateVar=0.280621
X5814   59   129  memristor PARAMS: InitStateVar=0.241617
X5914   60   129  memristor PARAMS: InitStateVar=0.279351
X6014   61   129  memristor PARAMS: InitStateVar=0.237193
X6114   62   129  memristor PARAMS: InitStateVar=0.324053
X6214   63   129  memristor PARAMS: InitStateVar=0.481552
X6314   64   129  memristor PARAMS: InitStateVar=0.268907
X6414   65   129  memristor PARAMS: InitStateVar=0.320196
X6514   66   129  memristor PARAMS: InitStateVar=0.284695
X6614   67   129  memristor PARAMS: InitStateVar=0.302556
X6714   68   129  memristor PARAMS: InitStateVar=0.200476
X6814   69   129  memristor PARAMS: InitStateVar=0.447381
X6914   70   129  memristor PARAMS: InitStateVar=0.277232
X7014   71   129  memristor PARAMS: InitStateVar=0.280339
X7114   72   129  memristor PARAMS: InitStateVar=0.0749164
X7214   73   129  memristor PARAMS: InitStateVar=0.269123
X7314   74   129  memristor PARAMS: InitStateVar=0.197791
X7414   75   129  memristor PARAMS: InitStateVar=0.267105
X7514   76   129  memristor PARAMS: InitStateVar=0.118374
X7614   77   129  memristor PARAMS: InitStateVar=0.274033
X7714   78   129  memristor PARAMS: InitStateVar=0.438721
X7814   79   129  memristor PARAMS: InitStateVar=0.492027
X7914   80   129  memristor PARAMS: InitStateVar=0.213996
X8014   81   129  memristor PARAMS: InitStateVar=0.130482
X8114   82   129  memristor PARAMS: InitStateVar=0.344338
X8214   83   129  memristor PARAMS: InitStateVar=0.216495
X8314   84   129  memristor PARAMS: InitStateVar=0.20611
X8414   85   129  memristor PARAMS: InitStateVar=0.561642
X8514   86   129  memristor PARAMS: InitStateVar=0.216015
X8614   87   129  memristor PARAMS: InitStateVar=0.226239
X8714   88   129  memristor PARAMS: InitStateVar=0.434229
X8814   89   129  memristor PARAMS: InitStateVar=0.447492
X8914   90   129  memristor PARAMS: InitStateVar=0.405807
X9014   91   129  memristor PARAMS: InitStateVar=0.329828
X9114   92   129  memristor PARAMS: InitStateVar=0.321908
X9214   93   129  memristor PARAMS: InitStateVar=0.192351
X9314   94   129  memristor PARAMS: InitStateVar=0.34821
X9414   95   129  memristor PARAMS: InitStateVar=0.516094
X9514   96   129  memristor PARAMS: InitStateVar=0.345917
X9614   97   129  memristor PARAMS: InitStateVar=0.388653
X9714   98   129  memristor PARAMS: InitStateVar=0.493813
X9814   99   129  memristor PARAMS: InitStateVar=0.394283
X9914   100  129  memristor PARAMS: InitStateVar=0.31063
Xo15    129  130  OutputModule PARAMS: Rval=100
*------------------- Column 16 -------------------------------------------------
X15     1    131  memristor PARAMS: InitStateVar=0.301678
X115    2    131  memristor PARAMS: InitStateVar=0.311087
X215    3    131  memristor PARAMS: InitStateVar=0.174103
X315    4    131  memristor PARAMS: InitStateVar=0.229653
X415    5    131  memristor PARAMS: InitStateVar=0.253131
X515    6    131  memristor PARAMS: InitStateVar=0.415337
X615    7    131  memristor PARAMS: InitStateVar=0.35986
X715    8    131  memristor PARAMS: InitStateVar=0.4221
X815    9    131  memristor PARAMS: InitStateVar=0.131087
X915    10   131  memristor PARAMS: InitStateVar=0.435394
X1015   11   131  memristor PARAMS: InitStateVar=0.424335
X1115   12   131  memristor PARAMS: InitStateVar=0.240683
X1215   13   131  memristor PARAMS: InitStateVar=0.27917
X1315   14   131  memristor PARAMS: InitStateVar=0.27871
X1415   15   131  memristor PARAMS: InitStateVar=0.321627
X1515   16   131  memristor PARAMS: InitStateVar=0.376631
X1615   17   131  memristor PARAMS: InitStateVar=0.220376
X1715   18   131  memristor PARAMS: InitStateVar=0.304463
X1815   19   131  memristor PARAMS: InitStateVar=0.34128
X1915   20   131  memristor PARAMS: InitStateVar=0.304425
X2015   21   131  memristor PARAMS: InitStateVar=0.392879
X2115   22   131  memristor PARAMS: InitStateVar=0.499803
X2215   23   131  memristor PARAMS: InitStateVar=0.160929
X2315   24   131  memristor PARAMS: InitStateVar=0.14586
X2415   25   131  memristor PARAMS: InitStateVar=0.345512
X2515   26   131  memristor PARAMS: InitStateVar=0.460497
X2615   27   131  memristor PARAMS: InitStateVar=0.383958
X2715   28   131  memristor PARAMS: InitStateVar=0.324386
X2815   29   131  memristor PARAMS: InitStateVar=0.322642
X2915   30   131  memristor PARAMS: InitStateVar=0.366718
X3015   31   131  memristor PARAMS: InitStateVar=0.399673
X3115   32   131  memristor PARAMS: InitStateVar=0.30553
X3215   33   131  memristor PARAMS: InitStateVar=0.345777
X3315   34   131  memristor PARAMS: InitStateVar=0.139686
X3415   35   131  memristor PARAMS: InitStateVar=0.15013
X3515   36   131  memristor PARAMS: InitStateVar=0.382409
X3615   37   131  memristor PARAMS: InitStateVar=0.379931
X3715   38   131  memristor PARAMS: InitStateVar=0.409286
X3815   39   131  memristor PARAMS: InitStateVar=0.374118
X3915   40   131  memristor PARAMS: InitStateVar=0.156528
X4015   41   131  memristor PARAMS: InitStateVar=0.317305
X4115   42   131  memristor PARAMS: InitStateVar=0.477058
X4215   43   131  memristor PARAMS: InitStateVar=0.37417
X4315   44   131  memristor PARAMS: InitStateVar=0.196901
X4415   45   131  memristor PARAMS: InitStateVar=0.359632
X4515   46   131  memristor PARAMS: InitStateVar=0.191026
X4615   47   131  memristor PARAMS: InitStateVar=0.300294
X4715   48   131  memristor PARAMS: InitStateVar=0.50579
X4815   49   131  memristor PARAMS: InitStateVar=0.130342
X4915   50   131  memristor PARAMS: InitStateVar=0.177101
X5015   51   131  memristor PARAMS: InitStateVar=0.232515
X5115   52   131  memristor PARAMS: InitStateVar=0.161537
X5215   53   131  memristor PARAMS: InitStateVar=0.226263
X5315   54   131  memristor PARAMS: InitStateVar=0.592502
X5415   55   131  memristor PARAMS: InitStateVar=0.226426
X5515   56   131  memristor PARAMS: InitStateVar=0.315893
X5615   57   131  memristor PARAMS: InitStateVar=0.365267
X5715   58   131  memristor PARAMS: InitStateVar=0.28174
X5815   59   131  memristor PARAMS: InitStateVar=0.318498
X5915   60   131  memristor PARAMS: InitStateVar=0.380196
X6015   61   131  memristor PARAMS: InitStateVar=0.269546
X6115   62   131  memristor PARAMS: InitStateVar=0.355443
X6215   63   131  memristor PARAMS: InitStateVar=0.484141
X6315   64   131  memristor PARAMS: InitStateVar=0.363423
X6415   65   131  memristor PARAMS: InitStateVar=0.242876
X6515   66   131  memristor PARAMS: InitStateVar=0.241107
X6615   67   131  memristor PARAMS: InitStateVar=0.241163
X6715   68   131  memristor PARAMS: InitStateVar=0.217613
X6815   69   131  memristor PARAMS: InitStateVar=0.234096
X6915   70   131  memristor PARAMS: InitStateVar=0.276985
X7015   71   131  memristor PARAMS: InitStateVar=0.466617
X7115   72   131  memristor PARAMS: InitStateVar=0.340561
X7215   73   131  memristor PARAMS: InitStateVar=0.158692
X7315   74   131  memristor PARAMS: InitStateVar=0.167718
X7415   75   131  memristor PARAMS: InitStateVar=0.352144
X7515   76   131  memristor PARAMS: InitStateVar=0.34075
X7615   77   131  memristor PARAMS: InitStateVar=0.278111
X7715   78   131  memristor PARAMS: InitStateVar=0.27859
X7815   79   131  memristor PARAMS: InitStateVar=0.450365
X7915   80   131  memristor PARAMS: InitStateVar=0.490112
X8015   81   131  memristor PARAMS: InitStateVar=0.421282
X8115   82   131  memristor PARAMS: InitStateVar=0.342272
X8215   83   131  memristor PARAMS: InitStateVar=0.295291
X8315   84   131  memristor PARAMS: InitStateVar=0.448081
X8415   85   131  memristor PARAMS: InitStateVar=0.290197
X8515   86   131  memristor PARAMS: InitStateVar=0.398604
X8615   87   131  memristor PARAMS: InitStateVar=0.41591
X8715   88   131  memristor PARAMS: InitStateVar=0.238849
X8815   89   131  memristor PARAMS: InitStateVar=0.479466
X8915   90   131  memristor PARAMS: InitStateVar=0.269178
X9015   91   131  memristor PARAMS: InitStateVar=0.35774
X9115   92   131  memristor PARAMS: InitStateVar=0.32468
X9215   93   131  memristor PARAMS: InitStateVar=0.211049
X9315   94   131  memristor PARAMS: InitStateVar=0.259722
X9415   95   131  memristor PARAMS: InitStateVar=0.265767
X9515   96   131  memristor PARAMS: InitStateVar=0.377828
X9615   97   131  memristor PARAMS: InitStateVar=0.286697
X9715   98   131  memristor PARAMS: InitStateVar=0.369744
X9815   99   131  memristor PARAMS: InitStateVar=0.300789
X9915   100  131  memristor PARAMS: InitStateVar=0.221721
Xo16    131  132  OutputModule PARAMS: Rval=100
*------------------- Column 17 -------------------------------------------------
X16     1    133  memristor PARAMS: InitStateVar=0.36776
X116    2    133  memristor PARAMS: InitStateVar=0.200935
X216    3    133  memristor PARAMS: InitStateVar=0.181295
X316    4    133  memristor PARAMS: InitStateVar=0.418667
X416    5    133  memristor PARAMS: InitStateVar=0.339927
X516    6    133  memristor PARAMS: InitStateVar=0.368938
X616    7    133  memristor PARAMS: InitStateVar=0.334593
X716    8    133  memristor PARAMS: InitStateVar=0.399651
X816    9    133  memristor PARAMS: InitStateVar=0.277054
X916    10   133  memristor PARAMS: InitStateVar=0.279818
X1016   11   133  memristor PARAMS: InitStateVar=0.25953
X1116   12   133  memristor PARAMS: InitStateVar=0.302977
X1216   13   133  memristor PARAMS: InitStateVar=0.489141
X1316   14   133  memristor PARAMS: InitStateVar=0.31252
X1416   15   133  memristor PARAMS: InitStateVar=0.444119
X1516   16   133  memristor PARAMS: InitStateVar=0.50193
X1616   17   133  memristor PARAMS: InitStateVar=0.196763
X1716   18   133  memristor PARAMS: InitStateVar=0.278409
X1816   19   133  memristor PARAMS: InitStateVar=0.193424
X1916   20   133  memristor PARAMS: InitStateVar=0.326428
X2016   21   133  memristor PARAMS: InitStateVar=0.210625
X2116   22   133  memristor PARAMS: InitStateVar=0.329795
X2216   23   133  memristor PARAMS: InitStateVar=0.215696
X2316   24   133  memristor PARAMS: InitStateVar=0.2875
X2416   25   133  memristor PARAMS: InitStateVar=0.382579
X2516   26   133  memristor PARAMS: InitStateVar=0.274119
X2616   27   133  memristor PARAMS: InitStateVar=0.036814
X2716   28   133  memristor PARAMS: InitStateVar=0.305639
X2816   29   133  memristor PARAMS: InitStateVar=0.149246
X2916   30   133  memristor PARAMS: InitStateVar=0.26169
X3016   31   133  memristor PARAMS: InitStateVar=0.313926
X3116   32   133  memristor PARAMS: InitStateVar=0.21887
X3216   33   133  memristor PARAMS: InitStateVar=0.342633
X3316   34   133  memristor PARAMS: InitStateVar=0.0706826
X3416   35   133  memristor PARAMS: InitStateVar=0.334047
X3516   36   133  memristor PARAMS: InitStateVar=0.342465
X3616   37   133  memristor PARAMS: InitStateVar=0.381845
X3716   38   133  memristor PARAMS: InitStateVar=0.385243
X3816   39   133  memristor PARAMS: InitStateVar=0.529939
X3916   40   133  memristor PARAMS: InitStateVar=0.336214
X4016   41   133  memristor PARAMS: InitStateVar=0.260348
X4116   42   133  memristor PARAMS: InitStateVar=0.142805
X4216   43   133  memristor PARAMS: InitStateVar=0.296979
X4316   44   133  memristor PARAMS: InitStateVar=0.458612
X4416   45   133  memristor PARAMS: InitStateVar=0.225511
X4516   46   133  memristor PARAMS: InitStateVar=0.219498
X4616   47   133  memristor PARAMS: InitStateVar=0.206405
X4716   48   133  memristor PARAMS: InitStateVar=0.435339
X4816   49   133  memristor PARAMS: InitStateVar=0.151501
X4916   50   133  memristor PARAMS: InitStateVar=0.208503
X5016   51   133  memristor PARAMS: InitStateVar=0.264318
X5116   52   133  memristor PARAMS: InitStateVar=0.407224
X5216   53   133  memristor PARAMS: InitStateVar=0.195356
X5316   54   133  memristor PARAMS: InitStateVar=0.247639
X5416   55   133  memristor PARAMS: InitStateVar=0.157797
X5516   56   133  memristor PARAMS: InitStateVar=0.211842
X5616   57   133  memristor PARAMS: InitStateVar=0.230078
X5716   58   133  memristor PARAMS: InitStateVar=0.488855
X5816   59   133  memristor PARAMS: InitStateVar=0.406401
X5916   60   133  memristor PARAMS: InitStateVar=0.316418
X6016   61   133  memristor PARAMS: InitStateVar=0.311239
X6116   62   133  memristor PARAMS: InitStateVar=0.257882
X6216   63   133  memristor PARAMS: InitStateVar=0.360727
X6316   64   133  memristor PARAMS: InitStateVar=0.181229
X6416   65   133  memristor PARAMS: InitStateVar=0.246481
X6516   66   133  memristor PARAMS: InitStateVar=0.409685
X6616   67   133  memristor PARAMS: InitStateVar=0.469004
X6716   68   133  memristor PARAMS: InitStateVar=0.0733268
X6816   69   133  memristor PARAMS: InitStateVar=0.283512
X6916   70   133  memristor PARAMS: InitStateVar=0.284218
X7016   71   133  memristor PARAMS: InitStateVar=0.300676
X7116   72   133  memristor PARAMS: InitStateVar=0.228269
X7216   73   133  memristor PARAMS: InitStateVar=0.347956
X7316   74   133  memristor PARAMS: InitStateVar=0.273377
X7416   75   133  memristor PARAMS: InitStateVar=0.436142
X7516   76   133  memristor PARAMS: InitStateVar=0.18841
X7616   77   133  memristor PARAMS: InitStateVar=0.324535
X7716   78   133  memristor PARAMS: InitStateVar=0.397316
X7816   79   133  memristor PARAMS: InitStateVar=0.300537
X7916   80   133  memristor PARAMS: InitStateVar=0.334599
X8016   81   133  memristor PARAMS: InitStateVar=0.365587
X8116   82   133  memristor PARAMS: InitStateVar=0.330336
X8216   83   133  memristor PARAMS: InitStateVar=0.534794
X8316   84   133  memristor PARAMS: InitStateVar=0.303055
X8416   85   133  memristor PARAMS: InitStateVar=0.350748
X8516   86   133  memristor PARAMS: InitStateVar=0.209769
X8616   87   133  memristor PARAMS: InitStateVar=0.375296
X8716   88   133  memristor PARAMS: InitStateVar=0.341137
X8816   89   133  memristor PARAMS: InitStateVar=0.299393
X8916   90   133  memristor PARAMS: InitStateVar=0.132928
X9016   91   133  memristor PARAMS: InitStateVar=0.179129
X9116   92   133  memristor PARAMS: InitStateVar=0.532591
X9216   93   133  memristor PARAMS: InitStateVar=0.185596
X9316   94   133  memristor PARAMS: InitStateVar=0.247862
X9416   95   133  memristor PARAMS: InitStateVar=0.320332
X9516   96   133  memristor PARAMS: InitStateVar=0.371433
X9616   97   133  memristor PARAMS: InitStateVar=0.25396
X9716   98   133  memristor PARAMS: InitStateVar=0.297339
X9816   99   133  memristor PARAMS: InitStateVar=0.302317
X9916   100  133  memristor PARAMS: InitStateVar=0.133561
Xo17    133  134  OutputModule PARAMS: Rval=100
*------------------- Column 18 -------------------------------------------------
X17     1    135  memristor PARAMS: InitStateVar=0.327103
X117    2    135  memristor PARAMS: InitStateVar=0.184045
X217    3    135  memristor PARAMS: InitStateVar=0.310572
X317    4    135  memristor PARAMS: InitStateVar=0.430659
X417    5    135  memristor PARAMS: InitStateVar=0.25809
X517    6    135  memristor PARAMS: InitStateVar=0.231213
X617    7    135  memristor PARAMS: InitStateVar=0.147305
X717    8    135  memristor PARAMS: InitStateVar=0.460459
X817    9    135  memristor PARAMS: InitStateVar=0.388482
X917    10   135  memristor PARAMS: InitStateVar=0.278873
X1017   11   135  memristor PARAMS: InitStateVar=0.440435
X1117   12   135  memristor PARAMS: InitStateVar=0.413542
X1217   13   135  memristor PARAMS: InitStateVar=0.392881
X1317   14   135  memristor PARAMS: InitStateVar=0.312859
X1417   15   135  memristor PARAMS: InitStateVar=0.359894
X1517   16   135  memristor PARAMS: InitStateVar=0.326728
X1617   17   135  memristor PARAMS: InitStateVar=0.286486
X1717   18   135  memristor PARAMS: InitStateVar=0.288583
X1817   19   135  memristor PARAMS: InitStateVar=0.499896
X1917   20   135  memristor PARAMS: InitStateVar=0.217877
X2017   21   135  memristor PARAMS: InitStateVar=0.152683
X2117   22   135  memristor PARAMS: InitStateVar=0.219527
X2217   23   135  memristor PARAMS: InitStateVar=0.395635
X2317   24   135  memristor PARAMS: InitStateVar=0.207403
X2417   25   135  memristor PARAMS: InitStateVar=0.338494
X2517   26   135  memristor PARAMS: InitStateVar=0.0992357
X2617   27   135  memristor PARAMS: InitStateVar=0.338363
X2717   28   135  memristor PARAMS: InitStateVar=0.316171
X2817   29   135  memristor PARAMS: InitStateVar=0.239047
X2917   30   135  memristor PARAMS: InitStateVar=0.180701
X3017   31   135  memristor PARAMS: InitStateVar=0.392304
X3117   32   135  memristor PARAMS: InitStateVar=0.245861
X3217   33   135  memristor PARAMS: InitStateVar=0.281432
X3317   34   135  memristor PARAMS: InitStateVar=0.314692
X3417   35   135  memristor PARAMS: InitStateVar=0.274862
X3517   36   135  memristor PARAMS: InitStateVar=0.465676
X3617   37   135  memristor PARAMS: InitStateVar=0.257754
X3717   38   135  memristor PARAMS: InitStateVar=0.323699
X3817   39   135  memristor PARAMS: InitStateVar=0.348287
X3917   40   135  memristor PARAMS: InitStateVar=0.510809
X4017   41   135  memristor PARAMS: InitStateVar=0.180199
X4117   42   135  memristor PARAMS: InitStateVar=0.346559
X4217   43   135  memristor PARAMS: InitStateVar=0.445086
X4317   44   135  memristor PARAMS: InitStateVar=0.279529
X4417   45   135  memristor PARAMS: InitStateVar=0.502784
X4517   46   135  memristor PARAMS: InitStateVar=0.45079
X4617   47   135  memristor PARAMS: InitStateVar=0.381285
X4717   48   135  memristor PARAMS: InitStateVar=0.297033
X4817   49   135  memristor PARAMS: InitStateVar=0.395539
X4917   50   135  memristor PARAMS: InitStateVar=0.301387
X5017   51   135  memristor PARAMS: InitStateVar=0.196667
X5117   52   135  memristor PARAMS: InitStateVar=0.306852
X5217   53   135  memristor PARAMS: InitStateVar=0.209953
X5317   54   135  memristor PARAMS: InitStateVar=0.0344154
X5417   55   135  memristor PARAMS: InitStateVar=0.198466
X5517   56   135  memristor PARAMS: InitStateVar=0.279756
X5617   57   135  memristor PARAMS: InitStateVar=0.345896
X5717   58   135  memristor PARAMS: InitStateVar=0.271147
X5817   59   135  memristor PARAMS: InitStateVar=0.223138
X5917   60   135  memristor PARAMS: InitStateVar=0.400649
X6017   61   135  memristor PARAMS: InitStateVar=0.324055
X6117   62   135  memristor PARAMS: InitStateVar=0.21947
X6217   63   135  memristor PARAMS: InitStateVar=0.410125
X6317   64   135  memristor PARAMS: InitStateVar=0.159189
X6417   65   135  memristor PARAMS: InitStateVar=0.420707
X6517   66   135  memristor PARAMS: InitStateVar=0.278548
X6617   67   135  memristor PARAMS: InitStateVar=0.170343
X6717   68   135  memristor PARAMS: InitStateVar=0.247125
X6817   69   135  memristor PARAMS: InitStateVar=0.349512
X6917   70   135  memristor PARAMS: InitStateVar=0.208308
X7017   71   135  memristor PARAMS: InitStateVar=0.138819
X7117   72   135  memristor PARAMS: InitStateVar=0.429886
X7217   73   135  memristor PARAMS: InitStateVar=0.244321
X7317   74   135  memristor PARAMS: InitStateVar=0.407495
X7417   75   135  memristor PARAMS: InitStateVar=0.251928
X7517   76   135  memristor PARAMS: InitStateVar=0.330521
X7617   77   135  memristor PARAMS: InitStateVar=0.235661
X7717   78   135  memristor PARAMS: InitStateVar=0.207946
X7817   79   135  memristor PARAMS: InitStateVar=0.243051
X7917   80   135  memristor PARAMS: InitStateVar=0.189157
X8017   81   135  memristor PARAMS: InitStateVar=0.158345
X8117   82   135  memristor PARAMS: InitStateVar=0.318535
X8217   83   135  memristor PARAMS: InitStateVar=0.3377
X8317   84   135  memristor PARAMS: InitStateVar=0.176381
X8417   85   135  memristor PARAMS: InitStateVar=0.0794462
X8517   86   135  memristor PARAMS: InitStateVar=0.3549
X8617   87   135  memristor PARAMS: InitStateVar=0.393545
X8717   88   135  memristor PARAMS: InitStateVar=0.415466
X8817   89   135  memristor PARAMS: InitStateVar=0.379755
X8917   90   135  memristor PARAMS: InitStateVar=0.135315
X9017   91   135  memristor PARAMS: InitStateVar=0.391449
X9117   92   135  memristor PARAMS: InitStateVar=0.350068
X9217   93   135  memristor PARAMS: InitStateVar=0.166325
X9317   94   135  memristor PARAMS: InitStateVar=0.224219
X9417   95   135  memristor PARAMS: InitStateVar=0.36894
X9517   96   135  memristor PARAMS: InitStateVar=0.42576
X9617   97   135  memristor PARAMS: InitStateVar=0.401417
X9717   98   135  memristor PARAMS: InitStateVar=0.486484
X9817   99   135  memristor PARAMS: InitStateVar=0.352087
X9917   100  135  memristor PARAMS: InitStateVar=0.503765
Xo18    135  136  OutputModule PARAMS: Rval=100
*------------------- Column 19 -------------------------------------------------
X18     1    137  memristor PARAMS: InitStateVar=0.270398
X118    2    137  memristor PARAMS: InitStateVar=0.343516
X218    3    137  memristor PARAMS: InitStateVar=0.175928
X318    4    137  memristor PARAMS: InitStateVar=0.116938
X418    5    137  memristor PARAMS: InitStateVar=0.512578
X518    6    137  memristor PARAMS: InitStateVar=0.27205
X618    7    137  memristor PARAMS: InitStateVar=0.212513
X718    8    137  memristor PARAMS: InitStateVar=0.0444414
X818    9    137  memristor PARAMS: InitStateVar=0.24679
X918    10   137  memristor PARAMS: InitStateVar=0.31106
X1018   11   137  memristor PARAMS: InitStateVar=0.291014
X1118   12   137  memristor PARAMS: InitStateVar=0.35522
X1218   13   137  memristor PARAMS: InitStateVar=0.320908
X1318   14   137  memristor PARAMS: InitStateVar=0.247659
X1418   15   137  memristor PARAMS: InitStateVar=0.273377
X1518   16   137  memristor PARAMS: InitStateVar=0.255633
X1618   17   137  memristor PARAMS: InitStateVar=0.254781
X1718   18   137  memristor PARAMS: InitStateVar=0.386707
X1818   19   137  memristor PARAMS: InitStateVar=0.328256
X1918   20   137  memristor PARAMS: InitStateVar=0.239782
X2018   21   137  memristor PARAMS: InitStateVar=0.303697
X2118   22   137  memristor PARAMS: InitStateVar=0.315598
X2218   23   137  memristor PARAMS: InitStateVar=0.478547
X2318   24   137  memristor PARAMS: InitStateVar=0.350681
X2418   25   137  memristor PARAMS: InitStateVar=0.306237
X2518   26   137  memristor PARAMS: InitStateVar=0.303761
X2618   27   137  memristor PARAMS: InitStateVar=0.434479
X2718   28   137  memristor PARAMS: InitStateVar=0.503457
X2818   29   137  memristor PARAMS: InitStateVar=0.340632
X2918   30   137  memristor PARAMS: InitStateVar=0.309745
X3018   31   137  memristor PARAMS: InitStateVar=0.162051
X3118   32   137  memristor PARAMS: InitStateVar=0.333965
X3218   33   137  memristor PARAMS: InitStateVar=0.222039
X3318   34   137  memristor PARAMS: InitStateVar=0.261136
X3418   35   137  memristor PARAMS: InitStateVar=0.471343
X3518   36   137  memristor PARAMS: InitStateVar=0.317889
X3618   37   137  memristor PARAMS: InitStateVar=0.254717
X3718   38   137  memristor PARAMS: InitStateVar=0.441086
X3818   39   137  memristor PARAMS: InitStateVar=0.356946
X3918   40   137  memristor PARAMS: InitStateVar=0.383073
X4018   41   137  memristor PARAMS: InitStateVar=0.182808
X4118   42   137  memristor PARAMS: InitStateVar=0.223284
X4218   43   137  memristor PARAMS: InitStateVar=0.567405
X4318   44   137  memristor PARAMS: InitStateVar=0.352349
X4418   45   137  memristor PARAMS: InitStateVar=0.103655
X4518   46   137  memristor PARAMS: InitStateVar=0.378541
X4618   47   137  memristor PARAMS: InitStateVar=0.3662
X4718   48   137  memristor PARAMS: InitStateVar=0.283234
X4818   49   137  memristor PARAMS: InitStateVar=0.437256
X4918   50   137  memristor PARAMS: InitStateVar=0.338857
X5018   51   137  memristor PARAMS: InitStateVar=0.240993
X5118   52   137  memristor PARAMS: InitStateVar=0.199034
X5218   53   137  memristor PARAMS: InitStateVar=0.462712
X5318   54   137  memristor PARAMS: InitStateVar=0.190772
X5418   55   137  memristor PARAMS: InitStateVar=0.296238
X5518   56   137  memristor PARAMS: InitStateVar=0.36129
X5618   57   137  memristor PARAMS: InitStateVar=0.39408
X5718   58   137  memristor PARAMS: InitStateVar=0.329378
X5818   59   137  memristor PARAMS: InitStateVar=0.15699
X5918   60   137  memristor PARAMS: InitStateVar=0.329179
X6018   61   137  memristor PARAMS: InitStateVar=0.235542
X6118   62   137  memristor PARAMS: InitStateVar=0.350878
X6218   63   137  memristor PARAMS: InitStateVar=0.32592
X6318   64   137  memristor PARAMS: InitStateVar=0.373493
X6418   65   137  memristor PARAMS: InitStateVar=0.18751
X6518   66   137  memristor PARAMS: InitStateVar=0.169679
X6618   67   137  memristor PARAMS: InitStateVar=0.293696
X6718   68   137  memristor PARAMS: InitStateVar=0.287627
X6818   69   137  memristor PARAMS: InitStateVar=0.289464
X6918   70   137  memristor PARAMS: InitStateVar=0.123996
X7018   71   137  memristor PARAMS: InitStateVar=0.33195
X7118   72   137  memristor PARAMS: InitStateVar=0.2046
X7218   73   137  memristor PARAMS: InitStateVar=0.38894
X7318   74   137  memristor PARAMS: InitStateVar=0.34838
X7418   75   137  memristor PARAMS: InitStateVar=0.228323
X7518   76   137  memristor PARAMS: InitStateVar=0.159813
X7618   77   137  memristor PARAMS: InitStateVar=0.19863
X7718   78   137  memristor PARAMS: InitStateVar=0.255043
X7818   79   137  memristor PARAMS: InitStateVar=0.255853
X7918   80   137  memristor PARAMS: InitStateVar=0.405427
X8018   81   137  memristor PARAMS: InitStateVar=0.180902
X8118   82   137  memristor PARAMS: InitStateVar=0.148967
X8218   83   137  memristor PARAMS: InitStateVar=0.405264
X8318   84   137  memristor PARAMS: InitStateVar=0.112033
X8418   85   137  memristor PARAMS: InitStateVar=0.473387
X8518   86   137  memristor PARAMS: InitStateVar=0.392122
X8618   87   137  memristor PARAMS: InitStateVar=0.218422
X8718   88   137  memristor PARAMS: InitStateVar=0.302718
X8818   89   137  memristor PARAMS: InitStateVar=0.294176
X8918   90   137  memristor PARAMS: InitStateVar=0.50625
X9018   91   137  memristor PARAMS: InitStateVar=0.275074
X9118   92   137  memristor PARAMS: InitStateVar=0.314776
X9218   93   137  memristor PARAMS: InitStateVar=0.353466
X9318   94   137  memristor PARAMS: InitStateVar=0.40727
X9418   95   137  memristor PARAMS: InitStateVar=0.304607
X9518   96   137  memristor PARAMS: InitStateVar=0.182362
X9618   97   137  memristor PARAMS: InitStateVar=0.183984
X9718   98   137  memristor PARAMS: InitStateVar=0.390836
X9818   99   137  memristor PARAMS: InitStateVar=0.193862
X9918   100  137  memristor PARAMS: InitStateVar=0.325832
Xo19    137  138  OutputModule PARAMS: Rval=100
*------------------- Column 20 -------------------------------------------------
X19     1    139  memristor PARAMS: InitStateVar=0.267498
X119    2    139  memristor PARAMS: InitStateVar=0.353258
X219    3    139  memristor PARAMS: InitStateVar=0.196176
X319    4    139  memristor PARAMS: InitStateVar=0.301525
X419    5    139  memristor PARAMS: InitStateVar=0.404798
X519    6    139  memristor PARAMS: InitStateVar=0.324655
X619    7    139  memristor PARAMS: InitStateVar=0.459003
X719    8    139  memristor PARAMS: InitStateVar=0.204606
X819    9    139  memristor PARAMS: InitStateVar=0.126312
X919    10   139  memristor PARAMS: InitStateVar=0.291661
X1019   11   139  memristor PARAMS: InitStateVar=0.309419
X1119   12   139  memristor PARAMS: InitStateVar=0.32506
X1219   13   139  memristor PARAMS: InitStateVar=0.349559
X1319   14   139  memristor PARAMS: InitStateVar=0.366867
X1419   15   139  memristor PARAMS: InitStateVar=0.233139
X1519   16   139  memristor PARAMS: InitStateVar=0.245499
X1619   17   139  memristor PARAMS: InitStateVar=0.278763
X1719   18   139  memristor PARAMS: InitStateVar=0.372582
X1819   19   139  memristor PARAMS: InitStateVar=0.205431
X1919   20   139  memristor PARAMS: InitStateVar=0.124671
X2019   21   139  memristor PARAMS: InitStateVar=0.506001
X2119   22   139  memristor PARAMS: InitStateVar=0.291445
X2219   23   139  memristor PARAMS: InitStateVar=0.209455
X2319   24   139  memristor PARAMS: InitStateVar=0.230302
X2419   25   139  memristor PARAMS: InitStateVar=0.396219
X2519   26   139  memristor PARAMS: InitStateVar=0.309011
X2619   27   139  memristor PARAMS: InitStateVar=0.310042
X2719   28   139  memristor PARAMS: InitStateVar=0.236455
X2819   29   139  memristor PARAMS: InitStateVar=0.356755
X2919   30   139  memristor PARAMS: InitStateVar=0.388497
X3019   31   139  memristor PARAMS: InitStateVar=0.337081
X3119   32   139  memristor PARAMS: InitStateVar=0.208051
X3219   33   139  memristor PARAMS: InitStateVar=0.229734
X3319   34   139  memristor PARAMS: InitStateVar=0.333426
X3419   35   139  memristor PARAMS: InitStateVar=0.309734
X3519   36   139  memristor PARAMS: InitStateVar=0.150173
X3619   37   139  memristor PARAMS: InitStateVar=0.42562
X3719   38   139  memristor PARAMS: InitStateVar=0.327118
X3819   39   139  memristor PARAMS: InitStateVar=0.392605
X3919   40   139  memristor PARAMS: InitStateVar=0.166998
X4019   41   139  memristor PARAMS: InitStateVar=0.295633
X4119   42   139  memristor PARAMS: InitStateVar=0.220764
X4219   43   139  memristor PARAMS: InitStateVar=0.424727
X4319   44   139  memristor PARAMS: InitStateVar=0.230295
X4419   45   139  memristor PARAMS: InitStateVar=0.375214
X4519   46   139  memristor PARAMS: InitStateVar=0.134857
X4619   47   139  memristor PARAMS: InitStateVar=0.310054
X4719   48   139  memristor PARAMS: InitStateVar=0.449337
X4819   49   139  memristor PARAMS: InitStateVar=0.204664
X4919   50   139  memristor PARAMS: InitStateVar=0.330179
X5019   51   139  memristor PARAMS: InitStateVar=0.337109
X5119   52   139  memristor PARAMS: InitStateVar=0.292704
X5219   53   139  memristor PARAMS: InitStateVar=0.45932
X5319   54   139  memristor PARAMS: InitStateVar=0.283944
X5419   55   139  memristor PARAMS: InitStateVar=0.399571
X5519   56   139  memristor PARAMS: InitStateVar=0.381195
X5619   57   139  memristor PARAMS: InitStateVar=0.256654
X5719   58   139  memristor PARAMS: InitStateVar=0.257285
X5819   59   139  memristor PARAMS: InitStateVar=0.337712
X5919   60   139  memristor PARAMS: InitStateVar=0.315703
X6019   61   139  memristor PARAMS: InitStateVar=0.400825
X6119   62   139  memristor PARAMS: InitStateVar=0.471428
X6219   63   139  memristor PARAMS: InitStateVar=0.326244
X6319   64   139  memristor PARAMS: InitStateVar=0.303878
X6419   65   139  memristor PARAMS: InitStateVar=0.158456
X6519   66   139  memristor PARAMS: InitStateVar=0.166351
X6619   67   139  memristor PARAMS: InitStateVar=0.245721
X6719   68   139  memristor PARAMS: InitStateVar=0.287427
X6819   69   139  memristor PARAMS: InitStateVar=0.106635
X6919   70   139  memristor PARAMS: InitStateVar=0.203805
X7019   71   139  memristor PARAMS: InitStateVar=0.356807
X7119   72   139  memristor PARAMS: InitStateVar=0.426053
X7219   73   139  memristor PARAMS: InitStateVar=0.312007
X7319   74   139  memristor PARAMS: InitStateVar=0.237677
X7419   75   139  memristor PARAMS: InitStateVar=0.283095
X7519   76   139  memristor PARAMS: InitStateVar=0.414922
X7619   77   139  memristor PARAMS: InitStateVar=0.418166
X7719   78   139  memristor PARAMS: InitStateVar=0.428336
X7819   79   139  memristor PARAMS: InitStateVar=0.326314
X7919   80   139  memristor PARAMS: InitStateVar=0.123433
X8019   81   139  memristor PARAMS: InitStateVar=0.362269
X8119   82   139  memristor PARAMS: InitStateVar=0.375982
X8219   83   139  memristor PARAMS: InitStateVar=0.276727
X8319   84   139  memristor PARAMS: InitStateVar=0.227242
X8419   85   139  memristor PARAMS: InitStateVar=0.503845
X8519   86   139  memristor PARAMS: InitStateVar=0.389954
X8619   87   139  memristor PARAMS: InitStateVar=0.310045
X8719   88   139  memristor PARAMS: InitStateVar=0.237463
X8819   89   139  memristor PARAMS: InitStateVar=0.288245
X8919   90   139  memristor PARAMS: InitStateVar=0.228635
X9019   91   139  memristor PARAMS: InitStateVar=0.333452
X9119   92   139  memristor PARAMS: InitStateVar=0.418781
X9219   93   139  memristor PARAMS: InitStateVar=0.212327
X9319   94   139  memristor PARAMS: InitStateVar=0.175982
X9419   95   139  memristor PARAMS: InitStateVar=0.155031
X9519   96   139  memristor PARAMS: InitStateVar=0.410394
X9619   97   139  memristor PARAMS: InitStateVar=0.164372
X9719   98   139  memristor PARAMS: InitStateVar=0.248681
X9819   99   139  memristor PARAMS: InitStateVar=0.196882
X9919   100  139  memristor PARAMS: InitStateVar=0.563757
Xo20    139  140  OutputModule PARAMS: Rval=100
*------------------- Column 21 -------------------------------------------------
X20     1    141  memristor PARAMS: InitStateVar=0.312576
X120    2    141  memristor PARAMS: InitStateVar=0.402821
X220    3    141  memristor PARAMS: InitStateVar=0.137299
X320    4    141  memristor PARAMS: InitStateVar=0.507682
X420    5    141  memristor PARAMS: InitStateVar=0.296444
X520    6    141  memristor PARAMS: InitStateVar=0.266852
X620    7    141  memristor PARAMS: InitStateVar=0.188831
X720    8    141  memristor PARAMS: InitStateVar=0.365297
X820    9    141  memristor PARAMS: InitStateVar=0.0828066
X920    10   141  memristor PARAMS: InitStateVar=0.227119
X1020   11   141  memristor PARAMS: InitStateVar=0.376023
X1120   12   141  memristor PARAMS: InitStateVar=0.269725
X1220   13   141  memristor PARAMS: InitStateVar=0.463039
X1320   14   141  memristor PARAMS: InitStateVar=0.316124
X1420   15   141  memristor PARAMS: InitStateVar=0.234213
X1520   16   141  memristor PARAMS: InitStateVar=0.262498
X1620   17   141  memristor PARAMS: InitStateVar=0.454056
X1720   18   141  memristor PARAMS: InitStateVar=0.253315
X1820   19   141  memristor PARAMS: InitStateVar=0.34399
X1920   20   141  memristor PARAMS: InitStateVar=0.385091
X2020   21   141  memristor PARAMS: InitStateVar=0.39117
X2120   22   141  memristor PARAMS: InitStateVar=0.308808
X2220   23   141  memristor PARAMS: InitStateVar=0.287146
X2320   24   141  memristor PARAMS: InitStateVar=0.219848
X2420   25   141  memristor PARAMS: InitStateVar=0.328317
X2520   26   141  memristor PARAMS: InitStateVar=0.285262
X2620   27   141  memristor PARAMS: InitStateVar=0.233053
X2720   28   141  memristor PARAMS: InitStateVar=0.484949
X2820   29   141  memristor PARAMS: InitStateVar=0.1078
X2920   30   141  memristor PARAMS: InitStateVar=0.322971
X3020   31   141  memristor PARAMS: InitStateVar=0.360562
X3120   32   141  memristor PARAMS: InitStateVar=0.432045
X3220   33   141  memristor PARAMS: InitStateVar=0.131927
X3320   34   141  memristor PARAMS: InitStateVar=0.463962
X3420   35   141  memristor PARAMS: InitStateVar=0.304635
X3520   36   141  memristor PARAMS: InitStateVar=0.37396
X3620   37   141  memristor PARAMS: InitStateVar=0.210178
X3720   38   141  memristor PARAMS: InitStateVar=0.201203
X3820   39   141  memristor PARAMS: InitStateVar=0.306138
X3920   40   141  memristor PARAMS: InitStateVar=0.173007
X4020   41   141  memristor PARAMS: InitStateVar=0.250138
X4120   42   141  memristor PARAMS: InitStateVar=0.329292
X4220   43   141  memristor PARAMS: InitStateVar=0.325229
X4320   44   141  memristor PARAMS: InitStateVar=0.302642
X4420   45   141  memristor PARAMS: InitStateVar=0.377017
X4520   46   141  memristor PARAMS: InitStateVar=0.372422
X4620   47   141  memristor PARAMS: InitStateVar=0.313409
X4720   48   141  memristor PARAMS: InitStateVar=0.489262
X4820   49   141  memristor PARAMS: InitStateVar=0.145729
X4920   50   141  memristor PARAMS: InitStateVar=0.280528
X5020   51   141  memristor PARAMS: InitStateVar=0.271241
X5120   52   141  memristor PARAMS: InitStateVar=0.334996
X5220   53   141  memristor PARAMS: InitStateVar=0.219359
X5320   54   141  memristor PARAMS: InitStateVar=0.211123
X5420   55   141  memristor PARAMS: InitStateVar=0.325123
X5520   56   141  memristor PARAMS: InitStateVar=0.329762
X5620   57   141  memristor PARAMS: InitStateVar=0.350863
X5720   58   141  memristor PARAMS: InitStateVar=0.325168
X5820   59   141  memristor PARAMS: InitStateVar=0.239742
X5920   60   141  memristor PARAMS: InitStateVar=0.321283
X6020   61   141  memristor PARAMS: InitStateVar=0.313933
X6120   62   141  memristor PARAMS: InitStateVar=0.431259
X6220   63   141  memristor PARAMS: InitStateVar=0.372786
X6320   64   141  memristor PARAMS: InitStateVar=0.364947
X6420   65   141  memristor PARAMS: InitStateVar=0.302496
X6520   66   141  memristor PARAMS: InitStateVar=0.377472
X6620   67   141  memristor PARAMS: InitStateVar=0.173914
X6720   68   141  memristor PARAMS: InitStateVar=0.246358
X6820   69   141  memristor PARAMS: InitStateVar=0.196663
X6920   70   141  memristor PARAMS: InitStateVar=0.457537
X7020   71   141  memristor PARAMS: InitStateVar=0.202192
X7120   72   141  memristor PARAMS: InitStateVar=0.191952
X7220   73   141  memristor PARAMS: InitStateVar=0.15706
X7320   74   141  memristor PARAMS: InitStateVar=0.414497
X7420   75   141  memristor PARAMS: InitStateVar=0.334007
X7520   76   141  memristor PARAMS: InitStateVar=0.205925
X7620   77   141  memristor PARAMS: InitStateVar=0.194314
X7720   78   141  memristor PARAMS: InitStateVar=0.272286
X7820   79   141  memristor PARAMS: InitStateVar=0.304843
X7920   80   141  memristor PARAMS: InitStateVar=0.279848
X8020   81   141  memristor PARAMS: InitStateVar=0.337424
X8120   82   141  memristor PARAMS: InitStateVar=0.315697
X8220   83   141  memristor PARAMS: InitStateVar=0.16511
X8320   84   141  memristor PARAMS: InitStateVar=0.370184
X8420   85   141  memristor PARAMS: InitStateVar=0.308661
X8520   86   141  memristor PARAMS: InitStateVar=0.366223
X8620   87   141  memristor PARAMS: InitStateVar=0.368317
X8720   88   141  memristor PARAMS: InitStateVar=0.218459
X8820   89   141  memristor PARAMS: InitStateVar=0.234839
X8920   90   141  memristor PARAMS: InitStateVar=0.344217
X9020   91   141  memristor PARAMS: InitStateVar=0.134402
X9120   92   141  memristor PARAMS: InitStateVar=0.237764
X9220   93   141  memristor PARAMS: InitStateVar=0.287908
X9320   94   141  memristor PARAMS: InitStateVar=0.296249
X9420   95   141  memristor PARAMS: InitStateVar=0.428994
X9520   96   141  memristor PARAMS: InitStateVar=0.484669
X9620   97   141  memristor PARAMS: InitStateVar=0.278448
X9720   98   141  memristor PARAMS: InitStateVar=0.43806
X9820   99   141  memristor PARAMS: InitStateVar=0.285325
X9920   100  141  memristor PARAMS: InitStateVar=0.427743
Xo21    141  142  OutputModule PARAMS: Rval=100
*------------------- Column 22 -------------------------------------------------
X21     1    143  memristor PARAMS: InitStateVar=0.576007
X121    2    143  memristor PARAMS: InitStateVar=0.396269
X221    3    143  memristor PARAMS: InitStateVar=0.345375
X321    4    143  memristor PARAMS: InitStateVar=0.162075
X421    5    143  memristor PARAMS: InitStateVar=0.366682
X521    6    143  memristor PARAMS: InitStateVar=0.19734
X621    7    143  memristor PARAMS: InitStateVar=0.341536
X721    8    143  memristor PARAMS: InitStateVar=0.303748
X821    9    143  memristor PARAMS: InitStateVar=0.269022
X921    10   143  memristor PARAMS: InitStateVar=0.363061
X1021   11   143  memristor PARAMS: InitStateVar=0.157966
X1121   12   143  memristor PARAMS: InitStateVar=0.147638
X1221   13   143  memristor PARAMS: InitStateVar=0.0383459
X1321   14   143  memristor PARAMS: InitStateVar=0.235485
X1421   15   143  memristor PARAMS: InitStateVar=0.35964
X1521   16   143  memristor PARAMS: InitStateVar=0.363534
X1621   17   143  memristor PARAMS: InitStateVar=0.377978
X1721   18   143  memristor PARAMS: InitStateVar=0.246312
X1821   19   143  memristor PARAMS: InitStateVar=0.233703
X1921   20   143  memristor PARAMS: InitStateVar=0.296265
X2021   21   143  memristor PARAMS: InitStateVar=0.125508
X2121   22   143  memristor PARAMS: InitStateVar=0.188615
X2221   23   143  memristor PARAMS: InitStateVar=0.303261
X2321   24   143  memristor PARAMS: InitStateVar=0.474904
X2421   25   143  memristor PARAMS: InitStateVar=0.397879
X2521   26   143  memristor PARAMS: InitStateVar=0.402589
X2621   27   143  memristor PARAMS: InitStateVar=0.186855
X2721   28   143  memristor PARAMS: InitStateVar=0.434262
X2821   29   143  memristor PARAMS: InitStateVar=0.205481
X2921   30   143  memristor PARAMS: InitStateVar=0.132902
X3021   31   143  memristor PARAMS: InitStateVar=0.296623
X3121   32   143  memristor PARAMS: InitStateVar=0.261985
X3221   33   143  memristor PARAMS: InitStateVar=0.15962
X3321   34   143  memristor PARAMS: InitStateVar=0.309956
X3421   35   143  memristor PARAMS: InitStateVar=0.14353
X3521   36   143  memristor PARAMS: InitStateVar=0.14802
X3621   37   143  memristor PARAMS: InitStateVar=0.45084
X3721   38   143  memristor PARAMS: InitStateVar=0.361165
X3821   39   143  memristor PARAMS: InitStateVar=0.234277
X3921   40   143  memristor PARAMS: InitStateVar=0.202357
X4021   41   143  memristor PARAMS: InitStateVar=0.27019
X4121   42   143  memristor PARAMS: InitStateVar=0.446405
X4221   43   143  memristor PARAMS: InitStateVar=0.424244
X4321   44   143  memristor PARAMS: InitStateVar=0.368652
X4421   45   143  memristor PARAMS: InitStateVar=0.330259
X4521   46   143  memristor PARAMS: InitStateVar=0.332222
X4621   47   143  memristor PARAMS: InitStateVar=0.258575
X4721   48   143  memristor PARAMS: InitStateVar=0.307906
X4821   49   143  memristor PARAMS: InitStateVar=0.346174
X4921   50   143  memristor PARAMS: InitStateVar=0.188699
X5021   51   143  memristor PARAMS: InitStateVar=0.279302
X5121   52   143  memristor PARAMS: InitStateVar=0.417318
X5221   53   143  memristor PARAMS: InitStateVar=0.468656
X5321   54   143  memristor PARAMS: InitStateVar=0.25027
X5421   55   143  memristor PARAMS: InitStateVar=0.362807
X5521   56   143  memristor PARAMS: InitStateVar=0.270792
X5621   57   143  memristor PARAMS: InitStateVar=0.366994
X5721   58   143  memristor PARAMS: InitStateVar=0.382791
X5821   59   143  memristor PARAMS: InitStateVar=0.47503
X5921   60   143  memristor PARAMS: InitStateVar=0.361229
X6021   61   143  memristor PARAMS: InitStateVar=0.375718
X6121   62   143  memristor PARAMS: InitStateVar=0.144731
X6221   63   143  memristor PARAMS: InitStateVar=0.353526
X6321   64   143  memristor PARAMS: InitStateVar=0.566562
X6421   65   143  memristor PARAMS: InitStateVar=0.448439
X6521   66   143  memristor PARAMS: InitStateVar=0.407048
X6621   67   143  memristor PARAMS: InitStateVar=0.255808
X6721   68   143  memristor PARAMS: InitStateVar=0.277163
X6821   69   143  memristor PARAMS: InitStateVar=0.372068
X6921   70   143  memristor PARAMS: InitStateVar=0.312238
X7021   71   143  memristor PARAMS: InitStateVar=0.278007
X7121   72   143  memristor PARAMS: InitStateVar=0.449787
X7221   73   143  memristor PARAMS: InitStateVar=0.35966
X7321   74   143  memristor PARAMS: InitStateVar=0.28351
X7421   75   143  memristor PARAMS: InitStateVar=0.416552
X7521   76   143  memristor PARAMS: InitStateVar=0.356264
X7621   77   143  memristor PARAMS: InitStateVar=0.351339
X7721   78   143  memristor PARAMS: InitStateVar=0.245912
X7821   79   143  memristor PARAMS: InitStateVar=0.155738
X7921   80   143  memristor PARAMS: InitStateVar=0.380365
X8021   81   143  memristor PARAMS: InitStateVar=0.536786
X8121   82   143  memristor PARAMS: InitStateVar=0.349908
X8221   83   143  memristor PARAMS: InitStateVar=0.255701
X8321   84   143  memristor PARAMS: InitStateVar=0.099368
X8421   85   143  memristor PARAMS: InitStateVar=0.319008
X8521   86   143  memristor PARAMS: InitStateVar=0.132545
X8621   87   143  memristor PARAMS: InitStateVar=0.34047
X8721   88   143  memristor PARAMS: InitStateVar=0.353676
X8821   89   143  memristor PARAMS: InitStateVar=0.185429
X8921   90   143  memristor PARAMS: InitStateVar=0.247766
X9021   91   143  memristor PARAMS: InitStateVar=0.348972
X9121   92   143  memristor PARAMS: InitStateVar=0.306457
X9221   93   143  memristor PARAMS: InitStateVar=0.258239
X9321   94   143  memristor PARAMS: InitStateVar=0.482228
X9421   95   143  memristor PARAMS: InitStateVar=0.371408
X9521   96   143  memristor PARAMS: InitStateVar=0.330583
X9621   97   143  memristor PARAMS: InitStateVar=0.34709
X9721   98   143  memristor PARAMS: InitStateVar=0.408126
X9821   99   143  memristor PARAMS: InitStateVar=0.431278
X9921   100  143  memristor PARAMS: InitStateVar=0.315641
Xo22    143  144  OutputModule PARAMS: Rval=100
*------------------- Column 23 -------------------------------------------------
X22     1    145  memristor PARAMS: InitStateVar=0.17198
X122    2    145  memristor PARAMS: InitStateVar=0.324
X222    3    145  memristor PARAMS: InitStateVar=0.0723951
X322    4    145  memristor PARAMS: InitStateVar=0.180685
X422    5    145  memristor PARAMS: InitStateVar=0.18783
X522    6    145  memristor PARAMS: InitStateVar=0.418955
X622    7    145  memristor PARAMS: InitStateVar=0.48926
X722    8    145  memristor PARAMS: InitStateVar=0.272954
X822    9    145  memristor PARAMS: InitStateVar=0.235924
X922    10   145  memristor PARAMS: InitStateVar=0.634711
X1022   11   145  memristor PARAMS: InitStateVar=0.287764
X1122   12   145  memristor PARAMS: InitStateVar=0.278142
X1222   13   145  memristor PARAMS: InitStateVar=0.249862
X1322   14   145  memristor PARAMS: InitStateVar=0.0720402
X1422   15   145  memristor PARAMS: InitStateVar=0.360449
X1522   16   145  memristor PARAMS: InitStateVar=0.337985
X1622   17   145  memristor PARAMS: InitStateVar=0.285266
X1722   18   145  memristor PARAMS: InitStateVar=0.193973
X1822   19   145  memristor PARAMS: InitStateVar=0.330757
X1922   20   145  memristor PARAMS: InitStateVar=0.348632
X2022   21   145  memristor PARAMS: InitStateVar=0.290443
X2122   22   145  memristor PARAMS: InitStateVar=0.271076
X2222   23   145  memristor PARAMS: InitStateVar=0.203888
X2322   24   145  memristor PARAMS: InitStateVar=0.285825
X2422   25   145  memristor PARAMS: InitStateVar=0.311954
X2522   26   145  memristor PARAMS: InitStateVar=0.487158
X2622   27   145  memristor PARAMS: InitStateVar=0.255551
X2722   28   145  memristor PARAMS: InitStateVar=0.407098
X2822   29   145  memristor PARAMS: InitStateVar=0.331707
X2922   30   145  memristor PARAMS: InitStateVar=0.313908
X3022   31   145  memristor PARAMS: InitStateVar=0.256951
X3122   32   145  memristor PARAMS: InitStateVar=0.272236
X3222   33   145  memristor PARAMS: InitStateVar=0.318147
X3322   34   145  memristor PARAMS: InitStateVar=0.257185
X3422   35   145  memristor PARAMS: InitStateVar=0.434744
X3522   36   145  memristor PARAMS: InitStateVar=0.273433
X3622   37   145  memristor PARAMS: InitStateVar=0.263128
X3722   38   145  memristor PARAMS: InitStateVar=0.464854
X3822   39   145  memristor PARAMS: InitStateVar=0.20276
X3922   40   145  memristor PARAMS: InitStateVar=0.45723
X4022   41   145  memristor PARAMS: InitStateVar=0.445656
X4122   42   145  memristor PARAMS: InitStateVar=0.224897
X4222   43   145  memristor PARAMS: InitStateVar=0.359809
X4322   44   145  memristor PARAMS: InitStateVar=0.174442
X4422   45   145  memristor PARAMS: InitStateVar=0.288246
X4522   46   145  memristor PARAMS: InitStateVar=0.30123
X4622   47   145  memristor PARAMS: InitStateVar=0.247639
X4722   48   145  memristor PARAMS: InitStateVar=0.374112
X4822   49   145  memristor PARAMS: InitStateVar=0.190047
X4922   50   145  memristor PARAMS: InitStateVar=0.163941
X5022   51   145  memristor PARAMS: InitStateVar=0.286039
X5122   52   145  memristor PARAMS: InitStateVar=0.332663
X5222   53   145  memristor PARAMS: InitStateVar=0.264657
X5322   54   145  memristor PARAMS: InitStateVar=0.379157
X5422   55   145  memristor PARAMS: InitStateVar=0.264337
X5522   56   145  memristor PARAMS: InitStateVar=0.266038
X5622   57   145  memristor PARAMS: InitStateVar=0.178987
X5722   58   145  memristor PARAMS: InitStateVar=0.329995
X5822   59   145  memristor PARAMS: InitStateVar=0.288943
X5922   60   145  memristor PARAMS: InitStateVar=0.35658
X6022   61   145  memristor PARAMS: InitStateVar=0.474209
X6122   62   145  memristor PARAMS: InitStateVar=0.265422
X6222   63   145  memristor PARAMS: InitStateVar=0.31513
X6322   64   145  memristor PARAMS: InitStateVar=0.357861
X6422   65   145  memristor PARAMS: InitStateVar=0.343543
X6522   66   145  memristor PARAMS: InitStateVar=0.382786
X6622   67   145  memristor PARAMS: InitStateVar=0.401562
X6722   68   145  memristor PARAMS: InitStateVar=0.35106
X6822   69   145  memristor PARAMS: InitStateVar=0.486904
X6922   70   145  memristor PARAMS: InitStateVar=0.341314
X7022   71   145  memristor PARAMS: InitStateVar=0.238844
X7122   72   145  memristor PARAMS: InitStateVar=0.320782
X7222   73   145  memristor PARAMS: InitStateVar=0.114857
X7322   74   145  memristor PARAMS: InitStateVar=0.289162
X7422   75   145  memristor PARAMS: InitStateVar=0.515182
X7522   76   145  memristor PARAMS: InitStateVar=0.314852
X7622   77   145  memristor PARAMS: InitStateVar=0.229296
X7722   78   145  memristor PARAMS: InitStateVar=0.340334
X7822   79   145  memristor PARAMS: InitStateVar=0.325421
X7922   80   145  memristor PARAMS: InitStateVar=0.211078
X8022   81   145  memristor PARAMS: InitStateVar=0.194167
X8122   82   145  memristor PARAMS: InitStateVar=0.356563
X8222   83   145  memristor PARAMS: InitStateVar=0.3501
X8322   84   145  memristor PARAMS: InitStateVar=0.323203
X8422   85   145  memristor PARAMS: InitStateVar=0.314543
X8522   86   145  memristor PARAMS: InitStateVar=0.238231
X8622   87   145  memristor PARAMS: InitStateVar=0.495089
X8722   88   145  memristor PARAMS: InitStateVar=0.396278
X8822   89   145  memristor PARAMS: InitStateVar=0.263126
X8922   90   145  memristor PARAMS: InitStateVar=0.352123
X9022   91   145  memristor PARAMS: InitStateVar=0.37588
X9122   92   145  memristor PARAMS: InitStateVar=0.450521
X9222   93   145  memristor PARAMS: InitStateVar=0.191901
X9322   94   145  memristor PARAMS: InitStateVar=0.215228
X9422   95   145  memristor PARAMS: InitStateVar=0.193368
X9522   96   145  memristor PARAMS: InitStateVar=0.294888
X9622   97   145  memristor PARAMS: InitStateVar=0.123958
X9722   98   145  memristor PARAMS: InitStateVar=0.404359
X9822   99   145  memristor PARAMS: InitStateVar=0.317131
X9922   100  145  memristor PARAMS: InitStateVar=0.456815
Xo23    145  146  OutputModule PARAMS: Rval=100
*------------------- Column 24 -------------------------------------------------
X23     1    147  memristor PARAMS: InitStateVar=0.138141
X123    2    147  memristor PARAMS: InitStateVar=0.379354
X223    3    147  memristor PARAMS: InitStateVar=0.582453
X323    4    147  memristor PARAMS: InitStateVar=0.323364
X423    5    147  memristor PARAMS: InitStateVar=0.311939
X523    6    147  memristor PARAMS: InitStateVar=0.30626
X623    7    147  memristor PARAMS: InitStateVar=0.45786
X723    8    147  memristor PARAMS: InitStateVar=0.227401
X823    9    147  memristor PARAMS: InitStateVar=0.332574
X923    10   147  memristor PARAMS: InitStateVar=0.258169
X1023   11   147  memristor PARAMS: InitStateVar=0.235486
X1123   12   147  memristor PARAMS: InitStateVar=0.320498
X1223   13   147  memristor PARAMS: InitStateVar=0.359252
X1323   14   147  memristor PARAMS: InitStateVar=0.384856
X1423   15   147  memristor PARAMS: InitStateVar=0.222263
X1523   16   147  memristor PARAMS: InitStateVar=0.0670103
X1623   17   147  memristor PARAMS: InitStateVar=0.454334
X1723   18   147  memristor PARAMS: InitStateVar=0.410362
X1823   19   147  memristor PARAMS: InitStateVar=0.419855
X1923   20   147  memristor PARAMS: InitStateVar=0.387698
X2023   21   147  memristor PARAMS: InitStateVar=0.361035
X2123   22   147  memristor PARAMS: InitStateVar=0.27915
X2223   23   147  memristor PARAMS: InitStateVar=0.433488
X2323   24   147  memristor PARAMS: InitStateVar=0.267988
X2423   25   147  memristor PARAMS: InitStateVar=0.240745
X2523   26   147  memristor PARAMS: InitStateVar=0.355369
X2623   27   147  memristor PARAMS: InitStateVar=0.39721
X2723   28   147  memristor PARAMS: InitStateVar=0.390004
X2823   29   147  memristor PARAMS: InitStateVar=0.254269
X2923   30   147  memristor PARAMS: InitStateVar=0.298633
X3023   31   147  memristor PARAMS: InitStateVar=0.33222
X3123   32   147  memristor PARAMS: InitStateVar=0.403411
X3223   33   147  memristor PARAMS: InitStateVar=0.361905
X3323   34   147  memristor PARAMS: InitStateVar=0.330524
X3423   35   147  memristor PARAMS: InitStateVar=0.259652
X3523   36   147  memristor PARAMS: InitStateVar=0.330629
X3623   37   147  memristor PARAMS: InitStateVar=0.299759
X3723   38   147  memristor PARAMS: InitStateVar=0.148582
X3823   39   147  memristor PARAMS: InitStateVar=0.193974
X3923   40   147  memristor PARAMS: InitStateVar=0.365331
X4023   41   147  memristor PARAMS: InitStateVar=0.388036
X4123   42   147  memristor PARAMS: InitStateVar=0.365426
X4223   43   147  memristor PARAMS: InitStateVar=0.152418
X4323   44   147  memristor PARAMS: InitStateVar=0.315888
X4423   45   147  memristor PARAMS: InitStateVar=0.160794
X4523   46   147  memristor PARAMS: InitStateVar=0.265662
X4623   47   147  memristor PARAMS: InitStateVar=0.329325
X4723   48   147  memristor PARAMS: InitStateVar=0.325387
X4823   49   147  memristor PARAMS: InitStateVar=0.355571
X4923   50   147  memristor PARAMS: InitStateVar=0.224428
X5023   51   147  memristor PARAMS: InitStateVar=0.472209
X5123   52   147  memristor PARAMS: InitStateVar=0.273589
X5223   53   147  memristor PARAMS: InitStateVar=0.351421
X5323   54   147  memristor PARAMS: InitStateVar=0.325738
X5423   55   147  memristor PARAMS: InitStateVar=0.178534
X5523   56   147  memristor PARAMS: InitStateVar=0.194848
X5623   57   147  memristor PARAMS: InitStateVar=0.487781
X5723   58   147  memristor PARAMS: InitStateVar=0.320749
X5823   59   147  memristor PARAMS: InitStateVar=0.363901
X5923   60   147  memristor PARAMS: InitStateVar=0.258873
X6023   61   147  memristor PARAMS: InitStateVar=0.190101
X6123   62   147  memristor PARAMS: InitStateVar=0.145313
X6223   63   147  memristor PARAMS: InitStateVar=0.306013
X6323   64   147  memristor PARAMS: InitStateVar=0.303766
X6423   65   147  memristor PARAMS: InitStateVar=0.309905
X6523   66   147  memristor PARAMS: InitStateVar=0.373776
X6623   67   147  memristor PARAMS: InitStateVar=0.411564
X6723   68   147  memristor PARAMS: InitStateVar=0.306105
X6823   69   147  memristor PARAMS: InitStateVar=0.26404
X6923   70   147  memristor PARAMS: InitStateVar=0.270812
X7023   71   147  memristor PARAMS: InitStateVar=0.0920178
X7123   72   147  memristor PARAMS: InitStateVar=0.317463
X7223   73   147  memristor PARAMS: InitStateVar=0.411028
X7323   74   147  memristor PARAMS: InitStateVar=0.508954
X7423   75   147  memristor PARAMS: InitStateVar=0.236168
X7523   76   147  memristor PARAMS: InitStateVar=0.229509
X7623   77   147  memristor PARAMS: InitStateVar=0.206975
X7723   78   147  memristor PARAMS: InitStateVar=0.371302
X7823   79   147  memristor PARAMS: InitStateVar=0.207614
X7923   80   147  memristor PARAMS: InitStateVar=0.226843
X8023   81   147  memristor PARAMS: InitStateVar=0.38119
X8123   82   147  memristor PARAMS: InitStateVar=0.354822
X8223   83   147  memristor PARAMS: InitStateVar=0.173329
X8323   84   147  memristor PARAMS: InitStateVar=0.498783
X8423   85   147  memristor PARAMS: InitStateVar=0.415964
X8523   86   147  memristor PARAMS: InitStateVar=0.434311
X8623   87   147  memristor PARAMS: InitStateVar=0.254531
X8723   88   147  memristor PARAMS: InitStateVar=0.119112
X8823   89   147  memristor PARAMS: InitStateVar=0.236687
X8923   90   147  memristor PARAMS: InitStateVar=0.368921
X9023   91   147  memristor PARAMS: InitStateVar=0.229936
X9123   92   147  memristor PARAMS: InitStateVar=0.248189
X9223   93   147  memristor PARAMS: InitStateVar=0.228545
X9323   94   147  memristor PARAMS: InitStateVar=0.448017
X9423   95   147  memristor PARAMS: InitStateVar=0.420231
X9523   96   147  memristor PARAMS: InitStateVar=0.297341
X9623   97   147  memristor PARAMS: InitStateVar=0.33268
X9723   98   147  memristor PARAMS: InitStateVar=0.278349
X9823   99   147  memristor PARAMS: InitStateVar=0.211852
X9923   100  147  memristor PARAMS: InitStateVar=0.160165
Xo24    147  148  OutputModule PARAMS: Rval=100
*------------------- Column 25 -------------------------------------------------
X24     1    149  memristor PARAMS: InitStateVar=0.294527
X124    2    149  memristor PARAMS: InitStateVar=0.309106
X224    3    149  memristor PARAMS: InitStateVar=0.465172
X324    4    149  memristor PARAMS: InitStateVar=0.20414
X424    5    149  memristor PARAMS: InitStateVar=0.364061
X524    6    149  memristor PARAMS: InitStateVar=0.216922
X624    7    149  memristor PARAMS: InitStateVar=0.24028
X724    8    149  memristor PARAMS: InitStateVar=0.396976
X824    9    149  memristor PARAMS: InitStateVar=0.219701
X924    10   149  memristor PARAMS: InitStateVar=0.518652
X1024   11   149  memristor PARAMS: InitStateVar=0.252263
X1124   12   149  memristor PARAMS: InitStateVar=0.31099
X1224   13   149  memristor PARAMS: InitStateVar=0.227374
X1324   14   149  memristor PARAMS: InitStateVar=0.206472
X1424   15   149  memristor PARAMS: InitStateVar=0.398164
X1524   16   149  memristor PARAMS: InitStateVar=0.316593
X1624   17   149  memristor PARAMS: InitStateVar=0.427479
X1724   18   149  memristor PARAMS: InitStateVar=0.118801
X1824   19   149  memristor PARAMS: InitStateVar=0.168835
X1924   20   149  memristor PARAMS: InitStateVar=0.243743
X2024   21   149  memristor PARAMS: InitStateVar=0.251445
X2124   22   149  memristor PARAMS: InitStateVar=0.299557
X2224   23   149  memristor PARAMS: InitStateVar=0.580753
X2324   24   149  memristor PARAMS: InitStateVar=0.391982
X2424   25   149  memristor PARAMS: InitStateVar=0.100001
X2524   26   149  memristor PARAMS: InitStateVar=0.250378
X2624   27   149  memristor PARAMS: InitStateVar=0.445285
X2724   28   149  memristor PARAMS: InitStateVar=0.2469
X2824   29   149  memristor PARAMS: InitStateVar=0.49995
X2924   30   149  memristor PARAMS: InitStateVar=0.210485
X3024   31   149  memristor PARAMS: InitStateVar=0.243478
X3124   32   149  memristor PARAMS: InitStateVar=0.382391
X3224   33   149  memristor PARAMS: InitStateVar=0.282836
X3324   34   149  memristor PARAMS: InitStateVar=0.369871
X3424   35   149  memristor PARAMS: InitStateVar=0.378968
X3524   36   149  memristor PARAMS: InitStateVar=0.312375
X3624   37   149  memristor PARAMS: InitStateVar=0.289743
X3724   38   149  memristor PARAMS: InitStateVar=0.311251
X3824   39   149  memristor PARAMS: InitStateVar=0.374237
X3924   40   149  memristor PARAMS: InitStateVar=0.292884
X4024   41   149  memristor PARAMS: InitStateVar=0.383716
X4124   42   149  memristor PARAMS: InitStateVar=0.254277
X4224   43   149  memristor PARAMS: InitStateVar=0.237218
X4324   44   149  memristor PARAMS: InitStateVar=0.338026
X4424   45   149  memristor PARAMS: InitStateVar=0.1964
X4524   46   149  memristor PARAMS: InitStateVar=0.112188
X4624   47   149  memristor PARAMS: InitStateVar=0.468409
X4724   48   149  memristor PARAMS: InitStateVar=0.326534
X4824   49   149  memristor PARAMS: InitStateVar=0.250266
X4924   50   149  memristor PARAMS: InitStateVar=0.256985
X5024   51   149  memristor PARAMS: InitStateVar=0.335627
X5124   52   149  memristor PARAMS: InitStateVar=0.317449
X5224   53   149  memristor PARAMS: InitStateVar=0.315513
X5324   54   149  memristor PARAMS: InitStateVar=0.343256
X5424   55   149  memristor PARAMS: InitStateVar=0.336181
X5524   56   149  memristor PARAMS: InitStateVar=0.193544
X5624   57   149  memristor PARAMS: InitStateVar=0.476615
X5724   58   149  memristor PARAMS: InitStateVar=0.362251
X5824   59   149  memristor PARAMS: InitStateVar=0.384567
X5924   60   149  memristor PARAMS: InitStateVar=0.272849
X6024   61   149  memristor PARAMS: InitStateVar=0.283873
X6124   62   149  memristor PARAMS: InitStateVar=0.523322
X6224   63   149  memristor PARAMS: InitStateVar=0.310702
X6324   64   149  memristor PARAMS: InitStateVar=0.232275
X6424   65   149  memristor PARAMS: InitStateVar=0.190473
X6524   66   149  memristor PARAMS: InitStateVar=0.250211
X6624   67   149  memristor PARAMS: InitStateVar=0.24022
X6724   68   149  memristor PARAMS: InitStateVar=0.518393
X6824   69   149  memristor PARAMS: InitStateVar=0.201087
X6924   70   149  memristor PARAMS: InitStateVar=0.404293
X7024   71   149  memristor PARAMS: InitStateVar=0.267127
X7124   72   149  memristor PARAMS: InitStateVar=0.260813
X7224   73   149  memristor PARAMS: InitStateVar=0.28389
X7324   74   149  memristor PARAMS: InitStateVar=0.382038
X7424   75   149  memristor PARAMS: InitStateVar=0.159217
X7524   76   149  memristor PARAMS: InitStateVar=0.163198
X7624   77   149  memristor PARAMS: InitStateVar=0.269334
X7724   78   149  memristor PARAMS: InitStateVar=0.344438
X7824   79   149  memristor PARAMS: InitStateVar=0.0266037
X7924   80   149  memristor PARAMS: InitStateVar=0.314927
X8024   81   149  memristor PARAMS: InitStateVar=0.316326
X8124   82   149  memristor PARAMS: InitStateVar=0.386468
X8224   83   149  memristor PARAMS: InitStateVar=0.170195
X8324   84   149  memristor PARAMS: InitStateVar=0.299573
X8424   85   149  memristor PARAMS: InitStateVar=0.364305
X8524   86   149  memristor PARAMS: InitStateVar=0.30292
X8624   87   149  memristor PARAMS: InitStateVar=0.345211
X8724   88   149  memristor PARAMS: InitStateVar=0.35654
X8824   89   149  memristor PARAMS: InitStateVar=0.261992
X8924   90   149  memristor PARAMS: InitStateVar=0.408212
X9024   91   149  memristor PARAMS: InitStateVar=0.421823
X9124   92   149  memristor PARAMS: InitStateVar=0.197628
X9224   93   149  memristor PARAMS: InitStateVar=0.240311
X9324   94   149  memristor PARAMS: InitStateVar=0.332641
X9424   95   149  memristor PARAMS: InitStateVar=0.302017
X9524   96   149  memristor PARAMS: InitStateVar=0.437772
X9624   97   149  memristor PARAMS: InitStateVar=0.478288
X9724   98   149  memristor PARAMS: InitStateVar=0.40447
X9824   99   149  memristor PARAMS: InitStateVar=0.505698
X9924   100  149  memristor PARAMS: InitStateVar=0.309133
Xo25    149  150  OutputModule PARAMS: Rval=100
*------------------- Column 26 -------------------------------------------------
X25     1    151  memristor PARAMS: InitStateVar=0.417685
X125    2    151  memristor PARAMS: InitStateVar=0.523716
X225    3    151  memristor PARAMS: InitStateVar=0.444383
X325    4    151  memristor PARAMS: InitStateVar=0.346792
X425    5    151  memristor PARAMS: InitStateVar=0.403088
X525    6    151  memristor PARAMS: InitStateVar=0.316568
X625    7    151  memristor PARAMS: InitStateVar=0.544349
X725    8    151  memristor PARAMS: InitStateVar=0.396725
X825    9    151  memristor PARAMS: InitStateVar=0.213107
X925    10   151  memristor PARAMS: InitStateVar=0.234576
X1025   11   151  memristor PARAMS: InitStateVar=0.337729
X1125   12   151  memristor PARAMS: InitStateVar=0.387524
X1225   13   151  memristor PARAMS: InitStateVar=0.269425
X1325   14   151  memristor PARAMS: InitStateVar=0.232821
X1425   15   151  memristor PARAMS: InitStateVar=0.200357
X1525   16   151  memristor PARAMS: InitStateVar=0.412972
X1625   17   151  memristor PARAMS: InitStateVar=0.24358
X1725   18   151  memristor PARAMS: InitStateVar=0.125606
X1825   19   151  memristor PARAMS: InitStateVar=0.273264
X1925   20   151  memristor PARAMS: InitStateVar=0.156215
X2025   21   151  memristor PARAMS: InitStateVar=0.387904
X2125   22   151  memristor PARAMS: InitStateVar=0.333493
X2225   23   151  memristor PARAMS: InitStateVar=0.311605
X2325   24   151  memristor PARAMS: InitStateVar=0.249811
X2425   25   151  memristor PARAMS: InitStateVar=0.165974
X2525   26   151  memristor PARAMS: InitStateVar=0.211363
X2625   27   151  memristor PARAMS: InitStateVar=0.254667
X2725   28   151  memristor PARAMS: InitStateVar=0.333305
X2825   29   151  memristor PARAMS: InitStateVar=0.258524
X2925   30   151  memristor PARAMS: InitStateVar=0.30108
X3025   31   151  memristor PARAMS: InitStateVar=0.239751
X3125   32   151  memristor PARAMS: InitStateVar=0.422226
X3225   33   151  memristor PARAMS: InitStateVar=0.449776
X3325   34   151  memristor PARAMS: InitStateVar=0.209649
X3425   35   151  memristor PARAMS: InitStateVar=0.306156
X3525   36   151  memristor PARAMS: InitStateVar=0.269741
X3625   37   151  memristor PARAMS: InitStateVar=0.346841
X3725   38   151  memristor PARAMS: InitStateVar=0.00505512
X3825   39   151  memristor PARAMS: InitStateVar=0.213629
X3925   40   151  memristor PARAMS: InitStateVar=0.357209
X4025   41   151  memristor PARAMS: InitStateVar=0.317633
X4125   42   151  memristor PARAMS: InitStateVar=0.391133
X4225   43   151  memristor PARAMS: InitStateVar=0.184294
X4325   44   151  memristor PARAMS: InitStateVar=0.230355
X4425   45   151  memristor PARAMS: InitStateVar=0.333927
X4525   46   151  memristor PARAMS: InitStateVar=0.190586
X4625   47   151  memristor PARAMS: InitStateVar=0.45711
X4725   48   151  memristor PARAMS: InitStateVar=0.250147
X4825   49   151  memristor PARAMS: InitStateVar=0.116811
X4925   50   151  memristor PARAMS: InitStateVar=0.428051
X5025   51   151  memristor PARAMS: InitStateVar=0.329643
X5125   52   151  memristor PARAMS: InitStateVar=0.365403
X5225   53   151  memristor PARAMS: InitStateVar=0.295823
X5325   54   151  memristor PARAMS: InitStateVar=0.399646
X5425   55   151  memristor PARAMS: InitStateVar=0.400522
X5525   56   151  memristor PARAMS: InitStateVar=0.1191
X5625   57   151  memristor PARAMS: InitStateVar=0.365898
X5725   58   151  memristor PARAMS: InitStateVar=0.44909
X5825   59   151  memristor PARAMS: InitStateVar=0.12228
X5925   60   151  memristor PARAMS: InitStateVar=0.375988
X6025   61   151  memristor PARAMS: InitStateVar=0.349179
X6125   62   151  memristor PARAMS: InitStateVar=0.294459
X6225   63   151  memristor PARAMS: InitStateVar=0.344853
X6325   64   151  memristor PARAMS: InitStateVar=0.207938
X6425   65   151  memristor PARAMS: InitStateVar=0.273266
X6525   66   151  memristor PARAMS: InitStateVar=0.221536
X6625   67   151  memristor PARAMS: InitStateVar=0.273278
X6725   68   151  memristor PARAMS: InitStateVar=0.408718
X6825   69   151  memristor PARAMS: InitStateVar=0.586474
X6925   70   151  memristor PARAMS: InitStateVar=0.419552
X7025   71   151  memristor PARAMS: InitStateVar=0.161763
X7125   72   151  memristor PARAMS: InitStateVar=0.313472
X7225   73   151  memristor PARAMS: InitStateVar=0.460326
X7325   74   151  memristor PARAMS: InitStateVar=0.214067
X7425   75   151  memristor PARAMS: InitStateVar=0.296732
X7525   76   151  memristor PARAMS: InitStateVar=0.378935
X7625   77   151  memristor PARAMS: InitStateVar=0.201078
X7725   78   151  memristor PARAMS: InitStateVar=0.398374
X7825   79   151  memristor PARAMS: InitStateVar=0.236837
X7925   80   151  memristor PARAMS: InitStateVar=0.274927
X8025   81   151  memristor PARAMS: InitStateVar=0.225025
X8125   82   151  memristor PARAMS: InitStateVar=0.222532
X8225   83   151  memristor PARAMS: InitStateVar=0.29862
X8325   84   151  memristor PARAMS: InitStateVar=0.317166
X8425   85   151  memristor PARAMS: InitStateVar=0.530873
X8525   86   151  memristor PARAMS: InitStateVar=0.367343
X8625   87   151  memristor PARAMS: InitStateVar=0.132354
X8725   88   151  memristor PARAMS: InitStateVar=0.35817
X8825   89   151  memristor PARAMS: InitStateVar=0.27815
X8925   90   151  memristor PARAMS: InitStateVar=0.261543
X9025   91   151  memristor PARAMS: InitStateVar=0.215078
X9125   92   151  memristor PARAMS: InitStateVar=0.216736
X9225   93   151  memristor PARAMS: InitStateVar=0.296014
X9325   94   151  memristor PARAMS: InitStateVar=0.34319
X9425   95   151  memristor PARAMS: InitStateVar=0.219519
X9525   96   151  memristor PARAMS: InitStateVar=0.352396
X9625   97   151  memristor PARAMS: InitStateVar=0.359004
X9725   98   151  memristor PARAMS: InitStateVar=0.260779
X9825   99   151  memristor PARAMS: InitStateVar=0.398411
X9925   100  151  memristor PARAMS: InitStateVar=0.113507
Xo26    151  152  OutputModule PARAMS: Rval=100
*------------------- Column 27 -------------------------------------------------
X26     1    153  memristor PARAMS: InitStateVar=0.224352
X126    2    153  memristor PARAMS: InitStateVar=0.256575
X226    3    153  memristor PARAMS: InitStateVar=0.571253
X326    4    153  memristor PARAMS: InitStateVar=0.211137
X426    5    153  memristor PARAMS: InitStateVar=0.433745
X526    6    153  memristor PARAMS: InitStateVar=0.35964
X626    7    153  memristor PARAMS: InitStateVar=0.248387
X726    8    153  memristor PARAMS: InitStateVar=0.501902
X826    9    153  memristor PARAMS: InitStateVar=0.307142
X926    10   153  memristor PARAMS: InitStateVar=0.453368
X1026   11   153  memristor PARAMS: InitStateVar=0.196366
X1126   12   153  memristor PARAMS: InitStateVar=0.444952
X1226   13   153  memristor PARAMS: InitStateVar=0.308608
X1326   14   153  memristor PARAMS: InitStateVar=0.304411
X1426   15   153  memristor PARAMS: InitStateVar=0.0902414
X1526   16   153  memristor PARAMS: InitStateVar=0.172894
X1626   17   153  memristor PARAMS: InitStateVar=0.287058
X1726   18   153  memristor PARAMS: InitStateVar=0.0267404
X1826   19   153  memristor PARAMS: InitStateVar=0.41348
X1926   20   153  memristor PARAMS: InitStateVar=0.449821
X2026   21   153  memristor PARAMS: InitStateVar=0.272141
X2126   22   153  memristor PARAMS: InitStateVar=0.496778
X2226   23   153  memristor PARAMS: InitStateVar=0.245314
X2326   24   153  memristor PARAMS: InitStateVar=0.240915
X2426   25   153  memristor PARAMS: InitStateVar=0.515541
X2526   26   153  memristor PARAMS: InitStateVar=0.216376
X2626   27   153  memristor PARAMS: InitStateVar=0.237961
X2726   28   153  memristor PARAMS: InitStateVar=0.272951
X2826   29   153  memristor PARAMS: InitStateVar=0.196746
X2926   30   153  memristor PARAMS: InitStateVar=0.449962
X3026   31   153  memristor PARAMS: InitStateVar=0.344797
X3126   32   153  memristor PARAMS: InitStateVar=0.346827
X3226   33   153  memristor PARAMS: InitStateVar=0.32229
X3326   34   153  memristor PARAMS: InitStateVar=0.263554
X3426   35   153  memristor PARAMS: InitStateVar=0.33456
X3526   36   153  memristor PARAMS: InitStateVar=0.313415
X3626   37   153  memristor PARAMS: InitStateVar=0.189389
X3726   38   153  memristor PARAMS: InitStateVar=0.276552
X3826   39   153  memristor PARAMS: InitStateVar=0.270083
X3926   40   153  memristor PARAMS: InitStateVar=0.213738
X4026   41   153  memristor PARAMS: InitStateVar=0.25029
X4126   42   153  memristor PARAMS: InitStateVar=0.379537
X4226   43   153  memristor PARAMS: InitStateVar=0.154433
X4326   44   153  memristor PARAMS: InitStateVar=0.0851452
X4426   45   153  memristor PARAMS: InitStateVar=0.282719
X4526   46   153  memristor PARAMS: InitStateVar=0.19866
X4626   47   153  memristor PARAMS: InitStateVar=0.166169
X4726   48   153  memristor PARAMS: InitStateVar=0.332303
X4826   49   153  memristor PARAMS: InitStateVar=0.279253
X4926   50   153  memristor PARAMS: InitStateVar=0.212479
X5026   51   153  memristor PARAMS: InitStateVar=0.320629
X5126   52   153  memristor PARAMS: InitStateVar=0.398365
X5226   53   153  memristor PARAMS: InitStateVar=0.103619
X5326   54   153  memristor PARAMS: InitStateVar=0.347654
X5426   55   153  memristor PARAMS: InitStateVar=0.346439
X5526   56   153  memristor PARAMS: InitStateVar=0.139315
X5626   57   153  memristor PARAMS: InitStateVar=0.293535
X5726   58   153  memristor PARAMS: InitStateVar=0.288178
X5826   59   153  memristor PARAMS: InitStateVar=0.323974
X5926   60   153  memristor PARAMS: InitStateVar=0.309736
X6026   61   153  memristor PARAMS: InitStateVar=0.297177
X6126   62   153  memristor PARAMS: InitStateVar=0.278048
X6226   63   153  memristor PARAMS: InitStateVar=0.217753
X6326   64   153  memristor PARAMS: InitStateVar=0.292162
X6426   65   153  memristor PARAMS: InitStateVar=0.256205
X6526   66   153  memristor PARAMS: InitStateVar=0.202967
X6626   67   153  memristor PARAMS: InitStateVar=0.262952
X6726   68   153  memristor PARAMS: InitStateVar=0.250878
X6826   69   153  memristor PARAMS: InitStateVar=0.0945576
X6926   70   153  memristor PARAMS: InitStateVar=0.241048
X7026   71   153  memristor PARAMS: InitStateVar=0.246718
X7126   72   153  memristor PARAMS: InitStateVar=0.340552
X7226   73   153  memristor PARAMS: InitStateVar=0.322691
X7326   74   153  memristor PARAMS: InitStateVar=0.336078
X7426   75   153  memristor PARAMS: InitStateVar=0.156575
X7526   76   153  memristor PARAMS: InitStateVar=0.406875
X7626   77   153  memristor PARAMS: InitStateVar=0.32138
X7726   78   153  memristor PARAMS: InitStateVar=0.373872
X7826   79   153  memristor PARAMS: InitStateVar=0.412841
X7926   80   153  memristor PARAMS: InitStateVar=0.368947
X8026   81   153  memristor PARAMS: InitStateVar=0.272236
X8126   82   153  memristor PARAMS: InitStateVar=0.185075
X8226   83   153  memristor PARAMS: InitStateVar=0.231879
X8326   84   153  memristor PARAMS: InitStateVar=0.411823
X8426   85   153  memristor PARAMS: InitStateVar=0.326797
X8526   86   153  memristor PARAMS: InitStateVar=0.323585
X8626   87   153  memristor PARAMS: InitStateVar=0.317996
X8726   88   153  memristor PARAMS: InitStateVar=0.275928
X8826   89   153  memristor PARAMS: InitStateVar=0.387872
X8926   90   153  memristor PARAMS: InitStateVar=0.27349
X9026   91   153  memristor PARAMS: InitStateVar=0.277377
X9126   92   153  memristor PARAMS: InitStateVar=0.278391
X9226   93   153  memristor PARAMS: InitStateVar=0.260638
X9326   94   153  memristor PARAMS: InitStateVar=0.345151
X9426   95   153  memristor PARAMS: InitStateVar=0.28929
X9526   96   153  memristor PARAMS: InitStateVar=0.3009
X9626   97   153  memristor PARAMS: InitStateVar=-0.0236853
X9726   98   153  memristor PARAMS: InitStateVar=0.185559
X9826   99   153  memristor PARAMS: InitStateVar=0.386309
X9926   100  153  memristor PARAMS: InitStateVar=0.175892
Xo27    153  154  OutputModule PARAMS: Rval=100
*------------------- Column 28 -------------------------------------------------
X27     1    155  memristor PARAMS: InitStateVar=0.380908
X127    2    155  memristor PARAMS: InitStateVar=0.302997
X227    3    155  memristor PARAMS: InitStateVar=0.489561
X327    4    155  memristor PARAMS: InitStateVar=0.335831
X427    5    155  memristor PARAMS: InitStateVar=0.170995
X527    6    155  memristor PARAMS: InitStateVar=0.293496
X627    7    155  memristor PARAMS: InitStateVar=0.218761
X727    8    155  memristor PARAMS: InitStateVar=0.343314
X827    9    155  memristor PARAMS: InitStateVar=0.387913
X927    10   155  memristor PARAMS: InitStateVar=0.0444075
X1027   11   155  memristor PARAMS: InitStateVar=0.341205
X1127   12   155  memristor PARAMS: InitStateVar=0.389388
X1227   13   155  memristor PARAMS: InitStateVar=0.152911
X1327   14   155  memristor PARAMS: InitStateVar=0.286056
X1427   15   155  memristor PARAMS: InitStateVar=0.381886
X1527   16   155  memristor PARAMS: InitStateVar=0.26754
X1627   17   155  memristor PARAMS: InitStateVar=0.30273
X1727   18   155  memristor PARAMS: InitStateVar=0.218854
X1827   19   155  memristor PARAMS: InitStateVar=0.333215
X1927   20   155  memristor PARAMS: InitStateVar=0.393457
X2027   21   155  memristor PARAMS: InitStateVar=0.447008
X2127   22   155  memristor PARAMS: InitStateVar=0.307509
X2227   23   155  memristor PARAMS: InitStateVar=0.469337
X2327   24   155  memristor PARAMS: InitStateVar=0.244094
X2427   25   155  memristor PARAMS: InitStateVar=0.171986
X2527   26   155  memristor PARAMS: InitStateVar=0.220599
X2627   27   155  memristor PARAMS: InitStateVar=0.249798
X2727   28   155  memristor PARAMS: InitStateVar=0.282505
X2827   29   155  memristor PARAMS: InitStateVar=0.236987
X2927   30   155  memristor PARAMS: InitStateVar=0.370002
X3027   31   155  memristor PARAMS: InitStateVar=0.134581
X3127   32   155  memristor PARAMS: InitStateVar=0.357239
X3227   33   155  memristor PARAMS: InitStateVar=0.338321
X3327   34   155  memristor PARAMS: InitStateVar=0.295085
X3427   35   155  memristor PARAMS: InitStateVar=0.36898
X3527   36   155  memristor PARAMS: InitStateVar=0.39413
X3627   37   155  memristor PARAMS: InitStateVar=0.290184
X3727   38   155  memristor PARAMS: InitStateVar=0.26213
X3827   39   155  memristor PARAMS: InitStateVar=0.2036
X3927   40   155  memristor PARAMS: InitStateVar=0.323313
X4027   41   155  memristor PARAMS: InitStateVar=0.461167
X4127   42   155  memristor PARAMS: InitStateVar=0.343643
X4227   43   155  memristor PARAMS: InitStateVar=0.434789
X4327   44   155  memristor PARAMS: InitStateVar=0.345479
X4427   45   155  memristor PARAMS: InitStateVar=0.30264
X4527   46   155  memristor PARAMS: InitStateVar=0.212619
X4627   47   155  memristor PARAMS: InitStateVar=0.4302
X4727   48   155  memristor PARAMS: InitStateVar=0.370065
X4827   49   155  memristor PARAMS: InitStateVar=0.269743
X4927   50   155  memristor PARAMS: InitStateVar=0.265227
X5027   51   155  memristor PARAMS: InitStateVar=0.313821
X5127   52   155  memristor PARAMS: InitStateVar=0.384497
X5227   53   155  memristor PARAMS: InitStateVar=0.294754
X5327   54   155  memristor PARAMS: InitStateVar=0.174965
X5427   55   155  memristor PARAMS: InitStateVar=0.351207
X5527   56   155  memristor PARAMS: InitStateVar=0.0772971
X5627   57   155  memristor PARAMS: InitStateVar=0.35198
X5727   58   155  memristor PARAMS: InitStateVar=0.123316
X5827   59   155  memristor PARAMS: InitStateVar=0.344386
X5927   60   155  memristor PARAMS: InitStateVar=0.362863
X6027   61   155  memristor PARAMS: InitStateVar=0.301742
X6127   62   155  memristor PARAMS: InitStateVar=0.271308
X6227   63   155  memristor PARAMS: InitStateVar=0.166737
X6327   64   155  memristor PARAMS: InitStateVar=0.367303
X6427   65   155  memristor PARAMS: InitStateVar=0.421069
X6527   66   155  memristor PARAMS: InitStateVar=0.369965
X6627   67   155  memristor PARAMS: InitStateVar=0.144522
X6727   68   155  memristor PARAMS: InitStateVar=0.399483
X6827   69   155  memristor PARAMS: InitStateVar=0.1533
X6927   70   155  memristor PARAMS: InitStateVar=0.281198
X7027   71   155  memristor PARAMS: InitStateVar=0.236778
X7127   72   155  memristor PARAMS: InitStateVar=0.234223
X7227   73   155  memristor PARAMS: InitStateVar=0.255588
X7327   74   155  memristor PARAMS: InitStateVar=0.443146
X7427   75   155  memristor PARAMS: InitStateVar=0.418118
X7527   76   155  memristor PARAMS: InitStateVar=0.370003
X7627   77   155  memristor PARAMS: InitStateVar=0.352045
X7727   78   155  memristor PARAMS: InitStateVar=0.186456
X7827   79   155  memristor PARAMS: InitStateVar=0.276909
X7927   80   155  memristor PARAMS: InitStateVar=0.265353
X8027   81   155  memristor PARAMS: InitStateVar=0.186001
X8127   82   155  memristor PARAMS: InitStateVar=0.230031
X8227   83   155  memristor PARAMS: InitStateVar=0.298462
X8327   84   155  memristor PARAMS: InitStateVar=0.276799
X8427   85   155  memristor PARAMS: InitStateVar=0.258281
X8527   86   155  memristor PARAMS: InitStateVar=0.209806
X8627   87   155  memristor PARAMS: InitStateVar=0.343715
X8727   88   155  memristor PARAMS: InitStateVar=0.277801
X8827   89   155  memristor PARAMS: InitStateVar=0.292081
X8927   90   155  memristor PARAMS: InitStateVar=0.401841
X9027   91   155  memristor PARAMS: InitStateVar=0.580361
X9127   92   155  memristor PARAMS: InitStateVar=0.34199
X9227   93   155  memristor PARAMS: InitStateVar=0.242305
X9327   94   155  memristor PARAMS: InitStateVar=0.401137
X9427   95   155  memristor PARAMS: InitStateVar=0.212867
X9527   96   155  memristor PARAMS: InitStateVar=0.462011
X9627   97   155  memristor PARAMS: InitStateVar=0.33271
X9727   98   155  memristor PARAMS: InitStateVar=0.488785
X9827   99   155  memristor PARAMS: InitStateVar=0.223515
X9927   100  155  memristor PARAMS: InitStateVar=0.281519
Xo28    155  156  OutputModule PARAMS: Rval=100
*------------------- Column 29 -------------------------------------------------
X28     1    157  memristor PARAMS: InitStateVar=0.383017
X128    2    157  memristor PARAMS: InitStateVar=0.234015
X228    3    157  memristor PARAMS: InitStateVar=0.243245
X328    4    157  memristor PARAMS: InitStateVar=0.34167
X428    5    157  memristor PARAMS: InitStateVar=0.345632
X528    6    157  memristor PARAMS: InitStateVar=0.275635
X628    7    157  memristor PARAMS: InitStateVar=0.277602
X728    8    157  memristor PARAMS: InitStateVar=0.320481
X828    9    157  memristor PARAMS: InitStateVar=0.128914
X928    10   157  memristor PARAMS: InitStateVar=0.351362
X1028   11   157  memristor PARAMS: InitStateVar=0.217705
X1128   12   157  memristor PARAMS: InitStateVar=0.190832
X1228   13   157  memristor PARAMS: InitStateVar=0.24884
X1328   14   157  memristor PARAMS: InitStateVar=0.221045
X1428   15   157  memristor PARAMS: InitStateVar=0.409744
X1528   16   157  memristor PARAMS: InitStateVar=0.268754
X1628   17   157  memristor PARAMS: InitStateVar=0.19908
X1728   18   157  memristor PARAMS: InitStateVar=0.283045
X1828   19   157  memristor PARAMS: InitStateVar=0.210552
X1928   20   157  memristor PARAMS: InitStateVar=0.281615
X2028   21   157  memristor PARAMS: InitStateVar=0.394894
X2128   22   157  memristor PARAMS: InitStateVar=0.385545
X2228   23   157  memristor PARAMS: InitStateVar=0.351615
X2328   24   157  memristor PARAMS: InitStateVar=0.258176
X2428   25   157  memristor PARAMS: InitStateVar=0.238696
X2528   26   157  memristor PARAMS: InitStateVar=0.273796
X2628   27   157  memristor PARAMS: InitStateVar=0.27283
X2728   28   157  memristor PARAMS: InitStateVar=0.38714
X2828   29   157  memristor PARAMS: InitStateVar=0.245351
X2928   30   157  memristor PARAMS: InitStateVar=0.181919
X3028   31   157  memristor PARAMS: InitStateVar=0.342581
X3128   32   157  memristor PARAMS: InitStateVar=0.154303
X3228   33   157  memristor PARAMS: InitStateVar=0.360094
X3328   34   157  memristor PARAMS: InitStateVar=0.537235
X3428   35   157  memristor PARAMS: InitStateVar=0.553498
X3528   36   157  memristor PARAMS: InitStateVar=0.318905
X3628   37   157  memristor PARAMS: InitStateVar=0.303078
X3728   38   157  memristor PARAMS: InitStateVar=0.372839
X3828   39   157  memristor PARAMS: InitStateVar=0.374133
X3928   40   157  memristor PARAMS: InitStateVar=0.245056
X4028   41   157  memristor PARAMS: InitStateVar=0.375227
X4128   42   157  memristor PARAMS: InitStateVar=0.436508
X4228   43   157  memristor PARAMS: InitStateVar=0.155577
X4328   44   157  memristor PARAMS: InitStateVar=0.15998
X4428   45   157  memristor PARAMS: InitStateVar=0.335992
X4528   46   157  memristor PARAMS: InitStateVar=0.273295
X4628   47   157  memristor PARAMS: InitStateVar=0.349017
X4728   48   157  memristor PARAMS: InitStateVar=0.212562
X4828   49   157  memristor PARAMS: InitStateVar=0.214712
X4928   50   157  memristor PARAMS: InitStateVar=0.297081
X5028   51   157  memristor PARAMS: InitStateVar=0.439074
X5128   52   157  memristor PARAMS: InitStateVar=0.19574
X5228   53   157  memristor PARAMS: InitStateVar=0.14096
X5328   54   157  memristor PARAMS: InitStateVar=0.213714
X5428   55   157  memristor PARAMS: InitStateVar=0.452327
X5528   56   157  memristor PARAMS: InitStateVar=0.458642
X5628   57   157  memristor PARAMS: InitStateVar=0.414144
X5728   58   157  memristor PARAMS: InitStateVar=0.389759
X5828   59   157  memristor PARAMS: InitStateVar=0.250346
X5928   60   157  memristor PARAMS: InitStateVar=0.331724
X6028   61   157  memristor PARAMS: InitStateVar=0.450568
X6128   62   157  memristor PARAMS: InitStateVar=0.116186
X6228   63   157  memristor PARAMS: InitStateVar=0.0711244
X6328   64   157  memristor PARAMS: InitStateVar=0.455523
X6428   65   157  memristor PARAMS: InitStateVar=0.444735
X6528   66   157  memristor PARAMS: InitStateVar=0.365886
X6628   67   157  memristor PARAMS: InitStateVar=0.224398
X6728   68   157  memristor PARAMS: InitStateVar=0.468867
X6828   69   157  memristor PARAMS: InitStateVar=0.334186
X6928   70   157  memristor PARAMS: InitStateVar=0.177349
X7028   71   157  memristor PARAMS: InitStateVar=0.359726
X7128   72   157  memristor PARAMS: InitStateVar=0.0723464
X7228   73   157  memristor PARAMS: InitStateVar=0.283596
X7328   74   157  memristor PARAMS: InitStateVar=0.22856
X7428   75   157  memristor PARAMS: InitStateVar=0.361547
X7528   76   157  memristor PARAMS: InitStateVar=0.4255
X7628   77   157  memristor PARAMS: InitStateVar=0.400882
X7728   78   157  memristor PARAMS: InitStateVar=0.21882
X7828   79   157  memristor PARAMS: InitStateVar=0.358097
X7928   80   157  memristor PARAMS: InitStateVar=0.248163
X8028   81   157  memristor PARAMS: InitStateVar=0.562655
X8128   82   157  memristor PARAMS: InitStateVar=0.150379
X8228   83   157  memristor PARAMS: InitStateVar=0.375689
X8328   84   157  memristor PARAMS: InitStateVar=0.12056
X8428   85   157  memristor PARAMS: InitStateVar=0.28753
X8528   86   157  memristor PARAMS: InitStateVar=0.247587
X8628   87   157  memristor PARAMS: InitStateVar=0.456217
X8728   88   157  memristor PARAMS: InitStateVar=0.370722
X8828   89   157  memristor PARAMS: InitStateVar=0.267626
X8928   90   157  memristor PARAMS: InitStateVar=0.255753
X9028   91   157  memristor PARAMS: InitStateVar=0.240803
X9128   92   157  memristor PARAMS: InitStateVar=0.495507
X9228   93   157  memristor PARAMS: InitStateVar=0.373161
X9328   94   157  memristor PARAMS: InitStateVar=0.19194
X9428   95   157  memristor PARAMS: InitStateVar=0.25445
X9528   96   157  memristor PARAMS: InitStateVar=0.455198
X9628   97   157  memristor PARAMS: InitStateVar=0.231964
X9728   98   157  memristor PARAMS: InitStateVar=0.210391
X9828   99   157  memristor PARAMS: InitStateVar=0.228569
X9928   100  157  memristor PARAMS: InitStateVar=0.312916
Xo29    157  158  OutputModule PARAMS: Rval=100
*------------------- Column 30 -------------------------------------------------
X29     1    159  memristor PARAMS: InitStateVar=0.360701
X129    2    159  memristor PARAMS: InitStateVar=0.131493
X229    3    159  memristor PARAMS: InitStateVar=0.31364
X329    4    159  memristor PARAMS: InitStateVar=0.439865
X429    5    159  memristor PARAMS: InitStateVar=0.312878
X529    6    159  memristor PARAMS: InitStateVar=0.407628
X629    7    159  memristor PARAMS: InitStateVar=0.402707
X729    8    159  memristor PARAMS: InitStateVar=0.187217
X829    9    159  memristor PARAMS: InitStateVar=0.439098
X929    10   159  memristor PARAMS: InitStateVar=0.185556
X1029   11   159  memristor PARAMS: InitStateVar=0.243897
X1129   12   159  memristor PARAMS: InitStateVar=0.370448
X1229   13   159  memristor PARAMS: InitStateVar=0.248925
X1329   14   159  memristor PARAMS: InitStateVar=0.3907
X1429   15   159  memristor PARAMS: InitStateVar=0.411528
X1529   16   159  memristor PARAMS: InitStateVar=0.367526
X1629   17   159  memristor PARAMS: InitStateVar=0.433947
X1729   18   159  memristor PARAMS: InitStateVar=0.331145
X1829   19   159  memristor PARAMS: InitStateVar=0.212024
X1929   20   159  memristor PARAMS: InitStateVar=0.209044
X2029   21   159  memristor PARAMS: InitStateVar=0.28442
X2129   22   159  memristor PARAMS: InitStateVar=0.282337
X2229   23   159  memristor PARAMS: InitStateVar=0.416462
X2329   24   159  memristor PARAMS: InitStateVar=0.260798
X2429   25   159  memristor PARAMS: InitStateVar=0.129674
X2529   26   159  memristor PARAMS: InitStateVar=0.328674
X2629   27   159  memristor PARAMS: InitStateVar=0.31601
X2729   28   159  memristor PARAMS: InitStateVar=0.360456
X2829   29   159  memristor PARAMS: InitStateVar=0.299577
X2929   30   159  memristor PARAMS: InitStateVar=0.28002
X3029   31   159  memristor PARAMS: InitStateVar=0.369874
X3129   32   159  memristor PARAMS: InitStateVar=0.245731
X3229   33   159  memristor PARAMS: InitStateVar=0.327604
X3329   34   159  memristor PARAMS: InitStateVar=0.316952
X3429   35   159  memristor PARAMS: InitStateVar=0.383956
X3529   36   159  memristor PARAMS: InitStateVar=0.339591
X3629   37   159  memristor PARAMS: InitStateVar=0.427135
X3729   38   159  memristor PARAMS: InitStateVar=0.523835
X3829   39   159  memristor PARAMS: InitStateVar=0.283649
X3929   40   159  memristor PARAMS: InitStateVar=0.362679
X4029   41   159  memristor PARAMS: InitStateVar=0.155051
X4129   42   159  memristor PARAMS: InitStateVar=0.223477
X4229   43   159  memristor PARAMS: InitStateVar=0.205133
X4329   44   159  memristor PARAMS: InitStateVar=0.245273
X4429   45   159  memristor PARAMS: InitStateVar=0.0836775
X4529   46   159  memristor PARAMS: InitStateVar=0.334639
X4629   47   159  memristor PARAMS: InitStateVar=0.235101
X4729   48   159  memristor PARAMS: InitStateVar=0.232392
X4829   49   159  memristor PARAMS: InitStateVar=0.307417
X4929   50   159  memristor PARAMS: InitStateVar=0.209141
X5029   51   159  memristor PARAMS: InitStateVar=0.257239
X5129   52   159  memristor PARAMS: InitStateVar=0.314013
X5229   53   159  memristor PARAMS: InitStateVar=0.389464
X5329   54   159  memristor PARAMS: InitStateVar=0.215715
X5429   55   159  memristor PARAMS: InitStateVar=0.262158
X5529   56   159  memristor PARAMS: InitStateVar=0.286721
X5629   57   159  memristor PARAMS: InitStateVar=0.421608
X5729   58   159  memristor PARAMS: InitStateVar=0.302042
X5829   59   159  memristor PARAMS: InitStateVar=0.289662
X5929   60   159  memristor PARAMS: InitStateVar=0.370034
X6029   61   159  memristor PARAMS: InitStateVar=0.230469
X6129   62   159  memristor PARAMS: InitStateVar=0.394539
X6229   63   159  memristor PARAMS: InitStateVar=0.295582
X6329   64   159  memristor PARAMS: InitStateVar=0.399558
X6429   65   159  memristor PARAMS: InitStateVar=0.107014
X6529   66   159  memristor PARAMS: InitStateVar=0.102196
X6629   67   159  memristor PARAMS: InitStateVar=0.344989
X6729   68   159  memristor PARAMS: InitStateVar=0.289559
X6829   69   159  memristor PARAMS: InitStateVar=0.244963
X6929   70   159  memristor PARAMS: InitStateVar=0.279541
X7029   71   159  memristor PARAMS: InitStateVar=0.144259
X7129   72   159  memristor PARAMS: InitStateVar=0.336526
X7229   73   159  memristor PARAMS: InitStateVar=0.0720249
X7329   74   159  memristor PARAMS: InitStateVar=0.505305
X7429   75   159  memristor PARAMS: InitStateVar=0.304336
X7529   76   159  memristor PARAMS: InitStateVar=0.319381
X7629   77   159  memristor PARAMS: InitStateVar=0.457232
X7729   78   159  memristor PARAMS: InitStateVar=0.38128
X7829   79   159  memristor PARAMS: InitStateVar=0.197655
X7929   80   159  memristor PARAMS: InitStateVar=0.298766
X8029   81   159  memristor PARAMS: InitStateVar=0.276501
X8129   82   159  memristor PARAMS: InitStateVar=0.209239
X8229   83   159  memristor PARAMS: InitStateVar=0.49116
X8329   84   159  memristor PARAMS: InitStateVar=0.286463
X8429   85   159  memristor PARAMS: InitStateVar=0.307957
X8529   86   159  memristor PARAMS: InitStateVar=0.203176
X8629   87   159  memristor PARAMS: InitStateVar=0.312017
X8729   88   159  memristor PARAMS: InitStateVar=0.415385
X8829   89   159  memristor PARAMS: InitStateVar=0.411566
X8929   90   159  memristor PARAMS: InitStateVar=0.266608
X9029   91   159  memristor PARAMS: InitStateVar=0.288292
X9129   92   159  memristor PARAMS: InitStateVar=0.290117
X9229   93   159  memristor PARAMS: InitStateVar=0.342219
X9329   94   159  memristor PARAMS: InitStateVar=0.406074
X9429   95   159  memristor PARAMS: InitStateVar=0.25353
X9529   96   159  memristor PARAMS: InitStateVar=0.186444
X9629   97   159  memristor PARAMS: InitStateVar=0.260774
X9729   98   159  memristor PARAMS: InitStateVar=0.189285
X9829   99   159  memristor PARAMS: InitStateVar=0.253551
X9929   100  159  memristor PARAMS: InitStateVar=0.157061
Xo30    159  160  OutputModule PARAMS: Rval=100
*------------------- Column 31 -------------------------------------------------
X30     1    161  memristor PARAMS: InitStateVar=0.220301
X130    2    161  memristor PARAMS: InitStateVar=0.286959
X230    3    161  memristor PARAMS: InitStateVar=0.263101
X330    4    161  memristor PARAMS: InitStateVar=0.265236
X430    5    161  memristor PARAMS: InitStateVar=0.505144
X530    6    161  memristor PARAMS: InitStateVar=0.157135
X630    7    161  memristor PARAMS: InitStateVar=0.466559
X730    8    161  memristor PARAMS: InitStateVar=0.272092
X830    9    161  memristor PARAMS: InitStateVar=0.289958
X930    10   161  memristor PARAMS: InitStateVar=0.327964
X1030   11   161  memristor PARAMS: InitStateVar=0.370844
X1130   12   161  memristor PARAMS: InitStateVar=0.321885
X1230   13   161  memristor PARAMS: InitStateVar=0.332638
X1330   14   161  memristor PARAMS: InitStateVar=0.389256
X1430   15   161  memristor PARAMS: InitStateVar=0.406795
X1530   16   161  memristor PARAMS: InitStateVar=0.468584
X1630   17   161  memristor PARAMS: InitStateVar=0.396594
X1730   18   161  memristor PARAMS: InitStateVar=0.24362
X1830   19   161  memristor PARAMS: InitStateVar=0.371352
X1930   20   161  memristor PARAMS: InitStateVar=0.277044
X2030   21   161  memristor PARAMS: InitStateVar=0.353365
X2130   22   161  memristor PARAMS: InitStateVar=0.462804
X2230   23   161  memristor PARAMS: InitStateVar=0.138805
X2330   24   161  memristor PARAMS: InitStateVar=0.22978
X2430   25   161  memristor PARAMS: InitStateVar=0.337266
X2530   26   161  memristor PARAMS: InitStateVar=0.258064
X2630   27   161  memristor PARAMS: InitStateVar=0.358183
X2730   28   161  memristor PARAMS: InitStateVar=0.485761
X2830   29   161  memristor PARAMS: InitStateVar=0.368348
X2930   30   161  memristor PARAMS: InitStateVar=0.278653
X3030   31   161  memristor PARAMS: InitStateVar=0.226419
X3130   32   161  memristor PARAMS: InitStateVar=0.136475
X3230   33   161  memristor PARAMS: InitStateVar=0.322113
X3330   34   161  memristor PARAMS: InitStateVar=0.381958
X3430   35   161  memristor PARAMS: InitStateVar=0.333227
X3530   36   161  memristor PARAMS: InitStateVar=0.299758
X3630   37   161  memristor PARAMS: InitStateVar=0.302013
X3730   38   161  memristor PARAMS: InitStateVar=0.187132
X3830   39   161  memristor PARAMS: InitStateVar=0.342694
X3930   40   161  memristor PARAMS: InitStateVar=0.12285
X4030   41   161  memristor PARAMS: InitStateVar=0.381895
X4130   42   161  memristor PARAMS: InitStateVar=0.214869
X4230   43   161  memristor PARAMS: InitStateVar=0.255733
X4330   44   161  memristor PARAMS: InitStateVar=0.261104
X4430   45   161  memristor PARAMS: InitStateVar=0.378122
X4530   46   161  memristor PARAMS: InitStateVar=0.299448
X4630   47   161  memristor PARAMS: InitStateVar=0.27717
X4730   48   161  memristor PARAMS: InitStateVar=0.516263
X4830   49   161  memristor PARAMS: InitStateVar=0.248354
X4930   50   161  memristor PARAMS: InitStateVar=0.422099
X5030   51   161  memristor PARAMS: InitStateVar=0.485168
X5130   52   161  memristor PARAMS: InitStateVar=0.190261
X5230   53   161  memristor PARAMS: InitStateVar=0.37187
X5330   54   161  memristor PARAMS: InitStateVar=0.138455
X5430   55   161  memristor PARAMS: InitStateVar=0.278964
X5530   56   161  memristor PARAMS: InitStateVar=0.277951
X5630   57   161  memristor PARAMS: InitStateVar=0.386833
X5730   58   161  memristor PARAMS: InitStateVar=0.0735149
X5830   59   161  memristor PARAMS: InitStateVar=0.326999
X5930   60   161  memristor PARAMS: InitStateVar=0.23391
X6030   61   161  memristor PARAMS: InitStateVar=0.333326
X6130   62   161  memristor PARAMS: InitStateVar=0.262152
X6230   63   161  memristor PARAMS: InitStateVar=0.332465
X6330   64   161  memristor PARAMS: InitStateVar=0.192357
X6430   65   161  memristor PARAMS: InitStateVar=0.362287
X6530   66   161  memristor PARAMS: InitStateVar=0.318674
X6630   67   161  memristor PARAMS: InitStateVar=0.37386
X6730   68   161  memristor PARAMS: InitStateVar=0.262488
X6830   69   161  memristor PARAMS: InitStateVar=0.384719
X6930   70   161  memristor PARAMS: InitStateVar=0.298899
X7030   71   161  memristor PARAMS: InitStateVar=0.222612
X7130   72   161  memristor PARAMS: InitStateVar=0.502595
X7230   73   161  memristor PARAMS: InitStateVar=0.342513
X7330   74   161  memristor PARAMS: InitStateVar=0.152996
X7430   75   161  memristor PARAMS: InitStateVar=0.285312
X7530   76   161  memristor PARAMS: InitStateVar=0.245902
X7630   77   161  memristor PARAMS: InitStateVar=0.31586
X7730   78   161  memristor PARAMS: InitStateVar=0.521766
X7830   79   161  memristor PARAMS: InitStateVar=0.269572
X7930   80   161  memristor PARAMS: InitStateVar=0.400065
X8030   81   161  memristor PARAMS: InitStateVar=0.343442
X8130   82   161  memristor PARAMS: InitStateVar=0.370045
X8230   83   161  memristor PARAMS: InitStateVar=0.291679
X8330   84   161  memristor PARAMS: InitStateVar=0.366049
X8430   85   161  memristor PARAMS: InitStateVar=0.137374
X8530   86   161  memristor PARAMS: InitStateVar=0.352397
X8630   87   161  memristor PARAMS: InitStateVar=0.201145
X8730   88   161  memristor PARAMS: InitStateVar=0.194371
X8830   89   161  memristor PARAMS: InitStateVar=0.310063
X8930   90   161  memristor PARAMS: InitStateVar=0.269733
X9030   91   161  memristor PARAMS: InitStateVar=0.335423
X9130   92   161  memristor PARAMS: InitStateVar=0.623923
X9230   93   161  memristor PARAMS: InitStateVar=0.493543
X9330   94   161  memristor PARAMS: InitStateVar=0.43267
X9430   95   161  memristor PARAMS: InitStateVar=0.328976
X9530   96   161  memristor PARAMS: InitStateVar=0.328374
X9630   97   161  memristor PARAMS: InitStateVar=0.289181
X9730   98   161  memristor PARAMS: InitStateVar=0.130309
X9830   99   161  memristor PARAMS: InitStateVar=0.349649
X9930   100  161  memristor PARAMS: InitStateVar=0.263381
Xo31    161  162  OutputModule PARAMS: Rval=100
*------------------- Column 32 -------------------------------------------------
X31     1    163  memristor PARAMS: InitStateVar=0.367035
X131    2    163  memristor PARAMS: InitStateVar=0.323389
X231    3    163  memristor PARAMS: InitStateVar=0.284124
X331    4    163  memristor PARAMS: InitStateVar=0.445006
X431    5    163  memristor PARAMS: InitStateVar=0.515415
X531    6    163  memristor PARAMS: InitStateVar=0.351868
X631    7    163  memristor PARAMS: InitStateVar=0.394648
X731    8    163  memristor PARAMS: InitStateVar=0.182479
X831    9    163  memristor PARAMS: InitStateVar=0.304216
X931    10   163  memristor PARAMS: InitStateVar=0.360882
X1031   11   163  memristor PARAMS: InitStateVar=0.337362
X1131   12   163  memristor PARAMS: InitStateVar=0.0899514
X1231   13   163  memristor PARAMS: InitStateVar=0.291853
X1331   14   163  memristor PARAMS: InitStateVar=0.194565
X1431   15   163  memristor PARAMS: InitStateVar=0.310815
X1531   16   163  memristor PARAMS: InitStateVar=0.321945
X1631   17   163  memristor PARAMS: InitStateVar=0.30516
X1731   18   163  memristor PARAMS: InitStateVar=0.245172
X1831   19   163  memristor PARAMS: InitStateVar=0.293161
X1931   20   163  memristor PARAMS: InitStateVar=0.307616
X2031   21   163  memristor PARAMS: InitStateVar=0.479163
X2131   22   163  memristor PARAMS: InitStateVar=0.176263
X2231   23   163  memristor PARAMS: InitStateVar=0.336459
X2331   24   163  memristor PARAMS: InitStateVar=0.365691
X2431   25   163  memristor PARAMS: InitStateVar=0.323987
X2531   26   163  memristor PARAMS: InitStateVar=0.405003
X2631   27   163  memristor PARAMS: InitStateVar=0.201944
X2731   28   163  memristor PARAMS: InitStateVar=0.36533
X2831   29   163  memristor PARAMS: InitStateVar=0.253248
X2931   30   163  memristor PARAMS: InitStateVar=0.421775
X3031   31   163  memristor PARAMS: InitStateVar=0.212926
X3131   32   163  memristor PARAMS: InitStateVar=0.213544
X3231   33   163  memristor PARAMS: InitStateVar=0.214657
X3331   34   163  memristor PARAMS: InitStateVar=0.441525
X3431   35   163  memristor PARAMS: InitStateVar=0.348291
X3531   36   163  memristor PARAMS: InitStateVar=0.362495
X3631   37   163  memristor PARAMS: InitStateVar=0.290788
X3731   38   163  memristor PARAMS: InitStateVar=0.305989
X3831   39   163  memristor PARAMS: InitStateVar=0.20279
X3931   40   163  memristor PARAMS: InitStateVar=0.0994549
X4031   41   163  memristor PARAMS: InitStateVar=0.364706
X4131   42   163  memristor PARAMS: InitStateVar=0.327064
X4231   43   163  memristor PARAMS: InitStateVar=0.348277
X4331   44   163  memristor PARAMS: InitStateVar=0.37937
X4431   45   163  memristor PARAMS: InitStateVar=0.305168
X4531   46   163  memristor PARAMS: InitStateVar=0.273412
X4631   47   163  memristor PARAMS: InitStateVar=0.280803
X4731   48   163  memristor PARAMS: InitStateVar=0.293903
X4831   49   163  memristor PARAMS: InitStateVar=0.318401
X4931   50   163  memristor PARAMS: InitStateVar=0.284101
X5031   51   163  memristor PARAMS: InitStateVar=0.478841
X5131   52   163  memristor PARAMS: InitStateVar=0.473264
X5231   53   163  memristor PARAMS: InitStateVar=0.268198
X5331   54   163  memristor PARAMS: InitStateVar=0.429605
X5431   55   163  memristor PARAMS: InitStateVar=0.403186
X5531   56   163  memristor PARAMS: InitStateVar=0.34158
X5631   57   163  memristor PARAMS: InitStateVar=0.173109
X5731   58   163  memristor PARAMS: InitStateVar=0.43728
X5831   59   163  memristor PARAMS: InitStateVar=0.367247
X5931   60   163  memristor PARAMS: InitStateVar=0.15177
X6031   61   163  memristor PARAMS: InitStateVar=0.265611
X6131   62   163  memristor PARAMS: InitStateVar=0.198596
X6231   63   163  memristor PARAMS: InitStateVar=0.2104
X6331   64   163  memristor PARAMS: InitStateVar=0.382679
X6431   65   163  memristor PARAMS: InitStateVar=0.223864
X6531   66   163  memristor PARAMS: InitStateVar=0.158389
X6631   67   163  memristor PARAMS: InitStateVar=0.308442
X6731   68   163  memristor PARAMS: InitStateVar=0.37565
X6831   69   163  memristor PARAMS: InitStateVar=0.340343
X6931   70   163  memristor PARAMS: InitStateVar=0.3258
X7031   71   163  memristor PARAMS: InitStateVar=0.53547
X7131   72   163  memristor PARAMS: InitStateVar=0.286823
X7231   73   163  memristor PARAMS: InitStateVar=0.201538
X7331   74   163  memristor PARAMS: InitStateVar=0.17129
X7431   75   163  memristor PARAMS: InitStateVar=0.248489
X7531   76   163  memristor PARAMS: InitStateVar=0.457248
X7631   77   163  memristor PARAMS: InitStateVar=0.269404
X7731   78   163  memristor PARAMS: InitStateVar=0.517579
X7831   79   163  memristor PARAMS: InitStateVar=0.268724
X7931   80   163  memristor PARAMS: InitStateVar=0.100935
X8031   81   163  memristor PARAMS: InitStateVar=0.150836
X8131   82   163  memristor PARAMS: InitStateVar=0.177899
X8231   83   163  memristor PARAMS: InitStateVar=0.315962
X8331   84   163  memristor PARAMS: InitStateVar=0.308364
X8431   85   163  memristor PARAMS: InitStateVar=0.409868
X8531   86   163  memristor PARAMS: InitStateVar=0.410912
X8631   87   163  memristor PARAMS: InitStateVar=0.234781
X8731   88   163  memristor PARAMS: InitStateVar=0.289059
X8831   89   163  memristor PARAMS: InitStateVar=0.442039
X8931   90   163  memristor PARAMS: InitStateVar=0.301851
X9031   91   163  memristor PARAMS: InitStateVar=0.345884
X9131   92   163  memristor PARAMS: InitStateVar=0.434987
X9231   93   163  memristor PARAMS: InitStateVar=0.388541
X9331   94   163  memristor PARAMS: InitStateVar=0.290266
X9431   95   163  memristor PARAMS: InitStateVar=0.294826
X9531   96   163  memristor PARAMS: InitStateVar=0.0938609
X9631   97   163  memristor PARAMS: InitStateVar=0.41491
X9731   98   163  memristor PARAMS: InitStateVar=0.319324
X9831   99   163  memristor PARAMS: InitStateVar=0.314473
X9931   100  163  memristor PARAMS: InitStateVar=0.1505
Xo32    163  164  OutputModule PARAMS: Rval=100
*------------------- Column 33 -------------------------------------------------
X32     1    165  memristor PARAMS: InitStateVar=0.0553808
X132    2    165  memristor PARAMS: InitStateVar=0.234969
X232    3    165  memristor PARAMS: InitStateVar=0.409661
X332    4    165  memristor PARAMS: InitStateVar=0.444811
X432    5    165  memristor PARAMS: InitStateVar=0.300743
X532    6    165  memristor PARAMS: InitStateVar=0.354431
X632    7    165  memristor PARAMS: InitStateVar=0.133669
X732    8    165  memristor PARAMS: InitStateVar=0.385354
X832    9    165  memristor PARAMS: InitStateVar=0.248865
X932    10   165  memristor PARAMS: InitStateVar=0.371826
X1032   11   165  memristor PARAMS: InitStateVar=0.357187
X1132   12   165  memristor PARAMS: InitStateVar=0.375839
X1232   13   165  memristor PARAMS: InitStateVar=0.235313
X1332   14   165  memristor PARAMS: InitStateVar=0.19527
X1432   15   165  memristor PARAMS: InitStateVar=0.327598
X1532   16   165  memristor PARAMS: InitStateVar=0.219984
X1632   17   165  memristor PARAMS: InitStateVar=0.14254
X1732   18   165  memristor PARAMS: InitStateVar=0.299415
X1832   19   165  memristor PARAMS: InitStateVar=0.285049
X1932   20   165  memristor PARAMS: InitStateVar=0.396746
X2032   21   165  memristor PARAMS: InitStateVar=0.26739
X2132   22   165  memristor PARAMS: InitStateVar=0.266948
X2232   23   165  memristor PARAMS: InitStateVar=0.268354
X2332   24   165  memristor PARAMS: InitStateVar=0.166487
X2432   25   165  memristor PARAMS: InitStateVar=0.389539
X2532   26   165  memristor PARAMS: InitStateVar=0.197006
X2632   27   165  memristor PARAMS: InitStateVar=0.22133
X2732   28   165  memristor PARAMS: InitStateVar=0.360319
X2832   29   165  memristor PARAMS: InitStateVar=0.287699
X2932   30   165  memristor PARAMS: InitStateVar=0.253057
X3032   31   165  memristor PARAMS: InitStateVar=0.195284
X3132   32   165  memristor PARAMS: InitStateVar=0.322098
X3232   33   165  memristor PARAMS: InitStateVar=0.439289
X3332   34   165  memristor PARAMS: InitStateVar=0.44602
X3432   35   165  memristor PARAMS: InitStateVar=0.245551
X3532   36   165  memristor PARAMS: InitStateVar=0.260676
X3632   37   165  memristor PARAMS: InitStateVar=0.41119
X3732   38   165  memristor PARAMS: InitStateVar=0.393696
X3832   39   165  memristor PARAMS: InitStateVar=0.261749
X3932   40   165  memristor PARAMS: InitStateVar=0.312641
X4032   41   165  memristor PARAMS: InitStateVar=0.410822
X4132   42   165  memristor PARAMS: InitStateVar=0.284455
X4232   43   165  memristor PARAMS: InitStateVar=0.290307
X4332   44   165  memristor PARAMS: InitStateVar=0.42122
X4432   45   165  memristor PARAMS: InitStateVar=0.365
X4532   46   165  memristor PARAMS: InitStateVar=0.457852
X4632   47   165  memristor PARAMS: InitStateVar=0.282473
X4732   48   165  memristor PARAMS: InitStateVar=0.440211
X4832   49   165  memristor PARAMS: InitStateVar=0.309009
X4932   50   165  memristor PARAMS: InitStateVar=0.176226
X5032   51   165  memristor PARAMS: InitStateVar=0.372823
X5132   52   165  memristor PARAMS: InitStateVar=0.30678
X5232   53   165  memristor PARAMS: InitStateVar=0.272936
X5332   54   165  memristor PARAMS: InitStateVar=0.19772
X5432   55   165  memristor PARAMS: InitStateVar=0.226887
X5532   56   165  memristor PARAMS: InitStateVar=0.37153
X5632   57   165  memristor PARAMS: InitStateVar=0.206961
X5732   58   165  memristor PARAMS: InitStateVar=0.241087
X5832   59   165  memristor PARAMS: InitStateVar=0.241828
X5932   60   165  memristor PARAMS: InitStateVar=0.215463
X6032   61   165  memristor PARAMS: InitStateVar=0.199473
X6132   62   165  memristor PARAMS: InitStateVar=0.299064
X6232   63   165  memristor PARAMS: InitStateVar=0.256973
X6332   64   165  memristor PARAMS: InitStateVar=0.373425
X6432   65   165  memristor PARAMS: InitStateVar=0.250124
X6532   66   165  memristor PARAMS: InitStateVar=0.336255
X6632   67   165  memristor PARAMS: InitStateVar=0.429164
X6732   68   165  memristor PARAMS: InitStateVar=0.38726
X6832   69   165  memristor PARAMS: InitStateVar=0.126835
X6932   70   165  memristor PARAMS: InitStateVar=0.38822
X7032   71   165  memristor PARAMS: InitStateVar=0.294596
X7132   72   165  memristor PARAMS: InitStateVar=0.383112
X7232   73   165  memristor PARAMS: InitStateVar=0.346968
X7332   74   165  memristor PARAMS: InitStateVar=0.176598
X7432   75   165  memristor PARAMS: InitStateVar=0.330276
X7532   76   165  memristor PARAMS: InitStateVar=0.281809
X7632   77   165  memristor PARAMS: InitStateVar=0.33941
X7732   78   165  memristor PARAMS: InitStateVar=0.213578
X7832   79   165  memristor PARAMS: InitStateVar=0.196343
X7932   80   165  memristor PARAMS: InitStateVar=0.402622
X8032   81   165  memristor PARAMS: InitStateVar=0.210068
X8132   82   165  memristor PARAMS: InitStateVar=0.18565
X8232   83   165  memristor PARAMS: InitStateVar=0.232736
X8332   84   165  memristor PARAMS: InitStateVar=0.237396
X8432   85   165  memristor PARAMS: InitStateVar=0.213601
X8532   86   165  memristor PARAMS: InitStateVar=0.436547
X8632   87   165  memristor PARAMS: InitStateVar=0.463579
X8732   88   165  memristor PARAMS: InitStateVar=0.162208
X8832   89   165  memristor PARAMS: InitStateVar=0.154885
X8932   90   165  memristor PARAMS: InitStateVar=0.301895
X9032   91   165  memristor PARAMS: InitStateVar=0.479329
X9132   92   165  memristor PARAMS: InitStateVar=0.150443
X9232   93   165  memristor PARAMS: InitStateVar=0.443594
X9332   94   165  memristor PARAMS: InitStateVar=0.326454
X9432   95   165  memristor PARAMS: InitStateVar=0.277904
X9532   96   165  memristor PARAMS: InitStateVar=0.377701
X9632   97   165  memristor PARAMS: InitStateVar=0.544769
X9732   98   165  memristor PARAMS: InitStateVar=0.226089
X9832   99   165  memristor PARAMS: InitStateVar=0.220817
X9932   100  165  memristor PARAMS: InitStateVar=0.378505
Xo33    165  166  OutputModule PARAMS: Rval=100
*------------------- Column 34 -------------------------------------------------
X33     1    167  memristor PARAMS: InitStateVar=0.237948
X133    2    167  memristor PARAMS: InitStateVar=0.145255
X233    3    167  memristor PARAMS: InitStateVar=0.41366
X333    4    167  memristor PARAMS: InitStateVar=0.294698
X433    5    167  memristor PARAMS: InitStateVar=0.248589
X533    6    167  memristor PARAMS: InitStateVar=0.286137
X633    7    167  memristor PARAMS: InitStateVar=0.166982
X733    8    167  memristor PARAMS: InitStateVar=0.356345
X833    9    167  memristor PARAMS: InitStateVar=0.351036
X933    10   167  memristor PARAMS: InitStateVar=0.458627
X1033   11   167  memristor PARAMS: InitStateVar=0.307239
X1133   12   167  memristor PARAMS: InitStateVar=0.248975
X1233   13   167  memristor PARAMS: InitStateVar=0.377349
X1333   14   167  memristor PARAMS: InitStateVar=0.456929
X1433   15   167  memristor PARAMS: InitStateVar=0.353644
X1533   16   167  memristor PARAMS: InitStateVar=0.380852
X1633   17   167  memristor PARAMS: InitStateVar=0.189684
X1733   18   167  memristor PARAMS: InitStateVar=0.359831
X1833   19   167  memristor PARAMS: InitStateVar=0.354049
X1933   20   167  memristor PARAMS: InitStateVar=0.440628
X2033   21   167  memristor PARAMS: InitStateVar=0.25477
X2133   22   167  memristor PARAMS: InitStateVar=0.176013
X2233   23   167  memristor PARAMS: InitStateVar=0.352192
X2333   24   167  memristor PARAMS: InitStateVar=0.284898
X2433   25   167  memristor PARAMS: InitStateVar=0.277753
X2533   26   167  memristor PARAMS: InitStateVar=0.304377
X2633   27   167  memristor PARAMS: InitStateVar=0.300437
X2733   28   167  memristor PARAMS: InitStateVar=0.233301
X2833   29   167  memristor PARAMS: InitStateVar=0.32214
X2933   30   167  memristor PARAMS: InitStateVar=0.183382
X3033   31   167  memristor PARAMS: InitStateVar=0.230484
X3133   32   167  memristor PARAMS: InitStateVar=0.454411
X3233   33   167  memristor PARAMS: InitStateVar=0.293802
X3333   34   167  memristor PARAMS: InitStateVar=0.303033
X3433   35   167  memristor PARAMS: InitStateVar=0.447356
X3533   36   167  memristor PARAMS: InitStateVar=0.366867
X3633   37   167  memristor PARAMS: InitStateVar=0.163288
X3733   38   167  memristor PARAMS: InitStateVar=0.217178
X3833   39   167  memristor PARAMS: InitStateVar=0.305504
X3933   40   167  memristor PARAMS: InitStateVar=0.259157
X4033   41   167  memristor PARAMS: InitStateVar=0.31897
X4133   42   167  memristor PARAMS: InitStateVar=0.257716
X4233   43   167  memristor PARAMS: InitStateVar=0.231529
X4333   44   167  memristor PARAMS: InitStateVar=0.352977
X4433   45   167  memristor PARAMS: InitStateVar=0.291209
X4533   46   167  memristor PARAMS: InitStateVar=0.264567
X4633   47   167  memristor PARAMS: InitStateVar=0.509925
X4733   48   167  memristor PARAMS: InitStateVar=0.37407
X4833   49   167  memristor PARAMS: InitStateVar=0.324896
X4933   50   167  memristor PARAMS: InitStateVar=0.234483
X5033   51   167  memristor PARAMS: InitStateVar=0.298197
X5133   52   167  memristor PARAMS: InitStateVar=0.359303
X5233   53   167  memristor PARAMS: InitStateVar=0.51524
X5333   54   167  memristor PARAMS: InitStateVar=0.292948
X5433   55   167  memristor PARAMS: InitStateVar=0.206711
X5533   56   167  memristor PARAMS: InitStateVar=0.439657
X5633   57   167  memristor PARAMS: InitStateVar=0.438768
X5733   58   167  memristor PARAMS: InitStateVar=0.215191
X5833   59   167  memristor PARAMS: InitStateVar=0.145391
X5933   60   167  memristor PARAMS: InitStateVar=0.254996
X6033   61   167  memristor PARAMS: InitStateVar=0.277475
X6133   62   167  memristor PARAMS: InitStateVar=0.270711
X6233   63   167  memristor PARAMS: InitStateVar=0.358969
X6333   64   167  memristor PARAMS: InitStateVar=0.421559
X6433   65   167  memristor PARAMS: InitStateVar=0.169706
X6533   66   167  memristor PARAMS: InitStateVar=0.312635
X6633   67   167  memristor PARAMS: InitStateVar=0.098463
X6733   68   167  memristor PARAMS: InitStateVar=0.393703
X6833   69   167  memristor PARAMS: InitStateVar=0.113184
X6933   70   167  memristor PARAMS: InitStateVar=0.39291
X7033   71   167  memristor PARAMS: InitStateVar=0.0983617
X7133   72   167  memristor PARAMS: InitStateVar=0.194956
X7233   73   167  memristor PARAMS: InitStateVar=0.28835
X7333   74   167  memristor PARAMS: InitStateVar=0.374082
X7433   75   167  memristor PARAMS: InitStateVar=0.322103
X7533   76   167  memristor PARAMS: InitStateVar=0.199959
X7633   77   167  memristor PARAMS: InitStateVar=0.222844
X7733   78   167  memristor PARAMS: InitStateVar=0.365057
X7833   79   167  memristor PARAMS: InitStateVar=0.381361
X7933   80   167  memristor PARAMS: InitStateVar=0.256292
X8033   81   167  memristor PARAMS: InitStateVar=0.324083
X8133   82   167  memristor PARAMS: InitStateVar=0.171727
X8233   83   167  memristor PARAMS: InitStateVar=0.178986
X8333   84   167  memristor PARAMS: InitStateVar=0.239681
X8433   85   167  memristor PARAMS: InitStateVar=0.353125
X8533   86   167  memristor PARAMS: InitStateVar=0.384338
X8633   87   167  memristor PARAMS: InitStateVar=0.331647
X8733   88   167  memristor PARAMS: InitStateVar=0.297895
X8833   89   167  memristor PARAMS: InitStateVar=0.239165
X8933   90   167  memristor PARAMS: InitStateVar=0.0921928
X9033   91   167  memristor PARAMS: InitStateVar=0.0741739
X9133   92   167  memristor PARAMS: InitStateVar=0.386981
X9233   93   167  memristor PARAMS: InitStateVar=0.561686
X9333   94   167  memristor PARAMS: InitStateVar=0.497466
X9433   95   167  memristor PARAMS: InitStateVar=0.380487
X9533   96   167  memristor PARAMS: InitStateVar=0.348292
X9633   97   167  memristor PARAMS: InitStateVar=0.501955
X9733   98   167  memristor PARAMS: InitStateVar=0.346503
X9833   99   167  memristor PARAMS: InitStateVar=0.390526
X9933   100  167  memristor PARAMS: InitStateVar=0.295556
Xo34    167  168  OutputModule PARAMS: Rval=100
*------------------- Column 35 -------------------------------------------------
X34     1    169  memristor PARAMS: InitStateVar=0.335992
X134    2    169  memristor PARAMS: InitStateVar=0.0927756
X234    3    169  memristor PARAMS: InitStateVar=0.1848
X334    4    169  memristor PARAMS: InitStateVar=0.230163
X434    5    169  memristor PARAMS: InitStateVar=0.186673
X534    6    169  memristor PARAMS: InitStateVar=0.245548
X634    7    169  memristor PARAMS: InitStateVar=0.278011
X734    8    169  memristor PARAMS: InitStateVar=0.312717
X834    9    169  memristor PARAMS: InitStateVar=0.290282
X934    10   169  memristor PARAMS: InitStateVar=0.319683
X1034   11   169  memristor PARAMS: InitStateVar=0.424126
X1134   12   169  memristor PARAMS: InitStateVar=0.369938
X1234   13   169  memristor PARAMS: InitStateVar=0.202939
X1334   14   169  memristor PARAMS: InitStateVar=0.130516
X1434   15   169  memristor PARAMS: InitStateVar=0.528395
X1534   16   169  memristor PARAMS: InitStateVar=0.250279
X1634   17   169  memristor PARAMS: InitStateVar=0.27085
X1734   18   169  memristor PARAMS: InitStateVar=0.388602
X1834   19   169  memristor PARAMS: InitStateVar=0.320629
X1934   20   169  memristor PARAMS: InitStateVar=0.387736
X2034   21   169  memristor PARAMS: InitStateVar=0.206423
X2134   22   169  memristor PARAMS: InitStateVar=0.243799
X2234   23   169  memristor PARAMS: InitStateVar=0.26199
X2334   24   169  memristor PARAMS: InitStateVar=0.304697
X2434   25   169  memristor PARAMS: InitStateVar=0.2219
X2534   26   169  memristor PARAMS: InitStateVar=0.375817
X2634   27   169  memristor PARAMS: InitStateVar=0.340125
X2734   28   169  memristor PARAMS: InitStateVar=0.403444
X2834   29   169  memristor PARAMS: InitStateVar=0.361042
X2934   30   169  memristor PARAMS: InitStateVar=0.295367
X3034   31   169  memristor PARAMS: InitStateVar=0.321087
X3134   32   169  memristor PARAMS: InitStateVar=0.0513854
X3234   33   169  memristor PARAMS: InitStateVar=0.236077
X3334   34   169  memristor PARAMS: InitStateVar=0.156896
X3434   35   169  memristor PARAMS: InitStateVar=0.221101
X3534   36   169  memristor PARAMS: InitStateVar=0.384054
X3634   37   169  memristor PARAMS: InitStateVar=0.325538
X3734   38   169  memristor PARAMS: InitStateVar=0.245707
X3834   39   169  memristor PARAMS: InitStateVar=-0.0193079
X3934   40   169  memristor PARAMS: InitStateVar=0.352255
X4034   41   169  memristor PARAMS: InitStateVar=0.339705
X4134   42   169  memristor PARAMS: InitStateVar=0.514969
X4234   43   169  memristor PARAMS: InitStateVar=0.221781
X4334   44   169  memristor PARAMS: InitStateVar=0.36936
X4434   45   169  memristor PARAMS: InitStateVar=0.267861
X4534   46   169  memristor PARAMS: InitStateVar=0.17542
X4634   47   169  memristor PARAMS: InitStateVar=0.364522
X4734   48   169  memristor PARAMS: InitStateVar=0.252948
X4834   49   169  memristor PARAMS: InitStateVar=0.339726
X4934   50   169  memristor PARAMS: InitStateVar=0.510681
X5034   51   169  memristor PARAMS: InitStateVar=0.146881
X5134   52   169  memristor PARAMS: InitStateVar=0.269727
X5234   53   169  memristor PARAMS: InitStateVar=0.218236
X5334   54   169  memristor PARAMS: InitStateVar=0.195706
X5434   55   169  memristor PARAMS: InitStateVar=0.181122
X5534   56   169  memristor PARAMS: InitStateVar=0.312727
X5634   57   169  memristor PARAMS: InitStateVar=0.394666
X5734   58   169  memristor PARAMS: InitStateVar=0.131767
X5834   59   169  memristor PARAMS: InitStateVar=0.366565
X5934   60   169  memristor PARAMS: InitStateVar=0.371072
X6034   61   169  memristor PARAMS: InitStateVar=0.407137
X6134   62   169  memristor PARAMS: InitStateVar=0.195908
X6234   63   169  memristor PARAMS: InitStateVar=0.466333
X6334   64   169  memristor PARAMS: InitStateVar=0.292096
X6434   65   169  memristor PARAMS: InitStateVar=0.198129
X6534   66   169  memristor PARAMS: InitStateVar=0.439915
X6634   67   169  memristor PARAMS: InitStateVar=0.348342
X6734   68   169  memristor PARAMS: InitStateVar=0.381816
X6834   69   169  memristor PARAMS: InitStateVar=0.358789
X6934   70   169  memristor PARAMS: InitStateVar=0.360735
X7034   71   169  memristor PARAMS: InitStateVar=0.367761
X7134   72   169  memristor PARAMS: InitStateVar=0.379504
X7234   73   169  memristor PARAMS: InitStateVar=0.444946
X7334   74   169  memristor PARAMS: InitStateVar=0.15713
X7434   75   169  memristor PARAMS: InitStateVar=0.298856
X7534   76   169  memristor PARAMS: InitStateVar=0.328091
X7634   77   169  memristor PARAMS: InitStateVar=0.131584
X7734   78   169  memristor PARAMS: InitStateVar=0.261767
X7834   79   169  memristor PARAMS: InitStateVar=0.24153
X7934   80   169  memristor PARAMS: InitStateVar=0.201538
X8034   81   169  memristor PARAMS: InitStateVar=0.317287
X8134   82   169  memristor PARAMS: InitStateVar=0.302837
X8234   83   169  memristor PARAMS: InitStateVar=0.278409
X8334   84   169  memristor PARAMS: InitStateVar=0.364353
X8434   85   169  memristor PARAMS: InitStateVar=0.266272
X8534   86   169  memristor PARAMS: InitStateVar=0.245158
X8634   87   169  memristor PARAMS: InitStateVar=0.240547
X8734   88   169  memristor PARAMS: InitStateVar=0.315585
X8834   89   169  memristor PARAMS: InitStateVar=0.250976
X8934   90   169  memristor PARAMS: InitStateVar=0.288815
X9034   91   169  memristor PARAMS: InitStateVar=0.191897
X9134   92   169  memristor PARAMS: InitStateVar=0.167583
X9234   93   169  memristor PARAMS: InitStateVar=0.162908
X9334   94   169  memristor PARAMS: InitStateVar=0.428231
X9434   95   169  memristor PARAMS: InitStateVar=0.256214
X9534   96   169  memristor PARAMS: InitStateVar=0.43369
X9634   97   169  memristor PARAMS: InitStateVar=0.332189
X9734   98   169  memristor PARAMS: InitStateVar=0.368468
X9834   99   169  memristor PARAMS: InitStateVar=0.172789
X9934   100  169  memristor PARAMS: InitStateVar=0.278881
Xo35    169  170  OutputModule PARAMS: Rval=100
*------------------- Column 36 -------------------------------------------------
X35     1    171  memristor PARAMS: InitStateVar=0.393118
X135    2    171  memristor PARAMS: InitStateVar=0.445072
X235    3    171  memristor PARAMS: InitStateVar=0.45383
X335    4    171  memristor PARAMS: InitStateVar=0.363003
X435    5    171  memristor PARAMS: InitStateVar=0.323798
X535    6    171  memristor PARAMS: InitStateVar=0.142719
X635    7    171  memristor PARAMS: InitStateVar=0.417954
X735    8    171  memristor PARAMS: InitStateVar=0.142038
X835    9    171  memristor PARAMS: InitStateVar=0.335899
X935    10   171  memristor PARAMS: InitStateVar=0.239837
X1035   11   171  memristor PARAMS: InitStateVar=0.26999
X1135   12   171  memristor PARAMS: InitStateVar=0.231195
X1235   13   171  memristor PARAMS: InitStateVar=0.226729
X1335   14   171  memristor PARAMS: InitStateVar=0.411873
X1435   15   171  memristor PARAMS: InitStateVar=0.287751
X1535   16   171  memristor PARAMS: InitStateVar=0.325211
X1635   17   171  memristor PARAMS: InitStateVar=0.320771
X1735   18   171  memristor PARAMS: InitStateVar=0.408115
X1835   19   171  memristor PARAMS: InitStateVar=0.210503
X1935   20   171  memristor PARAMS: InitStateVar=0.414913
X2035   21   171  memristor PARAMS: InitStateVar=0.294358
X2135   22   171  memristor PARAMS: InitStateVar=0.263392
X2235   23   171  memristor PARAMS: InitStateVar=0.575383
X2335   24   171  memristor PARAMS: InitStateVar=0.335904
X2435   25   171  memristor PARAMS: InitStateVar=0.156182
X2535   26   171  memristor PARAMS: InitStateVar=0.352774
X2635   27   171  memristor PARAMS: InitStateVar=0.333447
X2735   28   171  memristor PARAMS: InitStateVar=0.373635
X2835   29   171  memristor PARAMS: InitStateVar=0.374396
X2935   30   171  memristor PARAMS: InitStateVar=0.212687
X3035   31   171  memristor PARAMS: InitStateVar=0.271662
X3135   32   171  memristor PARAMS: InitStateVar=0.297129
X3235   33   171  memristor PARAMS: InitStateVar=0.437985
X3335   34   171  memristor PARAMS: InitStateVar=0.341659
X3435   35   171  memristor PARAMS: InitStateVar=0.317184
X3535   36   171  memristor PARAMS: InitStateVar=0.335408
X3635   37   171  memristor PARAMS: InitStateVar=0.365276
X3735   38   171  memristor PARAMS: InitStateVar=0.408162
X3835   39   171  memristor PARAMS: InitStateVar=0.419231
X3935   40   171  memristor PARAMS: InitStateVar=0.234198
X4035   41   171  memristor PARAMS: InitStateVar=0.269302
X4135   42   171  memristor PARAMS: InitStateVar=0.337799
X4235   43   171  memristor PARAMS: InitStateVar=0.407791
X4335   44   171  memristor PARAMS: InitStateVar=0.385256
X4435   45   171  memristor PARAMS: InitStateVar=0.125675
X4535   46   171  memristor PARAMS: InitStateVar=0.361465
X4635   47   171  memristor PARAMS: InitStateVar=0.264936
X4735   48   171  memristor PARAMS: InitStateVar=0.046827
X4835   49   171  memristor PARAMS: InitStateVar=0.278381
X4935   50   171  memristor PARAMS: InitStateVar=0.277558
X5035   51   171  memristor PARAMS: InitStateVar=0.0960574
X5135   52   171  memristor PARAMS: InitStateVar=0.396749
X5235   53   171  memristor PARAMS: InitStateVar=0.239606
X5335   54   171  memristor PARAMS: InitStateVar=0.331717
X5435   55   171  memristor PARAMS: InitStateVar=0.315111
X5535   56   171  memristor PARAMS: InitStateVar=0.257706
X5635   57   171  memristor PARAMS: InitStateVar=0.275019
X5735   58   171  memristor PARAMS: InitStateVar=0.306939
X5835   59   171  memristor PARAMS: InitStateVar=0.393955
X5935   60   171  memristor PARAMS: InitStateVar=0.491279
X6035   61   171  memristor PARAMS: InitStateVar=0.292978
X6135   62   171  memristor PARAMS: InitStateVar=0.117401
X6235   63   171  memristor PARAMS: InitStateVar=0.360657
X6335   64   171  memristor PARAMS: InitStateVar=0.122788
X6435   65   171  memristor PARAMS: InitStateVar=0.299341
X6535   66   171  memristor PARAMS: InitStateVar=0.218048
X6635   67   171  memristor PARAMS: InitStateVar=0.157291
X6735   68   171  memristor PARAMS: InitStateVar=0.179867
X6835   69   171  memristor PARAMS: InitStateVar=0.144333
X6935   70   171  memristor PARAMS: InitStateVar=0.283959
X7035   71   171  memristor PARAMS: InitStateVar=0.263156
X7135   72   171  memristor PARAMS: InitStateVar=0.309132
X7235   73   171  memristor PARAMS: InitStateVar=0.291107
X7335   74   171  memristor PARAMS: InitStateVar=0.272159
X7435   75   171  memristor PARAMS: InitStateVar=0.423276
X7535   76   171  memristor PARAMS: InitStateVar=0.194211
X7635   77   171  memristor PARAMS: InitStateVar=0.276169
X7735   78   171  memristor PARAMS: InitStateVar=0.442529
X7835   79   171  memristor PARAMS: InitStateVar=0.241914
X7935   80   171  memristor PARAMS: InitStateVar=0.352516
X8035   81   171  memristor PARAMS: InitStateVar=0.296823
X8135   82   171  memristor PARAMS: InitStateVar=0.27014
X8235   83   171  memristor PARAMS: InitStateVar=0.396138
X8335   84   171  memristor PARAMS: InitStateVar=0.386717
X8435   85   171  memristor PARAMS: InitStateVar=0.428769
X8535   86   171  memristor PARAMS: InitStateVar=0.259353
X8635   87   171  memristor PARAMS: InitStateVar=0.405826
X8735   88   171  memristor PARAMS: InitStateVar=0.342302
X8835   89   171  memristor PARAMS: InitStateVar=0.260372
X8935   90   171  memristor PARAMS: InitStateVar=0.287617
X9035   91   171  memristor PARAMS: InitStateVar=0.556477
X9135   92   171  memristor PARAMS: InitStateVar=0.20267
X9235   93   171  memristor PARAMS: InitStateVar=0.275495
X9335   94   171  memristor PARAMS: InitStateVar=0.368349
X9435   95   171  memristor PARAMS: InitStateVar=0.265002
X9535   96   171  memristor PARAMS: InitStateVar=0.305045
X9635   97   171  memristor PARAMS: InitStateVar=0.164398
X9735   98   171  memristor PARAMS: InitStateVar=0.210723
X9835   99   171  memristor PARAMS: InitStateVar=0.38758
X9935   100  171  memristor PARAMS: InitStateVar=0.463609
Xo36    171  172  OutputModule PARAMS: Rval=100
*------------------- Column 37 -------------------------------------------------
X36     1    173  memristor PARAMS: InitStateVar=0.414771
X136    2    173  memristor PARAMS: InitStateVar=0.368097
X236    3    173  memristor PARAMS: InitStateVar=0.213222
X336    4    173  memristor PARAMS: InitStateVar=0.384412
X436    5    173  memristor PARAMS: InitStateVar=0.148787
X536    6    173  memristor PARAMS: InitStateVar=0.557402
X636    7    173  memristor PARAMS: InitStateVar=0.16019
X736    8    173  memristor PARAMS: InitStateVar=0.232362
X836    9    173  memristor PARAMS: InitStateVar=0.316402
X936    10   173  memristor PARAMS: InitStateVar=0.442096
X1036   11   173  memristor PARAMS: InitStateVar=0.482946
X1136   12   173  memristor PARAMS: InitStateVar=0.339481
X1236   13   173  memristor PARAMS: InitStateVar=0.519305
X1336   14   173  memristor PARAMS: InitStateVar=0.157619
X1436   15   173  memristor PARAMS: InitStateVar=0.339961
X1536   16   173  memristor PARAMS: InitStateVar=0.121258
X1636   17   173  memristor PARAMS: InitStateVar=0.383571
X1736   18   173  memristor PARAMS: InitStateVar=0.339921
X1836   19   173  memristor PARAMS: InitStateVar=0.198408
X1936   20   173  memristor PARAMS: InitStateVar=0.301221
X2036   21   173  memristor PARAMS: InitStateVar=0.369151
X2136   22   173  memristor PARAMS: InitStateVar=0.153297
X2236   23   173  memristor PARAMS: InitStateVar=0.382775
X2336   24   173  memristor PARAMS: InitStateVar=0.132574
X2436   25   173  memristor PARAMS: InitStateVar=0.328352
X2536   26   173  memristor PARAMS: InitStateVar=0.287726
X2636   27   173  memristor PARAMS: InitStateVar=0.438161
X2736   28   173  memristor PARAMS: InitStateVar=0.390316
X2836   29   173  memristor PARAMS: InitStateVar=0.258222
X2936   30   173  memristor PARAMS: InitStateVar=0.398556
X3036   31   173  memristor PARAMS: InitStateVar=0.226713
X3136   32   173  memristor PARAMS: InitStateVar=0.216572
X3236   33   173  memristor PARAMS: InitStateVar=0.262058
X3336   34   173  memristor PARAMS: InitStateVar=0.305673
X3436   35   173  memristor PARAMS: InitStateVar=0.0689505
X3536   36   173  memristor PARAMS: InitStateVar=0.273275
X3636   37   173  memristor PARAMS: InitStateVar=0.336075
X3736   38   173  memristor PARAMS: InitStateVar=0.430552
X3836   39   173  memristor PARAMS: InitStateVar=0.253089
X3936   40   173  memristor PARAMS: InitStateVar=0.29617
X4036   41   173  memristor PARAMS: InitStateVar=0.417626
X4136   42   173  memristor PARAMS: InitStateVar=0.322781
X4236   43   173  memristor PARAMS: InitStateVar=0.417882
X4336   44   173  memristor PARAMS: InitStateVar=0.403114
X4436   45   173  memristor PARAMS: InitStateVar=0.163387
X4536   46   173  memristor PARAMS: InitStateVar=0.269253
X4636   47   173  memristor PARAMS: InitStateVar=0.371402
X4736   48   173  memristor PARAMS: InitStateVar=0.428042
X4836   49   173  memristor PARAMS: InitStateVar=0.289031
X4936   50   173  memristor PARAMS: InitStateVar=0.281683
X5036   51   173  memristor PARAMS: InitStateVar=0.184739
X5136   52   173  memristor PARAMS: InitStateVar=0.479245
X5236   53   173  memristor PARAMS: InitStateVar=0.277622
X5336   54   173  memristor PARAMS: InitStateVar=0.458531
X5436   55   173  memristor PARAMS: InitStateVar=0.289567
X5536   56   173  memristor PARAMS: InitStateVar=0.41075
X5636   57   173  memristor PARAMS: InitStateVar=0.280356
X5736   58   173  memristor PARAMS: InitStateVar=0.342227
X5836   59   173  memristor PARAMS: InitStateVar=0.412434
X5936   60   173  memristor PARAMS: InitStateVar=0.116429
X6036   61   173  memristor PARAMS: InitStateVar=0.138821
X6136   62   173  memristor PARAMS: InitStateVar=0.212831
X6236   63   173  memristor PARAMS: InitStateVar=0.239078
X6336   64   173  memristor PARAMS: InitStateVar=0.127537
X6436   65   173  memristor PARAMS: InitStateVar=0.451206
X6536   66   173  memristor PARAMS: InitStateVar=0.417718
X6636   67   173  memristor PARAMS: InitStateVar=0.258109
X6736   68   173  memristor PARAMS: InitStateVar=0.344796
X6836   69   173  memristor PARAMS: InitStateVar=0.253985
X6936   70   173  memristor PARAMS: InitStateVar=0.181366
X7036   71   173  memristor PARAMS: InitStateVar=0.294836
X7136   72   173  memristor PARAMS: InitStateVar=0.281968
X7236   73   173  memristor PARAMS: InitStateVar=0.334577
X7336   74   173  memristor PARAMS: InitStateVar=0.309311
X7436   75   173  memristor PARAMS: InitStateVar=0.300879
X7536   76   173  memristor PARAMS: InitStateVar=0.117988
X7636   77   173  memristor PARAMS: InitStateVar=0.237665
X7736   78   173  memristor PARAMS: InitStateVar=0.371373
X7836   79   173  memristor PARAMS: InitStateVar=0.277527
X7936   80   173  memristor PARAMS: InitStateVar=0.252401
X8036   81   173  memristor PARAMS: InitStateVar=0.239214
X8136   82   173  memristor PARAMS: InitStateVar=0.284447
X8236   83   173  memristor PARAMS: InitStateVar=0.217394
X8336   84   173  memristor PARAMS: InitStateVar=0.413023
X8436   85   173  memristor PARAMS: InitStateVar=0.227827
X8536   86   173  memristor PARAMS: InitStateVar=0.444604
X8636   87   173  memristor PARAMS: InitStateVar=0.298841
X8736   88   173  memristor PARAMS: InitStateVar=0.430744
X8836   89   173  memristor PARAMS: InitStateVar=0.319813
X8936   90   173  memristor PARAMS: InitStateVar=0.387114
X9036   91   173  memristor PARAMS: InitStateVar=0.314777
X9136   92   173  memristor PARAMS: InitStateVar=0.254474
X9236   93   173  memristor PARAMS: InitStateVar=0.307801
X9336   94   173  memristor PARAMS: InitStateVar=0.30321
X9436   95   173  memristor PARAMS: InitStateVar=0.412497
X9536   96   173  memristor PARAMS: InitStateVar=0.375252
X9636   97   173  memristor PARAMS: InitStateVar=0.296141
X9736   98   173  memristor PARAMS: InitStateVar=0.278072
X9836   99   173  memristor PARAMS: InitStateVar=0.372131
X9936   100  173  memristor PARAMS: InitStateVar=0.423317
Xo37    173  174  OutputModule PARAMS: Rval=100
*------------------- Column 38 -------------------------------------------------
X37     1    175  memristor PARAMS: InitStateVar=0.365998
X137    2    175  memristor PARAMS: InitStateVar=0.504935
X237    3    175  memristor PARAMS: InitStateVar=0.120482
X337    4    175  memristor PARAMS: InitStateVar=0.273671
X437    5    175  memristor PARAMS: InitStateVar=0.291758
X537    6    175  memristor PARAMS: InitStateVar=0.185526
X637    7    175  memristor PARAMS: InitStateVar=0.288681
X737    8    175  memristor PARAMS: InitStateVar=0.342654
X837    9    175  memristor PARAMS: InitStateVar=0.231937
X937    10   175  memristor PARAMS: InitStateVar=0.48516
X1037   11   175  memristor PARAMS: InitStateVar=0.295197
X1137   12   175  memristor PARAMS: InitStateVar=0.360309
X1237   13   175  memristor PARAMS: InitStateVar=0.25484
X1337   14   175  memristor PARAMS: InitStateVar=0.283932
X1437   15   175  memristor PARAMS: InitStateVar=0.124072
X1537   16   175  memristor PARAMS: InitStateVar=0.222477
X1637   17   175  memristor PARAMS: InitStateVar=0.306172
X1737   18   175  memristor PARAMS: InitStateVar=0.241103
X1837   19   175  memristor PARAMS: InitStateVar=0.348157
X1937   20   175  memristor PARAMS: InitStateVar=0.178103
X2037   21   175  memristor PARAMS: InitStateVar=0.373395
X2137   22   175  memristor PARAMS: InitStateVar=0.331158
X2237   23   175  memristor PARAMS: InitStateVar=0.426373
X2337   24   175  memristor PARAMS: InitStateVar=0.186803
X2437   25   175  memristor PARAMS: InitStateVar=0.302593
X2537   26   175  memristor PARAMS: InitStateVar=0.38433
X2637   27   175  memristor PARAMS: InitStateVar=0.0909577
X2737   28   175  memristor PARAMS: InitStateVar=0.284143
X2837   29   175  memristor PARAMS: InitStateVar=0.216509
X2937   30   175  memristor PARAMS: InitStateVar=0.379288
X3037   31   175  memristor PARAMS: InitStateVar=0.474152
X3137   32   175  memristor PARAMS: InitStateVar=0.381707
X3237   33   175  memristor PARAMS: InitStateVar=0.540864
X3337   34   175  memristor PARAMS: InitStateVar=0.40554
X3437   35   175  memristor PARAMS: InitStateVar=0.323452
X3537   36   175  memristor PARAMS: InitStateVar=0.215562
X3637   37   175  memristor PARAMS: InitStateVar=0.339559
X3737   38   175  memristor PARAMS: InitStateVar=0.20289
X3837   39   175  memristor PARAMS: InitStateVar=0.216224
X3937   40   175  memristor PARAMS: InitStateVar=0.0949669
X4037   41   175  memristor PARAMS: InitStateVar=0.281846
X4137   42   175  memristor PARAMS: InitStateVar=0.254077
X4237   43   175  memristor PARAMS: InitStateVar=0.218971
X4337   44   175  memristor PARAMS: InitStateVar=0.35779
X4437   45   175  memristor PARAMS: InitStateVar=0.267217
X4537   46   175  memristor PARAMS: InitStateVar=0.197691
X4637   47   175  memristor PARAMS: InitStateVar=0.0893358
X4737   48   175  memristor PARAMS: InitStateVar=0.371404
X4837   49   175  memristor PARAMS: InitStateVar=0.331346
X4937   50   175  memristor PARAMS: InitStateVar=0.204639
X5037   51   175  memristor PARAMS: InitStateVar=0.344433
X5137   52   175  memristor PARAMS: InitStateVar=0.319076
X5237   53   175  memristor PARAMS: InitStateVar=0.424937
X5337   54   175  memristor PARAMS: InitStateVar=0.428646
X5437   55   175  memristor PARAMS: InitStateVar=0.332355
X5537   56   175  memristor PARAMS: InitStateVar=0.460468
X5637   57   175  memristor PARAMS: InitStateVar=0.302856
X5737   58   175  memristor PARAMS: InitStateVar=0.11971
X5837   59   175  memristor PARAMS: InitStateVar=0.425284
X5937   60   175  memristor PARAMS: InitStateVar=0.296117
X6037   61   175  memristor PARAMS: InitStateVar=0.499152
X6137   62   175  memristor PARAMS: InitStateVar=0.250708
X6237   63   175  memristor PARAMS: InitStateVar=0.295164
X6337   64   175  memristor PARAMS: InitStateVar=0.0788825
X6437   65   175  memristor PARAMS: InitStateVar=0.193112
X6537   66   175  memristor PARAMS: InitStateVar=0.385774
X6637   67   175  memristor PARAMS: InitStateVar=0.403698
X6737   68   175  memristor PARAMS: InitStateVar=0.40925
X6837   69   175  memristor PARAMS: InitStateVar=0.204591
X6937   70   175  memristor PARAMS: InitStateVar=0.403051
X7037   71   175  memristor PARAMS: InitStateVar=0.144896
X7137   72   175  memristor PARAMS: InitStateVar=0.0338786
X7237   73   175  memristor PARAMS: InitStateVar=0.20188
X7337   74   175  memristor PARAMS: InitStateVar=0.269863
X7437   75   175  memristor PARAMS: InitStateVar=0.394967
X7537   76   175  memristor PARAMS: InitStateVar=0.275679
X7637   77   175  memristor PARAMS: InitStateVar=0.285704
X7737   78   175  memristor PARAMS: InitStateVar=0.327638
X7837   79   175  memristor PARAMS: InitStateVar=0.34248
X7937   80   175  memristor PARAMS: InitStateVar=0.210874
X8037   81   175  memristor PARAMS: InitStateVar=0.327528
X8137   82   175  memristor PARAMS: InitStateVar=0.360339
X8237   83   175  memristor PARAMS: InitStateVar=0.237719
X8337   84   175  memristor PARAMS: InitStateVar=0.210442
X8437   85   175  memristor PARAMS: InitStateVar=0.19738
X8537   86   175  memristor PARAMS: InitStateVar=0.261989
X8637   87   175  memristor PARAMS: InitStateVar=0.500008
X8737   88   175  memristor PARAMS: InitStateVar=0.302472
X8837   89   175  memristor PARAMS: InitStateVar=0.242114
X8937   90   175  memristor PARAMS: InitStateVar=0.283647
X9037   91   175  memristor PARAMS: InitStateVar=0.247495
X9137   92   175  memristor PARAMS: InitStateVar=0.223973
X9237   93   175  memristor PARAMS: InitStateVar=0.27324
X9337   94   175  memristor PARAMS: InitStateVar=0.138293
X9437   95   175  memristor PARAMS: InitStateVar=0.282648
X9537   96   175  memristor PARAMS: InitStateVar=0.163617
X9637   97   175  memristor PARAMS: InitStateVar=0.278715
X9737   98   175  memristor PARAMS: InitStateVar=0.41132
X9837   99   175  memristor PARAMS: InitStateVar=0.241631
X9937   100  175  memristor PARAMS: InitStateVar=0.14648
Xo38    175  176  OutputModule PARAMS: Rval=100
*------------------- Column 39 -------------------------------------------------
X38     1    177  memristor PARAMS: InitStateVar=0.455816
X138    2    177  memristor PARAMS: InitStateVar=0.298345
X238    3    177  memristor PARAMS: InitStateVar=0.380849
X338    4    177  memristor PARAMS: InitStateVar=0.32865
X438    5    177  memristor PARAMS: InitStateVar=0.179964
X538    6    177  memristor PARAMS: InitStateVar=0.29438
X638    7    177  memristor PARAMS: InitStateVar=0.206174
X738    8    177  memristor PARAMS: InitStateVar=0.180632
X838    9    177  memristor PARAMS: InitStateVar=0.196718
X938    10   177  memristor PARAMS: InitStateVar=0.260341
X1038   11   177  memristor PARAMS: InitStateVar=0.189606
X1138   12   177  memristor PARAMS: InitStateVar=0.303763
X1238   13   177  memristor PARAMS: InitStateVar=0.264099
X1338   14   177  memristor PARAMS: InitStateVar=0.3651
X1438   15   177  memristor PARAMS: InitStateVar=0.297141
X1538   16   177  memristor PARAMS: InitStateVar=0.306012
X1638   17   177  memristor PARAMS: InitStateVar=0.42916
X1738   18   177  memristor PARAMS: InitStateVar=0.291326
X1838   19   177  memristor PARAMS: InitStateVar=0.320282
X1938   20   177  memristor PARAMS: InitStateVar=0.516016
X2038   21   177  memristor PARAMS: InitStateVar=0.419764
X2138   22   177  memristor PARAMS: InitStateVar=0.169067
X2238   23   177  memristor PARAMS: InitStateVar=0.172422
X2338   24   177  memristor PARAMS: InitStateVar=0.245724
X2438   25   177  memristor PARAMS: InitStateVar=0.512969
X2538   26   177  memristor PARAMS: InitStateVar=0.345154
X2638   27   177  memristor PARAMS: InitStateVar=0.284807
X2738   28   177  memristor PARAMS: InitStateVar=0.286805
X2838   29   177  memristor PARAMS: InitStateVar=0.393216
X2938   30   177  memristor PARAMS: InitStateVar=0.453906
X3038   31   177  memristor PARAMS: InitStateVar=0.143028
X3138   32   177  memristor PARAMS: InitStateVar=0.179829
X3238   33   177  memristor PARAMS: InitStateVar=0.511628
X3338   34   177  memristor PARAMS: InitStateVar=0.191391
X3438   35   177  memristor PARAMS: InitStateVar=0.370809
X3538   36   177  memristor PARAMS: InitStateVar=0.45056
X3638   37   177  memristor PARAMS: InitStateVar=0.409334
X3738   38   177  memristor PARAMS: InitStateVar=0.242224
X3838   39   177  memristor PARAMS: InitStateVar=0.290091
X3938   40   177  memristor PARAMS: InitStateVar=0.302143
X4038   41   177  memristor PARAMS: InitStateVar=0.314974
X4138   42   177  memristor PARAMS: InitStateVar=0.28371
X4238   43   177  memristor PARAMS: InitStateVar=0.197805
X4338   44   177  memristor PARAMS: InitStateVar=0.393033
X4438   45   177  memristor PARAMS: InitStateVar=0.328462
X4538   46   177  memristor PARAMS: InitStateVar=0.466494
X4638   47   177  memristor PARAMS: InitStateVar=0.401084
X4738   48   177  memristor PARAMS: InitStateVar=0.321565
X4838   49   177  memristor PARAMS: InitStateVar=0.296752
X4938   50   177  memristor PARAMS: InitStateVar=0.190682
X5038   51   177  memristor PARAMS: InitStateVar=0.354429
X5138   52   177  memristor PARAMS: InitStateVar=0.304452
X5238   53   177  memristor PARAMS: InitStateVar=0.294563
X5338   54   177  memristor PARAMS: InitStateVar=0.336319
X5438   55   177  memristor PARAMS: InitStateVar=0.275404
X5538   56   177  memristor PARAMS: InitStateVar=0.372742
X5638   57   177  memristor PARAMS: InitStateVar=0.257275
X5738   58   177  memristor PARAMS: InitStateVar=0.380657
X5838   59   177  memristor PARAMS: InitStateVar=0.389459
X5938   60   177  memristor PARAMS: InitStateVar=0.223781
X6038   61   177  memristor PARAMS: InitStateVar=0.242449
X6138   62   177  memristor PARAMS: InitStateVar=0.341164
X6238   63   177  memristor PARAMS: InitStateVar=0.174358
X6338   64   177  memristor PARAMS: InitStateVar=0.2724
X6438   65   177  memristor PARAMS: InitStateVar=0.237168
X6538   66   177  memristor PARAMS: InitStateVar=0.468881
X6638   67   177  memristor PARAMS: InitStateVar=0.379499
X6738   68   177  memristor PARAMS: InitStateVar=0.259798
X6838   69   177  memristor PARAMS: InitStateVar=0.373197
X6938   70   177  memristor PARAMS: InitStateVar=0.574586
X7038   71   177  memristor PARAMS: InitStateVar=0.263545
X7138   72   177  memristor PARAMS: InitStateVar=0.475823
X7238   73   177  memristor PARAMS: InitStateVar=0.330958
X7338   74   177  memristor PARAMS: InitStateVar=0.169905
X7438   75   177  memristor PARAMS: InitStateVar=0.29177
X7538   76   177  memristor PARAMS: InitStateVar=0.353401
X7638   77   177  memristor PARAMS: InitStateVar=0.200364
X7738   78   177  memristor PARAMS: InitStateVar=0.416443
X7838   79   177  memristor PARAMS: InitStateVar=0.306516
X7938   80   177  memristor PARAMS: InitStateVar=0.289637
X8038   81   177  memristor PARAMS: InitStateVar=0.1838
X8138   82   177  memristor PARAMS: InitStateVar=0.425903
X8238   83   177  memristor PARAMS: InitStateVar=0.133642
X8338   84   177  memristor PARAMS: InitStateVar=0.241008
X8438   85   177  memristor PARAMS: InitStateVar=0.193313
X8538   86   177  memristor PARAMS: InitStateVar=0.426112
X8638   87   177  memristor PARAMS: InitStateVar=0.190632
X8738   88   177  memristor PARAMS: InitStateVar=0.50895
X8838   89   177  memristor PARAMS: InitStateVar=0.104632
X8938   90   177  memristor PARAMS: InitStateVar=0.162001
X9038   91   177  memristor PARAMS: InitStateVar=0.416578
X9138   92   177  memristor PARAMS: InitStateVar=0.196304
X9238   93   177  memristor PARAMS: InitStateVar=0.291401
X9338   94   177  memristor PARAMS: InitStateVar=0.402615
X9438   95   177  memristor PARAMS: InitStateVar=0.433287
X9538   96   177  memristor PARAMS: InitStateVar=0.286203
X9638   97   177  memristor PARAMS: InitStateVar=0.140037
X9738   98   177  memristor PARAMS: InitStateVar=0.111878
X9838   99   177  memristor PARAMS: InitStateVar=0.306332
X9938   100  177  memristor PARAMS: InitStateVar=0.179194
Xo39    177  178  OutputModule PARAMS: Rval=100
*------------------- Column 40 -------------------------------------------------
X39     1    179  memristor PARAMS: InitStateVar=0.256353
X139    2    179  memristor PARAMS: InitStateVar=0.103628
X239    3    179  memristor PARAMS: InitStateVar=0.238481
X339    4    179  memristor PARAMS: InitStateVar=0.236015
X439    5    179  memristor PARAMS: InitStateVar=0.141819
X539    6    179  memristor PARAMS: InitStateVar=0.380592
X639    7    179  memristor PARAMS: InitStateVar=0.323443
X739    8    179  memristor PARAMS: InitStateVar=0.281026
X839    9    179  memristor PARAMS: InitStateVar=0.314753
X939    10   179  memristor PARAMS: InitStateVar=0.517168
X1039   11   179  memristor PARAMS: InitStateVar=0.330922
X1139   12   179  memristor PARAMS: InitStateVar=0.366783
X1239   13   179  memristor PARAMS: InitStateVar=0.361121
X1339   14   179  memristor PARAMS: InitStateVar=0.189107
X1439   15   179  memristor PARAMS: InitStateVar=0.273895
X1539   16   179  memristor PARAMS: InitStateVar=0.43437
X1639   17   179  memristor PARAMS: InitStateVar=0.358811
X1739   18   179  memristor PARAMS: InitStateVar=0.219435
X1839   19   179  memristor PARAMS: InitStateVar=0.220768
X1939   20   179  memristor PARAMS: InitStateVar=0.307449
X2039   21   179  memristor PARAMS: InitStateVar=0.284192
X2139   22   179  memristor PARAMS: InitStateVar=0.365753
X2239   23   179  memristor PARAMS: InitStateVar=0.456629
X2339   24   179  memristor PARAMS: InitStateVar=0.231668
X2439   25   179  memristor PARAMS: InitStateVar=0.287529
X2539   26   179  memristor PARAMS: InitStateVar=0.367627
X2639   27   179  memristor PARAMS: InitStateVar=0.220128
X2739   28   179  memristor PARAMS: InitStateVar=0.359596
X2839   29   179  memristor PARAMS: InitStateVar=0.220637
X2939   30   179  memristor PARAMS: InitStateVar=0.160827
X3039   31   179  memristor PARAMS: InitStateVar=0.225958
X3139   32   179  memristor PARAMS: InitStateVar=0.323389
X3239   33   179  memristor PARAMS: InitStateVar=0.0983891
X3339   34   179  memristor PARAMS: InitStateVar=0.539761
X3439   35   179  memristor PARAMS: InitStateVar=0.421473
X3539   36   179  memristor PARAMS: InitStateVar=0.306963
X3639   37   179  memristor PARAMS: InitStateVar=0.120255
X3739   38   179  memristor PARAMS: InitStateVar=0.418737
X3839   39   179  memristor PARAMS: InitStateVar=0.197674
X3939   40   179  memristor PARAMS: InitStateVar=0.199186
X4039   41   179  memristor PARAMS: InitStateVar=0.385365
X4139   42   179  memristor PARAMS: InitStateVar=0.171981
X4239   43   179  memristor PARAMS: InitStateVar=0.325664
X4339   44   179  memristor PARAMS: InitStateVar=0.232983
X4439   45   179  memristor PARAMS: InitStateVar=0.182359
X4539   46   179  memristor PARAMS: InitStateVar=0.433965
X4639   47   179  memristor PARAMS: InitStateVar=0.209337
X4739   48   179  memristor PARAMS: InitStateVar=0.335665
X4839   49   179  memristor PARAMS: InitStateVar=0.19968
X4939   50   179  memristor PARAMS: InitStateVar=0.512898
X5039   51   179  memristor PARAMS: InitStateVar=0.210493
X5139   52   179  memristor PARAMS: InitStateVar=0.270798
X5239   53   179  memristor PARAMS: InitStateVar=0.363809
X5339   54   179  memristor PARAMS: InitStateVar=0.365435
X5439   55   179  memristor PARAMS: InitStateVar=0.312858
X5539   56   179  memristor PARAMS: InitStateVar=0.268464
X5639   57   179  memristor PARAMS: InitStateVar=0.237603
X5739   58   179  memristor PARAMS: InitStateVar=0.251266
X5839   59   179  memristor PARAMS: InitStateVar=0.30687
X5939   60   179  memristor PARAMS: InitStateVar=0.380406
X6039   61   179  memristor PARAMS: InitStateVar=0.265766
X6139   62   179  memristor PARAMS: InitStateVar=0.289532
X6239   63   179  memristor PARAMS: InitStateVar=0.253699
X6339   64   179  memristor PARAMS: InitStateVar=0.13888
X6439   65   179  memristor PARAMS: InitStateVar=0.265022
X6539   66   179  memristor PARAMS: InitStateVar=0.314846
X6639   67   179  memristor PARAMS: InitStateVar=0.339644
X6739   68   179  memristor PARAMS: InitStateVar=0.511997
X6839   69   179  memristor PARAMS: InitStateVar=0.0889902
X6939   70   179  memristor PARAMS: InitStateVar=0.0808899
X7039   71   179  memristor PARAMS: InitStateVar=0.155162
X7139   72   179  memristor PARAMS: InitStateVar=0.261503
X7239   73   179  memristor PARAMS: InitStateVar=0.305593
X7339   74   179  memristor PARAMS: InitStateVar=0.0666297
X7439   75   179  memristor PARAMS: InitStateVar=0.232169
X7539   76   179  memristor PARAMS: InitStateVar=0.463558
X7639   77   179  memristor PARAMS: InitStateVar=0.28629
X7739   78   179  memristor PARAMS: InitStateVar=0.348194
X7839   79   179  memristor PARAMS: InitStateVar=0.273441
X7939   80   179  memristor PARAMS: InitStateVar=0.242894
X8039   81   179  memristor PARAMS: InitStateVar=0.0907176
X8139   82   179  memristor PARAMS: InitStateVar=0.356593
X8239   83   179  memristor PARAMS: InitStateVar=0.229355
X8339   84   179  memristor PARAMS: InitStateVar=0.34771
X8439   85   179  memristor PARAMS: InitStateVar=0.353207
X8539   86   179  memristor PARAMS: InitStateVar=0.372335
X8639   87   179  memristor PARAMS: InitStateVar=0.251749
X8739   88   179  memristor PARAMS: InitStateVar=0.290621
X8839   89   179  memristor PARAMS: InitStateVar=0.432786
X8939   90   179  memristor PARAMS: InitStateVar=0.289561
X9039   91   179  memristor PARAMS: InitStateVar=0.296457
X9139   92   179  memristor PARAMS: InitStateVar=0.370637
X9239   93   179  memristor PARAMS: InitStateVar=0.0566627
X9339   94   179  memristor PARAMS: InitStateVar=0.345177
X9439   95   179  memristor PARAMS: InitStateVar=0.25897
X9539   96   179  memristor PARAMS: InitStateVar=0.419674
X9639   97   179  memristor PARAMS: InitStateVar=0.242365
X9739   98   179  memristor PARAMS: InitStateVar=0.480084
X9839   99   179  memristor PARAMS: InitStateVar=0.31537
X9939   100  179  memristor PARAMS: InitStateVar=0.483372
Xo40    179  180  OutputModule PARAMS: Rval=100
*------------------- Column 41 -------------------------------------------------
X40     1    181  memristor PARAMS: InitStateVar=0.325135
X140    2    181  memristor PARAMS: InitStateVar=0.518533
X240    3    181  memristor PARAMS: InitStateVar=0.384603
X340    4    181  memristor PARAMS: InitStateVar=0.256536
X440    5    181  memristor PARAMS: InitStateVar=0.493896
X540    6    181  memristor PARAMS: InitStateVar=0.344086
X640    7    181  memristor PARAMS: InitStateVar=0.241819
X740    8    181  memristor PARAMS: InitStateVar=0.39837
X840    9    181  memristor PARAMS: InitStateVar=0.255548
X940    10   181  memristor PARAMS: InitStateVar=0.380683
X1040   11   181  memristor PARAMS: InitStateVar=0.384841
X1140   12   181  memristor PARAMS: InitStateVar=0.239492
X1240   13   181  memristor PARAMS: InitStateVar=0.348355
X1340   14   181  memristor PARAMS: InitStateVar=0.307239
X1440   15   181  memristor PARAMS: InitStateVar=0.314653
X1540   16   181  memristor PARAMS: InitStateVar=0.249303
X1640   17   181  memristor PARAMS: InitStateVar=0.312022
X1740   18   181  memristor PARAMS: InitStateVar=0.202902
X1840   19   181  memristor PARAMS: InitStateVar=0.291766
X1940   20   181  memristor PARAMS: InitStateVar=0.251633
X2040   21   181  memristor PARAMS: InitStateVar=0.214884
X2140   22   181  memristor PARAMS: InitStateVar=0.167205
X2240   23   181  memristor PARAMS: InitStateVar=0.365515
X2340   24   181  memristor PARAMS: InitStateVar=0.0108746
X2440   25   181  memristor PARAMS: InitStateVar=0.575515
X2540   26   181  memristor PARAMS: InitStateVar=0.231525
X2640   27   181  memristor PARAMS: InitStateVar=0.405031
X2740   28   181  memristor PARAMS: InitStateVar=0.283951
X2840   29   181  memristor PARAMS: InitStateVar=0.186809
X2940   30   181  memristor PARAMS: InitStateVar=0.407223
X3040   31   181  memristor PARAMS: InitStateVar=0.352534
X3140   32   181  memristor PARAMS: InitStateVar=0.188216
X3240   33   181  memristor PARAMS: InitStateVar=0.243801
X3340   34   181  memristor PARAMS: InitStateVar=0.17184
X3440   35   181  memristor PARAMS: InitStateVar=0.437379
X3540   36   181  memristor PARAMS: InitStateVar=0.419796
X3640   37   181  memristor PARAMS: InitStateVar=0.20837
X3740   38   181  memristor PARAMS: InitStateVar=0.357608
X3840   39   181  memristor PARAMS: InitStateVar=0.375867
X3940   40   181  memristor PARAMS: InitStateVar=0.229583
X4040   41   181  memristor PARAMS: InitStateVar=0.198495
X4140   42   181  memristor PARAMS: InitStateVar=0.459384
X4240   43   181  memristor PARAMS: InitStateVar=0.482091
X4340   44   181  memristor PARAMS: InitStateVar=0.217541
X4440   45   181  memristor PARAMS: InitStateVar=0.205925
X4540   46   181  memristor PARAMS: InitStateVar=0.18296
X4640   47   181  memristor PARAMS: InitStateVar=0.478741
X4740   48   181  memristor PARAMS: InitStateVar=0.469797
X4840   49   181  memristor PARAMS: InitStateVar=0.251766
X4940   50   181  memristor PARAMS: InitStateVar=0.435744
X5040   51   181  memristor PARAMS: InitStateVar=0.293334
X5140   52   181  memristor PARAMS: InitStateVar=0.371982
X5240   53   181  memristor PARAMS: InitStateVar=0.302203
X5340   54   181  memristor PARAMS: InitStateVar=0.337348
X5440   55   181  memristor PARAMS: InitStateVar=0.360456
X5540   56   181  memristor PARAMS: InitStateVar=0.305452
X5640   57   181  memristor PARAMS: InitStateVar=0.313212
X5740   58   181  memristor PARAMS: InitStateVar=0.278554
X5840   59   181  memristor PARAMS: InitStateVar=0.251633
X5940   60   181  memristor PARAMS: InitStateVar=0.238066
X6040   61   181  memristor PARAMS: InitStateVar=0.308453
X6140   62   181  memristor PARAMS: InitStateVar=0.236687
X6240   63   181  memristor PARAMS: InitStateVar=0.24793
X6340   64   181  memristor PARAMS: InitStateVar=0.291156
X6440   65   181  memristor PARAMS: InitStateVar=0.32853
X6540   66   181  memristor PARAMS: InitStateVar=0.452411
X6640   67   181  memristor PARAMS: InitStateVar=0.357803
X6740   68   181  memristor PARAMS: InitStateVar=0.29145
X6840   69   181  memristor PARAMS: InitStateVar=0.35778
X6940   70   181  memristor PARAMS: InitStateVar=0.164767
X7040   71   181  memristor PARAMS: InitStateVar=0.423403
X7140   72   181  memristor PARAMS: InitStateVar=0.441358
X7240   73   181  memristor PARAMS: InitStateVar=0.185813
X7340   74   181  memristor PARAMS: InitStateVar=0.238625
X7440   75   181  memristor PARAMS: InitStateVar=0.410681
X7540   76   181  memristor PARAMS: InitStateVar=0.254816
X7640   77   181  memristor PARAMS: InitStateVar=0.303816
X7740   78   181  memristor PARAMS: InitStateVar=0.398306
X7840   79   181  memristor PARAMS: InitStateVar=0.436607
X7940   80   181  memristor PARAMS: InitStateVar=0.441412
X8040   81   181  memristor PARAMS: InitStateVar=0.629649
X8140   82   181  memristor PARAMS: InitStateVar=0.503848
X8240   83   181  memristor PARAMS: InitStateVar=0.375697
X8340   84   181  memristor PARAMS: InitStateVar=0.27585
X8440   85   181  memristor PARAMS: InitStateVar=0.239018
X8540   86   181  memristor PARAMS: InitStateVar=0.252766
X8640   87   181  memristor PARAMS: InitStateVar=0.234894
X8740   88   181  memristor PARAMS: InitStateVar=0.318465
X8840   89   181  memristor PARAMS: InitStateVar=0.381407
X8940   90   181  memristor PARAMS: InitStateVar=0.350381
X9040   91   181  memristor PARAMS: InitStateVar=0.294485
X9140   92   181  memristor PARAMS: InitStateVar=0.418481
X9240   93   181  memristor PARAMS: InitStateVar=0.400963
X9340   94   181  memristor PARAMS: InitStateVar=0.436514
X9440   95   181  memristor PARAMS: InitStateVar=0.288534
X9540   96   181  memristor PARAMS: InitStateVar=0.225136
X9640   97   181  memristor PARAMS: InitStateVar=0.107291
X9740   98   181  memristor PARAMS: InitStateVar=0.319775
X9840   99   181  memristor PARAMS: InitStateVar=0.380957
X9940   100  181  memristor PARAMS: InitStateVar=0.257029
Xo41    181  182  OutputModule PARAMS: Rval=100
*------------------- Column 42 -------------------------------------------------
X41     1    183  memristor PARAMS: InitStateVar=0.352644
X141    2    183  memristor PARAMS: InitStateVar=0.414802
X241    3    183  memristor PARAMS: InitStateVar=0.18406
X341    4    183  memristor PARAMS: InitStateVar=0.286006
X441    5    183  memristor PARAMS: InitStateVar=0.318603
X541    6    183  memristor PARAMS: InitStateVar=0.263216
X641    7    183  memristor PARAMS: InitStateVar=0.190236
X741    8    183  memristor PARAMS: InitStateVar=0.407993
X841    9    183  memristor PARAMS: InitStateVar=0.160487
X941    10   183  memristor PARAMS: InitStateVar=0.365977
X1041   11   183  memristor PARAMS: InitStateVar=0.191122
X1141   12   183  memristor PARAMS: InitStateVar=0.288722
X1241   13   183  memristor PARAMS: InitStateVar=0.321206
X1341   14   183  memristor PARAMS: InitStateVar=0.213972
X1441   15   183  memristor PARAMS: InitStateVar=0.309805
X1541   16   183  memristor PARAMS: InitStateVar=0.392958
X1641   17   183  memristor PARAMS: InitStateVar=0.259067
X1741   18   183  memristor PARAMS: InitStateVar=0.303491
X1841   19   183  memristor PARAMS: InitStateVar=0.254215
X1941   20   183  memristor PARAMS: InitStateVar=0.460126
X2041   21   183  memristor PARAMS: InitStateVar=0.284932
X2141   22   183  memristor PARAMS: InitStateVar=0.436195
X2241   23   183  memristor PARAMS: InitStateVar=0.220019
X2341   24   183  memristor PARAMS: InitStateVar=0.30323
X2441   25   183  memristor PARAMS: InitStateVar=0.219418
X2541   26   183  memristor PARAMS: InitStateVar=0.131868
X2641   27   183  memristor PARAMS: InitStateVar=0.119538
X2741   28   183  memristor PARAMS: InitStateVar=0.4587
X2841   29   183  memristor PARAMS: InitStateVar=0.481105
X2941   30   183  memristor PARAMS: InitStateVar=0.384945
X3041   31   183  memristor PARAMS: InitStateVar=0.268459
X3141   32   183  memristor PARAMS: InitStateVar=0.336646
X3241   33   183  memristor PARAMS: InitStateVar=0.187977
X3341   34   183  memristor PARAMS: InitStateVar=0.272046
X3441   35   183  memristor PARAMS: InitStateVar=0.387399
X3541   36   183  memristor PARAMS: InitStateVar=0.39318
X3641   37   183  memristor PARAMS: InitStateVar=0.221708
X3741   38   183  memristor PARAMS: InitStateVar=0.214949
X3841   39   183  memristor PARAMS: InitStateVar=0.163923
X3941   40   183  memristor PARAMS: InitStateVar=0.237002
X4041   41   183  memristor PARAMS: InitStateVar=0.332315
X4141   42   183  memristor PARAMS: InitStateVar=0.356274
X4241   43   183  memristor PARAMS: InitStateVar=0.213556
X4341   44   183  memristor PARAMS: InitStateVar=0.29825
X4441   45   183  memristor PARAMS: InitStateVar=0.287233
X4541   46   183  memristor PARAMS: InitStateVar=0.276558
X4641   47   183  memristor PARAMS: InitStateVar=0.481118
X4741   48   183  memristor PARAMS: InitStateVar=0.56886
X4841   49   183  memristor PARAMS: InitStateVar=0.0932781
X4941   50   183  memristor PARAMS: InitStateVar=0.376499
X5041   51   183  memristor PARAMS: InitStateVar=0.313157
X5141   52   183  memristor PARAMS: InitStateVar=0.253283
X5241   53   183  memristor PARAMS: InitStateVar=0.278997
X5341   54   183  memristor PARAMS: InitStateVar=0.45853
X5441   55   183  memristor PARAMS: InitStateVar=0.280873
X5541   56   183  memristor PARAMS: InitStateVar=0.345713
X5641   57   183  memristor PARAMS: InitStateVar=0.0831084
X5741   58   183  memristor PARAMS: InitStateVar=0.346195
X5841   59   183  memristor PARAMS: InitStateVar=0.39019
X5941   60   183  memristor PARAMS: InitStateVar=0.242233
X6041   61   183  memristor PARAMS: InitStateVar=0.264256
X6141   62   183  memristor PARAMS: InitStateVar=0.326476
X6241   63   183  memristor PARAMS: InitStateVar=0.285433
X6341   64   183  memristor PARAMS: InitStateVar=0.240789
X6441   65   183  memristor PARAMS: InitStateVar=0.299613
X6541   66   183  memristor PARAMS: InitStateVar=0.369344
X6641   67   183  memristor PARAMS: InitStateVar=0.42933
X6741   68   183  memristor PARAMS: InitStateVar=0.279377
X6841   69   183  memristor PARAMS: InitStateVar=0.183791
X6941   70   183  memristor PARAMS: InitStateVar=0.540835
X7041   71   183  memristor PARAMS: InitStateVar=0.241725
X7141   72   183  memristor PARAMS: InitStateVar=0.443423
X7241   73   183  memristor PARAMS: InitStateVar=0.420915
X7341   74   183  memristor PARAMS: InitStateVar=0.112036
X7441   75   183  memristor PARAMS: InitStateVar=0.371997
X7541   76   183  memristor PARAMS: InitStateVar=0.439698
X7641   77   183  memristor PARAMS: InitStateVar=0.383347
X7741   78   183  memristor PARAMS: InitStateVar=0.321386
X7841   79   183  memristor PARAMS: InitStateVar=0.3935
X7941   80   183  memristor PARAMS: InitStateVar=0.249001
X8041   81   183  memristor PARAMS: InitStateVar=0.210435
X8141   82   183  memristor PARAMS: InitStateVar=0.249379
X8241   83   183  memristor PARAMS: InitStateVar=0.310724
X8341   84   183  memristor PARAMS: InitStateVar=0.390564
X8441   85   183  memristor PARAMS: InitStateVar=0.263577
X8541   86   183  memristor PARAMS: InitStateVar=0.241288
X8641   87   183  memristor PARAMS: InitStateVar=0.448653
X8741   88   183  memristor PARAMS: InitStateVar=0.329094
X8841   89   183  memristor PARAMS: InitStateVar=0.278098
X8941   90   183  memristor PARAMS: InitStateVar=0.471087
X9041   91   183  memristor PARAMS: InitStateVar=0.174963
X9141   92   183  memristor PARAMS: InitStateVar=0.443143
X9241   93   183  memristor PARAMS: InitStateVar=0.252011
X9341   94   183  memristor PARAMS: InitStateVar=0.224532
X9441   95   183  memristor PARAMS: InitStateVar=0.290797
X9541   96   183  memristor PARAMS: InitStateVar=0.247343
X9641   97   183  memristor PARAMS: InitStateVar=0.305255
X9741   98   183  memristor PARAMS: InitStateVar=0.357076
X9841   99   183  memristor PARAMS: InitStateVar=0.142055
X9941   100  183  memristor PARAMS: InitStateVar=0.406044
Xo42    183  184  OutputModule PARAMS: Rval=100
*------------------- Column 43 -------------------------------------------------
X42     1    185  memristor PARAMS: InitStateVar=0.329035
X142    2    185  memristor PARAMS: InitStateVar=0.28602
X242    3    185  memristor PARAMS: InitStateVar=0.381543
X342    4    185  memristor PARAMS: InitStateVar=0.128032
X442    5    185  memristor PARAMS: InitStateVar=0.203802
X542    6    185  memristor PARAMS: InitStateVar=0.22739
X642    7    185  memristor PARAMS: InitStateVar=0.288677
X742    8    185  memristor PARAMS: InitStateVar=0.238885
X842    9    185  memristor PARAMS: InitStateVar=0.316065
X942    10   185  memristor PARAMS: InitStateVar=0.307362
X1042   11   185  memristor PARAMS: InitStateVar=0.234076
X1142   12   185  memristor PARAMS: InitStateVar=0.151778
X1242   13   185  memristor PARAMS: InitStateVar=0.272462
X1342   14   185  memristor PARAMS: InitStateVar=0.168074
X1442   15   185  memristor PARAMS: InitStateVar=0.213815
X1542   16   185  memristor PARAMS: InitStateVar=0.37023
X1642   17   185  memristor PARAMS: InitStateVar=0.327808
X1742   18   185  memristor PARAMS: InitStateVar=0.206048
X1842   19   185  memristor PARAMS: InitStateVar=0.286037
X1942   20   185  memristor PARAMS: InitStateVar=0.267313
X2042   21   185  memristor PARAMS: InitStateVar=0.471352
X2142   22   185  memristor PARAMS: InitStateVar=0.0761508
X2242   23   185  memristor PARAMS: InitStateVar=0.2493
X2342   24   185  memristor PARAMS: InitStateVar=0.376287
X2442   25   185  memristor PARAMS: InitStateVar=0.220638
X2542   26   185  memristor PARAMS: InitStateVar=0.482436
X2642   27   185  memristor PARAMS: InitStateVar=0.455523
X2742   28   185  memristor PARAMS: InitStateVar=0.191098
X2842   29   185  memristor PARAMS: InitStateVar=0.503968
X2942   30   185  memristor PARAMS: InitStateVar=0.462012
X3042   31   185  memristor PARAMS: InitStateVar=0.264655
X3142   32   185  memristor PARAMS: InitStateVar=0.407002
X3242   33   185  memristor PARAMS: InitStateVar=0.32019
X3342   34   185  memristor PARAMS: InitStateVar=0.278872
X3442   35   185  memristor PARAMS: InitStateVar=0.294936
X3542   36   185  memristor PARAMS: InitStateVar=0.360384
X3642   37   185  memristor PARAMS: InitStateVar=0.175111
X3742   38   185  memristor PARAMS: InitStateVar=0.336247
X3842   39   185  memristor PARAMS: InitStateVar=0.349541
X3942   40   185  memristor PARAMS: InitStateVar=0.260893
X4042   41   185  memristor PARAMS: InitStateVar=0.288913
X4142   42   185  memristor PARAMS: InitStateVar=0.268139
X4242   43   185  memristor PARAMS: InitStateVar=0.572775
X4342   44   185  memristor PARAMS: InitStateVar=0.35651
X4442   45   185  memristor PARAMS: InitStateVar=0.0674046
X4542   46   185  memristor PARAMS: InitStateVar=0.465837
X4642   47   185  memristor PARAMS: InitStateVar=0.265514
X4742   48   185  memristor PARAMS: InitStateVar=0.425259
X4842   49   185  memristor PARAMS: InitStateVar=0.145767
X4942   50   185  memristor PARAMS: InitStateVar=0.424893
X5042   51   185  memristor PARAMS: InitStateVar=0.292145
X5142   52   185  memristor PARAMS: InitStateVar=0.0917756
X5242   53   185  memristor PARAMS: InitStateVar=0.333509
X5342   54   185  memristor PARAMS: InitStateVar=0.209425
X5442   55   185  memristor PARAMS: InitStateVar=0.135825
X5542   56   185  memristor PARAMS: InitStateVar=0.308899
X5642   57   185  memristor PARAMS: InitStateVar=0.309979
X5742   58   185  memristor PARAMS: InitStateVar=0.267244
X5842   59   185  memristor PARAMS: InitStateVar=0.401028
X5942   60   185  memristor PARAMS: InitStateVar=0.122596
X6042   61   185  memristor PARAMS: InitStateVar=0.232919
X6142   62   185  memristor PARAMS: InitStateVar=0.312008
X6242   63   185  memristor PARAMS: InitStateVar=0.421269
X6342   64   185  memristor PARAMS: InitStateVar=0.294202
X6442   65   185  memristor PARAMS: InitStateVar=0.374855
X6542   66   185  memristor PARAMS: InitStateVar=0.258317
X6642   67   185  memristor PARAMS: InitStateVar=0.299873
X6742   68   185  memristor PARAMS: InitStateVar=0.350358
X6842   69   185  memristor PARAMS: InitStateVar=0.303019
X6942   70   185  memristor PARAMS: InitStateVar=0.0581314
X7042   71   185  memristor PARAMS: InitStateVar=0.412686
X7142   72   185  memristor PARAMS: InitStateVar=0.440013
X7242   73   185  memristor PARAMS: InitStateVar=0.390922
X7342   74   185  memristor PARAMS: InitStateVar=0.549066
X7442   75   185  memristor PARAMS: InitStateVar=0.260225
X7542   76   185  memristor PARAMS: InitStateVar=0.187507
X7642   77   185  memristor PARAMS: InitStateVar=0.305657
X7742   78   185  memristor PARAMS: InitStateVar=0.129153
X7842   79   185  memristor PARAMS: InitStateVar=0.181781
X7942   80   185  memristor PARAMS: InitStateVar=0.291622
X8042   81   185  memristor PARAMS: InitStateVar=0.21369
X8142   82   185  memristor PARAMS: InitStateVar=0.279415
X8242   83   185  memristor PARAMS: InitStateVar=0.372808
X8342   84   185  memristor PARAMS: InitStateVar=0.266554
X8442   85   185  memristor PARAMS: InitStateVar=0.161474
X8542   86   185  memristor PARAMS: InitStateVar=0.333255
X8642   87   185  memristor PARAMS: InitStateVar=0.293154
X8742   88   185  memristor PARAMS: InitStateVar=0.287794
X8842   89   185  memristor PARAMS: InitStateVar=0.293093
X8942   90   185  memristor PARAMS: InitStateVar=0.231623
X9042   91   185  memristor PARAMS: InitStateVar=0.213995
X9142   92   185  memristor PARAMS: InitStateVar=0.261437
X9242   93   185  memristor PARAMS: InitStateVar=0.294179
X9342   94   185  memristor PARAMS: InitStateVar=0.224241
X9442   95   185  memristor PARAMS: InitStateVar=0.344589
X9542   96   185  memristor PARAMS: InitStateVar=0.160102
X9642   97   185  memristor PARAMS: InitStateVar=0.289812
X9742   98   185  memristor PARAMS: InitStateVar=0.493509
X9842   99   185  memristor PARAMS: InitStateVar=0.18098
X9942   100  185  memristor PARAMS: InitStateVar=0.379301
Xo43    185  186  OutputModule PARAMS: Rval=100
*------------------- Column 44 -------------------------------------------------
X43     1    187  memristor PARAMS: InitStateVar=0.118818
X143    2    187  memristor PARAMS: InitStateVar=0.330661
X243    3    187  memristor PARAMS: InitStateVar=0.223441
X343    4    187  memristor PARAMS: InitStateVar=0.207144
X443    5    187  memristor PARAMS: InitStateVar=0.296248
X543    6    187  memristor PARAMS: InitStateVar=0.425347
X643    7    187  memristor PARAMS: InitStateVar=0.417535
X743    8    187  memristor PARAMS: InitStateVar=0.351487
X843    9    187  memristor PARAMS: InitStateVar=0.222182
X943    10   187  memristor PARAMS: InitStateVar=0.43046
X1043   11   187  memristor PARAMS: InitStateVar=0.30387
X1143   12   187  memristor PARAMS: InitStateVar=0.223205
X1243   13   187  memristor PARAMS: InitStateVar=0.342128
X1343   14   187  memristor PARAMS: InitStateVar=0.223497
X1443   15   187  memristor PARAMS: InitStateVar=0.220152
X1543   16   187  memristor PARAMS: InitStateVar=0.29935
X1643   17   187  memristor PARAMS: InitStateVar=0.430333
X1743   18   187  memristor PARAMS: InitStateVar=0.0677887
X1843   19   187  memristor PARAMS: InitStateVar=0.296063
X1943   20   187  memristor PARAMS: InitStateVar=0.237763
X2043   21   187  memristor PARAMS: InitStateVar=0.340811
X2143   22   187  memristor PARAMS: InitStateVar=0.246891
X2243   23   187  memristor PARAMS: InitStateVar=0.340913
X2343   24   187  memristor PARAMS: InitStateVar=0.404092
X2443   25   187  memristor PARAMS: InitStateVar=0.254395
X2543   26   187  memristor PARAMS: InitStateVar=0.412933
X2643   27   187  memristor PARAMS: InitStateVar=0.284493
X2743   28   187  memristor PARAMS: InitStateVar=0.38505
X2843   29   187  memristor PARAMS: InitStateVar=0.284503
X2943   30   187  memristor PARAMS: InitStateVar=0.191375
X3043   31   187  memristor PARAMS: InitStateVar=0.386354
X3143   32   187  memristor PARAMS: InitStateVar=0.11787
X3243   33   187  memristor PARAMS: InitStateVar=0.147768
X3343   34   187  memristor PARAMS: InitStateVar=0.443076
X3443   35   187  memristor PARAMS: InitStateVar=0.433602
X3543   36   187  memristor PARAMS: InitStateVar=0.361048
X3643   37   187  memristor PARAMS: InitStateVar=0.254109
X3743   38   187  memristor PARAMS: InitStateVar=0.157021
X3843   39   187  memristor PARAMS: InitStateVar=0.512553
X3943   40   187  memristor PARAMS: InitStateVar=0.164848
X4043   41   187  memristor PARAMS: InitStateVar=0.316915
X4143   42   187  memristor PARAMS: InitStateVar=0.331164
X4243   43   187  memristor PARAMS: InitStateVar=0.244895
X4343   44   187  memristor PARAMS: InitStateVar=0.304074
X4443   45   187  memristor PARAMS: InitStateVar=0.352603
X4543   46   187  memristor PARAMS: InitStateVar=0.268395
X4643   47   187  memristor PARAMS: InitStateVar=0.271551
X4743   48   187  memristor PARAMS: InitStateVar=0.355297
X4843   49   187  memristor PARAMS: InitStateVar=0.320933
X4943   50   187  memristor PARAMS: InitStateVar=0.43969
X5043   51   187  memristor PARAMS: InitStateVar=0.412136
X5143   52   187  memristor PARAMS: InitStateVar=0.313026
X5243   53   187  memristor PARAMS: InitStateVar=0.298805
X5343   54   187  memristor PARAMS: InitStateVar=0.085964
X5443   55   187  memristor PARAMS: InitStateVar=0.31726
X5543   56   187  memristor PARAMS: InitStateVar=0.387385
X5643   57   187  memristor PARAMS: InitStateVar=0.240745
X5743   58   187  memristor PARAMS: InitStateVar=0.164732
X5843   59   187  memristor PARAMS: InitStateVar=0.122485
X5943   60   187  memristor PARAMS: InitStateVar=0.301684
X6043   61   187  memristor PARAMS: InitStateVar=0.180488
X6143   62   187  memristor PARAMS: InitStateVar=0.0953332
X6243   63   187  memristor PARAMS: InitStateVar=0.314342
X6343   64   187  memristor PARAMS: InitStateVar=0.455069
X6443   65   187  memristor PARAMS: InitStateVar=0.323592
X6543   66   187  memristor PARAMS: InitStateVar=0.212724
X6643   67   187  memristor PARAMS: InitStateVar=0.397665
X6743   68   187  memristor PARAMS: InitStateVar=0.387767
X6843   69   187  memristor PARAMS: InitStateVar=0.195658
X6943   70   187  memristor PARAMS: InitStateVar=0.171198
X7043   71   187  memristor PARAMS: InitStateVar=0.267336
X7143   72   187  memristor PARAMS: InitStateVar=0.218746
X7243   73   187  memristor PARAMS: InitStateVar=0.301342
X7343   74   187  memristor PARAMS: InitStateVar=0.280207
X7443   75   187  memristor PARAMS: InitStateVar=0.365809
X7543   76   187  memristor PARAMS: InitStateVar=0.0737055
X7643   77   187  memristor PARAMS: InitStateVar=0.273577
X7743   78   187  memristor PARAMS: InitStateVar=0.281959
X7843   79   187  memristor PARAMS: InitStateVar=0.234133
X7943   80   187  memristor PARAMS: InitStateVar=0.310414
X8043   81   187  memristor PARAMS: InitStateVar=0.363425
X8143   82   187  memristor PARAMS: InitStateVar=0.206819
X8243   83   187  memristor PARAMS: InitStateVar=0.442454
X8343   84   187  memristor PARAMS: InitStateVar=0.509522
X8443   85   187  memristor PARAMS: InitStateVar=0.268317
X8543   86   187  memristor PARAMS: InitStateVar=0.244639
X8643   87   187  memristor PARAMS: InitStateVar=0.37405
X8743   88   187  memristor PARAMS: InitStateVar=0.285736
X8843   89   187  memristor PARAMS: InitStateVar=0.406089
X8943   90   187  memristor PARAMS: InitStateVar=0.363885
X9043   91   187  memristor PARAMS: InitStateVar=0.329754
X9143   92   187  memristor PARAMS: InitStateVar=0.194329
X9243   93   187  memristor PARAMS: InitStateVar=0.226723
X9343   94   187  memristor PARAMS: InitStateVar=0.306588
X9443   95   187  memristor PARAMS: InitStateVar=0.383924
X9543   96   187  memristor PARAMS: InitStateVar=0.30634
X9643   97   187  memristor PARAMS: InitStateVar=0.20657
X9743   98   187  memristor PARAMS: InitStateVar=0.173934
X9843   99   187  memristor PARAMS: InitStateVar=0.218796
X9943   100  187  memristor PARAMS: InitStateVar=0.299902
Xo44    187  188  OutputModule PARAMS: Rval=100
*------------------- Column 45 -------------------------------------------------
X44     1    189  memristor PARAMS: InitStateVar=0.373102
X144    2    189  memristor PARAMS: InitStateVar=0.410186
X244    3    189  memristor PARAMS: InitStateVar=0.263489
X344    4    189  memristor PARAMS: InitStateVar=0.258105
X444    5    189  memristor PARAMS: InitStateVar=0.421575
X544    6    189  memristor PARAMS: InitStateVar=0.293161
X644    7    189  memristor PARAMS: InitStateVar=0.353499
X744    8    189  memristor PARAMS: InitStateVar=0.378593
X844    9    189  memristor PARAMS: InitStateVar=0.313036
X944    10   189  memristor PARAMS: InitStateVar=0.20474
X1044   11   189  memristor PARAMS: InitStateVar=0.132715
X1144   12   189  memristor PARAMS: InitStateVar=0.110409
X1244   13   189  memristor PARAMS: InitStateVar=0.150929
X1344   14   189  memristor PARAMS: InitStateVar=0.180365
X1444   15   189  memristor PARAMS: InitStateVar=0.393178
X1544   16   189  memristor PARAMS: InitStateVar=0.314526
X1644   17   189  memristor PARAMS: InitStateVar=0.369488
X1744   18   189  memristor PARAMS: InitStateVar=0.369673
X1844   19   189  memristor PARAMS: InitStateVar=0.48003
X1944   20   189  memristor PARAMS: InitStateVar=0.381764
X2044   21   189  memristor PARAMS: InitStateVar=0.30926
X2144   22   189  memristor PARAMS: InitStateVar=0.290849
X2244   23   189  memristor PARAMS: InitStateVar=0.276445
X2344   24   189  memristor PARAMS: InitStateVar=0.250285
X2444   25   189  memristor PARAMS: InitStateVar=0.367862
X2544   26   189  memristor PARAMS: InitStateVar=0.273242
X2644   27   189  memristor PARAMS: InitStateVar=0.314353
X2744   28   189  memristor PARAMS: InitStateVar=0.122525
X2844   29   189  memristor PARAMS: InitStateVar=0.34015
X2944   30   189  memristor PARAMS: InitStateVar=0.244937
X3044   31   189  memristor PARAMS: InitStateVar=0.34844
X3144   32   189  memristor PARAMS: InitStateVar=0.341414
X3244   33   189  memristor PARAMS: InitStateVar=0.317242
X3344   34   189  memristor PARAMS: InitStateVar=0.470599
X3444   35   189  memristor PARAMS: InitStateVar=0.460165
X3544   36   189  memristor PARAMS: InitStateVar=0.376042
X3644   37   189  memristor PARAMS: InitStateVar=0.329084
X3744   38   189  memristor PARAMS: InitStateVar=0.258399
X3844   39   189  memristor PARAMS: InitStateVar=0.375393
X3944   40   189  memristor PARAMS: InitStateVar=0.253432
X4044   41   189  memristor PARAMS: InitStateVar=0.315563
X4144   42   189  memristor PARAMS: InitStateVar=0.393258
X4244   43   189  memristor PARAMS: InitStateVar=0.275593
X4344   44   189  memristor PARAMS: InitStateVar=0.292382
X4444   45   189  memristor PARAMS: InitStateVar=0.212667
X4544   46   189  memristor PARAMS: InitStateVar=0.443053
X4644   47   189  memristor PARAMS: InitStateVar=0.427161
X4744   48   189  memristor PARAMS: InitStateVar=0.193316
X4844   49   189  memristor PARAMS: InitStateVar=0.392187
X4944   50   189  memristor PARAMS: InitStateVar=0.351965
X5044   51   189  memristor PARAMS: InitStateVar=0.351499
X5144   52   189  memristor PARAMS: InitStateVar=0.133405
X5244   53   189  memristor PARAMS: InitStateVar=0.223691
X5344   54   189  memristor PARAMS: InitStateVar=0.394904
X5444   55   189  memristor PARAMS: InitStateVar=0.45392
X5544   56   189  memristor PARAMS: InitStateVar=0.232003
X5644   57   189  memristor PARAMS: InitStateVar=0.249864
X5744   58   189  memristor PARAMS: InitStateVar=0.319672
X5844   59   189  memristor PARAMS: InitStateVar=0.33489
X5944   60   189  memristor PARAMS: InitStateVar=0.373869
X6044   61   189  memristor PARAMS: InitStateVar=0.493497
X6144   62   189  memristor PARAMS: InitStateVar=0.414567
X6244   63   189  memristor PARAMS: InitStateVar=0.319375
X6344   64   189  memristor PARAMS: InitStateVar=0.388885
X6444   65   189  memristor PARAMS: InitStateVar=0.209495
X6544   66   189  memristor PARAMS: InitStateVar=0.391646
X6644   67   189  memristor PARAMS: InitStateVar=0.358207
X6744   68   189  memristor PARAMS: InitStateVar=0.267429
X6844   69   189  memristor PARAMS: InitStateVar=0.224277
X6944   70   189  memristor PARAMS: InitStateVar=0.445296
X7044   71   189  memristor PARAMS: InitStateVar=0.408346
X7144   72   189  memristor PARAMS: InitStateVar=0.381104
X7244   73   189  memristor PARAMS: InitStateVar=0.267195
X7344   74   189  memristor PARAMS: InitStateVar=0.196341
X7444   75   189  memristor PARAMS: InitStateVar=0.299104
X7544   76   189  memristor PARAMS: InitStateVar=0.391516
X7644   77   189  memristor PARAMS: InitStateVar=0.252691
X7744   78   189  memristor PARAMS: InitStateVar=0.355312
X7844   79   189  memristor PARAMS: InitStateVar=0.178904
X7944   80   189  memristor PARAMS: InitStateVar=0.37658
X8044   81   189  memristor PARAMS: InitStateVar=0.200687
X8144   82   189  memristor PARAMS: InitStateVar=0.293196
X8244   83   189  memristor PARAMS: InitStateVar=0.357884
X8344   84   189  memristor PARAMS: InitStateVar=0.414117
X8444   85   189  memristor PARAMS: InitStateVar=0.260963
X8544   86   189  memristor PARAMS: InitStateVar=0.289492
X8644   87   189  memristor PARAMS: InitStateVar=0.262874
X8744   88   189  memristor PARAMS: InitStateVar=0.425605
X8844   89   189  memristor PARAMS: InitStateVar=0.182928
X8944   90   189  memristor PARAMS: InitStateVar=0.114669
X9044   91   189  memristor PARAMS: InitStateVar=0.302229
X9144   92   189  memristor PARAMS: InitStateVar=0.347925
X9244   93   189  memristor PARAMS: InitStateVar=0.343286
X9344   94   189  memristor PARAMS: InitStateVar=0.250093
X9444   95   189  memristor PARAMS: InitStateVar=0.425696
X9544   96   189  memristor PARAMS: InitStateVar=0.154767
X9644   97   189  memristor PARAMS: InitStateVar=0.268802
X9744   98   189  memristor PARAMS: InitStateVar=0.199197
X9844   99   189  memristor PARAMS: InitStateVar=0.289899
X9944   100  189  memristor PARAMS: InitStateVar=0.245187
Xo45    189  190  OutputModule PARAMS: Rval=100
*------------------- Column 46 -------------------------------------------------
X45     1    191  memristor PARAMS: InitStateVar=0.188725
X145    2    191  memristor PARAMS: InitStateVar=0.291115
X245    3    191  memristor PARAMS: InitStateVar=0.309392
X345    4    191  memristor PARAMS: InitStateVar=0.317295
X445    5    191  memristor PARAMS: InitStateVar=0.240148
X545    6    191  memristor PARAMS: InitStateVar=0.0848187
X645    7    191  memristor PARAMS: InitStateVar=0.234065
X745    8    191  memristor PARAMS: InitStateVar=0.228877
X845    9    191  memristor PARAMS: InitStateVar=0.348858
X945    10   191  memristor PARAMS: InitStateVar=0.35338
X1045   11   191  memristor PARAMS: InitStateVar=0.216216
X1145   12   191  memristor PARAMS: InitStateVar=0.21766
X1245   13   191  memristor PARAMS: InitStateVar=0.337174
X1345   14   191  memristor PARAMS: InitStateVar=0.322174
X1445   15   191  memristor PARAMS: InitStateVar=0.166515
X1545   16   191  memristor PARAMS: InitStateVar=0.126415
X1645   17   191  memristor PARAMS: InitStateVar=0.322666
X1745   18   191  memristor PARAMS: InitStateVar=0.290719
X1845   19   191  memristor PARAMS: InitStateVar=0.254895
X1945   20   191  memristor PARAMS: InitStateVar=0.315419
X2045   21   191  memristor PARAMS: InitStateVar=0.236249
X2145   22   191  memristor PARAMS: InitStateVar=0.217532
X2245   23   191  memristor PARAMS: InitStateVar=0.308648
X2345   24   191  memristor PARAMS: InitStateVar=0.165858
X2445   25   191  memristor PARAMS: InitStateVar=0.345698
X2545   26   191  memristor PARAMS: InitStateVar=0.431022
X2645   27   191  memristor PARAMS: InitStateVar=0.227184
X2745   28   191  memristor PARAMS: InitStateVar=0.226486
X2845   29   191  memristor PARAMS: InitStateVar=0.234796
X2945   30   191  memristor PARAMS: InitStateVar=0.320512
X3045   31   191  memristor PARAMS: InitStateVar=0.258313
X3145   32   191  memristor PARAMS: InitStateVar=0.162371
X3245   33   191  memristor PARAMS: InitStateVar=0.46928
X3345   34   191  memristor PARAMS: InitStateVar=0.366438
X3445   35   191  memristor PARAMS: InitStateVar=0.477461
X3545   36   191  memristor PARAMS: InitStateVar=0.191373
X3645   37   191  memristor PARAMS: InitStateVar=0.442118
X3745   38   191  memristor PARAMS: InitStateVar=0.328486
X3845   39   191  memristor PARAMS: InitStateVar=0.186802
X3945   40   191  memristor PARAMS: InitStateVar=0.483846
X4045   41   191  memristor PARAMS: InitStateVar=0.216016
X4145   42   191  memristor PARAMS: InitStateVar=0.262056
X4245   43   191  memristor PARAMS: InitStateVar=0.375336
X4345   44   191  memristor PARAMS: InitStateVar=0.159152
X4445   45   191  memristor PARAMS: InitStateVar=0.119857
X4545   46   191  memristor PARAMS: InitStateVar=0.129886
X4645   47   191  memristor PARAMS: InitStateVar=0.302484
X4745   48   191  memristor PARAMS: InitStateVar=0.33455
X4845   49   191  memristor PARAMS: InitStateVar=0.231945
X4945   50   191  memristor PARAMS: InitStateVar=0.154058
X5045   51   191  memristor PARAMS: InitStateVar=0.261447
X5145   52   191  memristor PARAMS: InitStateVar=0.515698
X5245   53   191  memristor PARAMS: InitStateVar=0.321536
X5345   54   191  memristor PARAMS: InitStateVar=0.404578
X5445   55   191  memristor PARAMS: InitStateVar=0.182397
X5545   56   191  memristor PARAMS: InitStateVar=0.452053
X5645   57   191  memristor PARAMS: InitStateVar=0.225864
X5745   58   191  memristor PARAMS: InitStateVar=0.383679
X5845   59   191  memristor PARAMS: InitStateVar=0.309588
X5945   60   191  memristor PARAMS: InitStateVar=0.261812
X6045   61   191  memristor PARAMS: InitStateVar=0.172884
X6145   62   191  memristor PARAMS: InitStateVar=0.173219
X6245   63   191  memristor PARAMS: InitStateVar=0.26774
X6345   64   191  memristor PARAMS: InitStateVar=0.1108
X6445   65   191  memristor PARAMS: InitStateVar=0.163539
X6545   66   191  memristor PARAMS: InitStateVar=0.252459
X6645   67   191  memristor PARAMS: InitStateVar=0.328789
X6745   68   191  memristor PARAMS: InitStateVar=0.227718
X6845   69   191  memristor PARAMS: InitStateVar=0.270796
X6945   70   191  memristor PARAMS: InitStateVar=0.273119
X7045   71   191  memristor PARAMS: InitStateVar=0.382957
X7145   72   191  memristor PARAMS: InitStateVar=0.512281
X7245   73   191  memristor PARAMS: InitStateVar=0.253279
X7345   74   191  memristor PARAMS: InitStateVar=0.400622
X7445   75   191  memristor PARAMS: InitStateVar=0.375308
X7545   76   191  memristor PARAMS: InitStateVar=0.245952
X7645   77   191  memristor PARAMS: InitStateVar=0.316503
X7745   78   191  memristor PARAMS: InitStateVar=0.291418
X7845   79   191  memristor PARAMS: InitStateVar=0.254854
X7945   80   191  memristor PARAMS: InitStateVar=0.357055
X8045   81   191  memristor PARAMS: InitStateVar=0.20015
X8145   82   191  memristor PARAMS: InitStateVar=0.366496
X8245   83   191  memristor PARAMS: InitStateVar=0.149815
X8345   84   191  memristor PARAMS: InitStateVar=0.359348
X8445   85   191  memristor PARAMS: InitStateVar=0.0925778
X8545   86   191  memristor PARAMS: InitStateVar=0.255393
X8645   87   191  memristor PARAMS: InitStateVar=0.331918
X8745   88   191  memristor PARAMS: InitStateVar=0.41582
X8845   89   191  memristor PARAMS: InitStateVar=0.323891
X8945   90   191  memristor PARAMS: InitStateVar=0.294033
X9045   91   191  memristor PARAMS: InitStateVar=0.0543563
X9145   92   191  memristor PARAMS: InitStateVar=0.23614
X9245   93   191  memristor PARAMS: InitStateVar=0.364981
X9345   94   191  memristor PARAMS: InitStateVar=0.317023
X9445   95   191  memristor PARAMS: InitStateVar=0.422086
X9545   96   191  memristor PARAMS: InitStateVar=0.254762
X9645   97   191  memristor PARAMS: InitStateVar=0.274834
X9745   98   191  memristor PARAMS: InitStateVar=0.266329
X9845   99   191  memristor PARAMS: InitStateVar=0.211612
X9945   100  191  memristor PARAMS: InitStateVar=0.294103
Xo46    191  192  OutputModule PARAMS: Rval=100
*------------------- Column 47 -------------------------------------------------
X46     1    193  memristor PARAMS: InitStateVar=0.322441
X146    2    193  memristor PARAMS: InitStateVar=0.377048
X246    3    193  memristor PARAMS: InitStateVar=0.16219
X346    4    193  memristor PARAMS: InitStateVar=0.274264
X446    5    193  memristor PARAMS: InitStateVar=0.290418
X546    6    193  memristor PARAMS: InitStateVar=0.452069
X646    7    193  memristor PARAMS: InitStateVar=0.388492
X746    8    193  memristor PARAMS: InitStateVar=0.224361
X846    9    193  memristor PARAMS: InitStateVar=0.311634
X946    10   193  memristor PARAMS: InitStateVar=0.465572
X1046   11   193  memristor PARAMS: InitStateVar=0.530785
X1146   12   193  memristor PARAMS: InitStateVar=0.344661
X1246   13   193  memristor PARAMS: InitStateVar=0.239406
X1346   14   193  memristor PARAMS: InitStateVar=0.231135
X1446   15   193  memristor PARAMS: InitStateVar=0.268438
X1546   16   193  memristor PARAMS: InitStateVar=0.372165
X1646   17   193  memristor PARAMS: InitStateVar=0.226428
X1746   18   193  memristor PARAMS: InitStateVar=0.30135
X1846   19   193  memristor PARAMS: InitStateVar=0.234161
X1946   20   193  memristor PARAMS: InitStateVar=0.278944
X2046   21   193  memristor PARAMS: InitStateVar=0.314747
X2146   22   193  memristor PARAMS: InitStateVar=0.240517
X2246   23   193  memristor PARAMS: InitStateVar=0.248165
X2346   24   193  memristor PARAMS: InitStateVar=0.165995
X2446   25   193  memristor PARAMS: InitStateVar=0.347693
X2546   26   193  memristor PARAMS: InitStateVar=0.451498
X2646   27   193  memristor PARAMS: InitStateVar=0.251374
X2746   28   193  memristor PARAMS: InitStateVar=0.374277
X2846   29   193  memristor PARAMS: InitStateVar=0.252843
X2946   30   193  memristor PARAMS: InitStateVar=0.362565
X3046   31   193  memristor PARAMS: InitStateVar=0.352999
X3146   32   193  memristor PARAMS: InitStateVar=0.436337
X3246   33   193  memristor PARAMS: InitStateVar=0.334748
X3346   34   193  memristor PARAMS: InitStateVar=0.302695
X3446   35   193  memristor PARAMS: InitStateVar=0.321955
X3546   36   193  memristor PARAMS: InitStateVar=0.42659
X3646   37   193  memristor PARAMS: InitStateVar=0.166084
X3746   38   193  memristor PARAMS: InitStateVar=0.386618
X3846   39   193  memristor PARAMS: InitStateVar=0.28789
X3946   40   193  memristor PARAMS: InitStateVar=0.284148
X4046   41   193  memristor PARAMS: InitStateVar=0.253945
X4146   42   193  memristor PARAMS: InitStateVar=0.324589
X4246   43   193  memristor PARAMS: InitStateVar=0.306964
X4346   44   193  memristor PARAMS: InitStateVar=0.279199
X4446   45   193  memristor PARAMS: InitStateVar=0.360003
X4546   46   193  memristor PARAMS: InitStateVar=0.258095
X4646   47   193  memristor PARAMS: InitStateVar=0.288171
X4746   48   193  memristor PARAMS: InitStateVar=0.373166
X4846   49   193  memristor PARAMS: InitStateVar=0.117019
X4946   50   193  memristor PARAMS: InitStateVar=0.362456
X5046   51   193  memristor PARAMS: InitStateVar=0.286573
X5146   52   193  memristor PARAMS: InitStateVar=0.395922
X5246   53   193  memristor PARAMS: InitStateVar=0.219129
X5346   54   193  memristor PARAMS: InitStateVar=0.368343
X5446   55   193  memristor PARAMS: InitStateVar=0.444476
X5546   56   193  memristor PARAMS: InitStateVar=0.463154
X5646   57   193  memristor PARAMS: InitStateVar=0.285491
X5746   58   193  memristor PARAMS: InitStateVar=0.359556
X5846   59   193  memristor PARAMS: InitStateVar=0.177362
X5946   60   193  memristor PARAMS: InitStateVar=0.191888
X6046   61   193  memristor PARAMS: InitStateVar=0.232978
X6146   62   193  memristor PARAMS: InitStateVar=0.221764
X6246   63   193  memristor PARAMS: InitStateVar=0.155664
X6346   64   193  memristor PARAMS: InitStateVar=0.252918
X6446   65   193  memristor PARAMS: InitStateVar=0.169628
X6546   66   193  memristor PARAMS: InitStateVar=0.527928
X6646   67   193  memristor PARAMS: InitStateVar=0.269372
X6746   68   193  memristor PARAMS: InitStateVar=0.123585
X6846   69   193  memristor PARAMS: InitStateVar=0.216882
X6946   70   193  memristor PARAMS: InitStateVar=0.249194
X7046   71   193  memristor PARAMS: InitStateVar=0.360477
X7146   72   193  memristor PARAMS: InitStateVar=0.349238
X7246   73   193  memristor PARAMS: InitStateVar=0.252349
X7346   74   193  memristor PARAMS: InitStateVar=0.403689
X7446   75   193  memristor PARAMS: InitStateVar=0.357967
X7546   76   193  memristor PARAMS: InitStateVar=0.161996
X7646   77   193  memristor PARAMS: InitStateVar=0.269209
X7746   78   193  memristor PARAMS: InitStateVar=0.172441
X7846   79   193  memristor PARAMS: InitStateVar=0.237388
X7946   80   193  memristor PARAMS: InitStateVar=0.403044
X8046   81   193  memristor PARAMS: InitStateVar=0.442969
X8146   82   193  memristor PARAMS: InitStateVar=0.486783
X8246   83   193  memristor PARAMS: InitStateVar=0.312805
X8346   84   193  memristor PARAMS: InitStateVar=0.161064
X8446   85   193  memristor PARAMS: InitStateVar=0.258251
X8546   86   193  memristor PARAMS: InitStateVar=0.0850518
X8646   87   193  memristor PARAMS: InitStateVar=0.223647
X8746   88   193  memristor PARAMS: InitStateVar=0.276106
X8846   89   193  memristor PARAMS: InitStateVar=0.428514
X8946   90   193  memristor PARAMS: InitStateVar=0.442744
X9046   91   193  memristor PARAMS: InitStateVar=0.259234
X9146   92   193  memristor PARAMS: InitStateVar=0.381272
X9246   93   193  memristor PARAMS: InitStateVar=0.256129
X9346   94   193  memristor PARAMS: InitStateVar=0.34381
X9446   95   193  memristor PARAMS: InitStateVar=0.254671
X9546   96   193  memristor PARAMS: InitStateVar=0.345185
X9646   97   193  memristor PARAMS: InitStateVar=0.348094
X9746   98   193  memristor PARAMS: InitStateVar=0.287138
X9846   99   193  memristor PARAMS: InitStateVar=0.209055
X9946   100  193  memristor PARAMS: InitStateVar=0.390383
Xo47    193  194  OutputModule PARAMS: Rval=100
*------------------- Column 48 -------------------------------------------------
X47     1    195  memristor PARAMS: InitStateVar=0.412731
X147    2    195  memristor PARAMS: InitStateVar=0.423624
X247    3    195  memristor PARAMS: InitStateVar=0.343796
X347    4    195  memristor PARAMS: InitStateVar=0.289572
X447    5    195  memristor PARAMS: InitStateVar=0.260743
X547    6    195  memristor PARAMS: InitStateVar=0.256805
X647    7    195  memristor PARAMS: InitStateVar=0.343049
X747    8    195  memristor PARAMS: InitStateVar=0.315122
X847    9    195  memristor PARAMS: InitStateVar=0.558444
X947    10   195  memristor PARAMS: InitStateVar=0.3215
X1047   11   195  memristor PARAMS: InitStateVar=0.450154
X1147   12   195  memristor PARAMS: InitStateVar=0.258999
X1247   13   195  memristor PARAMS: InitStateVar=0.432401
X1347   14   195  memristor PARAMS: InitStateVar=0.298187
X1447   15   195  memristor PARAMS: InitStateVar=0.202722
X1547   16   195  memristor PARAMS: InitStateVar=0.26917
X1647   17   195  memristor PARAMS: InitStateVar=0.34344
X1747   18   195  memristor PARAMS: InitStateVar=0.276596
X1847   19   195  memristor PARAMS: InitStateVar=0.305656
X1947   20   195  memristor PARAMS: InitStateVar=0.396717
X2047   21   195  memristor PARAMS: InitStateVar=0.258891
X2147   22   195  memristor PARAMS: InitStateVar=0.495921
X2247   23   195  memristor PARAMS: InitStateVar=0.350973
X2347   24   195  memristor PARAMS: InitStateVar=0.159192
X2447   25   195  memristor PARAMS: InitStateVar=0.176678
X2547   26   195  memristor PARAMS: InitStateVar=0.307885
X2647   27   195  memristor PARAMS: InitStateVar=0.106812
X2747   28   195  memristor PARAMS: InitStateVar=0.361336
X2847   29   195  memristor PARAMS: InitStateVar=0.240779
X2947   30   195  memristor PARAMS: InitStateVar=0.336558
X3047   31   195  memristor PARAMS: InitStateVar=0.415174
X3147   32   195  memristor PARAMS: InitStateVar=0.319738
X3247   33   195  memristor PARAMS: InitStateVar=0.240165
X3347   34   195  memristor PARAMS: InitStateVar=0.333896
X3447   35   195  memristor PARAMS: InitStateVar=0.353414
X3547   36   195  memristor PARAMS: InitStateVar=0.273209
X3647   37   195  memristor PARAMS: InitStateVar=0.383197
X3747   38   195  memristor PARAMS: InitStateVar=0.192304
X3847   39   195  memristor PARAMS: InitStateVar=0.274926
X3947   40   195  memristor PARAMS: InitStateVar=0.350741
X4047   41   195  memristor PARAMS: InitStateVar=0.399773
X4147   42   195  memristor PARAMS: InitStateVar=-0.0167285
X4247   43   195  memristor PARAMS: InitStateVar=0.22288
X4347   44   195  memristor PARAMS: InitStateVar=0.302741
X4447   45   195  memristor PARAMS: InitStateVar=0.168906
X4547   46   195  memristor PARAMS: InitStateVar=0.41297
X4647   47   195  memristor PARAMS: InitStateVar=0.205796
X4747   48   195  memristor PARAMS: InitStateVar=0.278453
X4847   49   195  memristor PARAMS: InitStateVar=0.286112
X4947   50   195  memristor PARAMS: InitStateVar=0.200585
X5047   51   195  memristor PARAMS: InitStateVar=0.330352
X5147   52   195  memristor PARAMS: InitStateVar=0.264586
X5247   53   195  memristor PARAMS: InitStateVar=0.333741
X5347   54   195  memristor PARAMS: InitStateVar=0.36709
X5447   55   195  memristor PARAMS: InitStateVar=0.190702
X5547   56   195  memristor PARAMS: InitStateVar=0.381777
X5647   57   195  memristor PARAMS: InitStateVar=0.112893
X5747   58   195  memristor PARAMS: InitStateVar=0.376513
X5847   59   195  memristor PARAMS: InitStateVar=0.326576
X5947   60   195  memristor PARAMS: InitStateVar=0.362419
X6047   61   195  memristor PARAMS: InitStateVar=0.362461
X6147   62   195  memristor PARAMS: InitStateVar=0.289184
X6247   63   195  memristor PARAMS: InitStateVar=0.270795
X6347   64   195  memristor PARAMS: InitStateVar=0.394695
X6447   65   195  memristor PARAMS: InitStateVar=0.231009
X6547   66   195  memristor PARAMS: InitStateVar=0.315858
X6647   67   195  memristor PARAMS: InitStateVar=0.319486
X6747   68   195  memristor PARAMS: InitStateVar=0.2995
X6847   69   195  memristor PARAMS: InitStateVar=0.203258
X6947   70   195  memristor PARAMS: InitStateVar=0.594364
X7047   71   195  memristor PARAMS: InitStateVar=0.315477
X7147   72   195  memristor PARAMS: InitStateVar=0.383907
X7247   73   195  memristor PARAMS: InitStateVar=0.3437
X7347   74   195  memristor PARAMS: InitStateVar=0.307387
X7447   75   195  memristor PARAMS: InitStateVar=0.392286
X7547   76   195  memristor PARAMS: InitStateVar=0.381054
X7647   77   195  memristor PARAMS: InitStateVar=0.49464
X7747   78   195  memristor PARAMS: InitStateVar=0.215716
X7847   79   195  memristor PARAMS: InitStateVar=0.319086
X7947   80   195  memristor PARAMS: InitStateVar=0.341205
X8047   81   195  memristor PARAMS: InitStateVar=0.254845
X8147   82   195  memristor PARAMS: InitStateVar=0.301142
X8247   83   195  memristor PARAMS: InitStateVar=0.212679
X8347   84   195  memristor PARAMS: InitStateVar=0.235348
X8447   85   195  memristor PARAMS: InitStateVar=0.250463
X8547   86   195  memristor PARAMS: InitStateVar=0.226385
X8647   87   195  memristor PARAMS: InitStateVar=0.310639
X8747   88   195  memristor PARAMS: InitStateVar=0.266762
X8847   89   195  memristor PARAMS: InitStateVar=0.360054
X8947   90   195  memristor PARAMS: InitStateVar=0.292289
X9047   91   195  memristor PARAMS: InitStateVar=0.283608
X9147   92   195  memristor PARAMS: InitStateVar=0.252793
X9247   93   195  memristor PARAMS: InitStateVar=0.338915
X9347   94   195  memristor PARAMS: InitStateVar=0.290555
X9447   95   195  memristor PARAMS: InitStateVar=0.4518
X9547   96   195  memristor PARAMS: InitStateVar=0.287305
X9647   97   195  memristor PARAMS: InitStateVar=0.129296
X9747   98   195  memristor PARAMS: InitStateVar=0.240874
X9847   99   195  memristor PARAMS: InitStateVar=0.298283
X9947   100  195  memristor PARAMS: InitStateVar=0.160592
Xo48    195  196  OutputModule PARAMS: Rval=100
*------------------- Column 49 -------------------------------------------------
X48     1    197  memristor PARAMS: InitStateVar=0.25343
X148    2    197  memristor PARAMS: InitStateVar=0.198823
X248    3    197  memristor PARAMS: InitStateVar=0.26643
X348    4    197  memristor PARAMS: InitStateVar=0.292502
X448    5    197  memristor PARAMS: InitStateVar=0.244391
X548    6    197  memristor PARAMS: InitStateVar=0.259912
X648    7    197  memristor PARAMS: InitStateVar=0.0353089
X748    8    197  memristor PARAMS: InitStateVar=0.271354
X848    9    197  memristor PARAMS: InitStateVar=0.436442
X948    10   197  memristor PARAMS: InitStateVar=0.343871
X1048   11   197  memristor PARAMS: InitStateVar=0.162025
X1148   12   197  memristor PARAMS: InitStateVar=0.56973
X1248   13   197  memristor PARAMS: InitStateVar=0.366079
X1348   14   197  memristor PARAMS: InitStateVar=0.248827
X1448   15   197  memristor PARAMS: InitStateVar=0.275511
X1548   16   197  memristor PARAMS: InitStateVar=0.227082
X1648   17   197  memristor PARAMS: InitStateVar=0.0674477
X1748   18   197  memristor PARAMS: InitStateVar=0.326698
X1848   19   197  memristor PARAMS: InitStateVar=0.480385
X1948   20   197  memristor PARAMS: InitStateVar=0.119394
X2048   21   197  memristor PARAMS: InitStateVar=0.22922
X2148   22   197  memristor PARAMS: InitStateVar=0.385073
X2248   23   197  memristor PARAMS: InitStateVar=0.292301
X2348   24   197  memristor PARAMS: InitStateVar=0.301684
X2448   25   197  memristor PARAMS: InitStateVar=0.166417
X2548   26   197  memristor PARAMS: InitStateVar=0.196454
X2648   27   197  memristor PARAMS: InitStateVar=0.195477
X2748   28   197  memristor PARAMS: InitStateVar=0.271009
X2848   29   197  memristor PARAMS: InitStateVar=0.274209
X2948   30   197  memristor PARAMS: InitStateVar=0.347117
X3048   31   197  memristor PARAMS: InitStateVar=0.344283
X3148   32   197  memristor PARAMS: InitStateVar=0.276735
X3248   33   197  memristor PARAMS: InitStateVar=0.393069
X3348   34   197  memristor PARAMS: InitStateVar=0.303504
X3448   35   197  memristor PARAMS: InitStateVar=0.321806
X3548   36   197  memristor PARAMS: InitStateVar=0.374481
X3648   37   197  memristor PARAMS: InitStateVar=0.13789
X3748   38   197  memristor PARAMS: InitStateVar=0.186151
X3848   39   197  memristor PARAMS: InitStateVar=0.350902
X3948   40   197  memristor PARAMS: InitStateVar=0.252644
X4048   41   197  memristor PARAMS: InitStateVar=0.225605
X4148   42   197  memristor PARAMS: InitStateVar=0.234969
X4248   43   197  memristor PARAMS: InitStateVar=0.235513
X4348   44   197  memristor PARAMS: InitStateVar=0.149833
X4448   45   197  memristor PARAMS: InitStateVar=0.411299
X4548   46   197  memristor PARAMS: InitStateVar=0.305172
X4648   47   197  memristor PARAMS: InitStateVar=0.283357
X4748   48   197  memristor PARAMS: InitStateVar=0.270825
X4848   49   197  memristor PARAMS: InitStateVar=0.538748
X4948   50   197  memristor PARAMS: InitStateVar=0.265384
X5048   51   197  memristor PARAMS: InitStateVar=0.230914
X5148   52   197  memristor PARAMS: InitStateVar=0.127972
X5248   53   197  memristor PARAMS: InitStateVar=0.465854
X5348   54   197  memristor PARAMS: InitStateVar=0.123712
X5448   55   197  memristor PARAMS: InitStateVar=0.418666
X5548   56   197  memristor PARAMS: InitStateVar=0.291704
X5648   57   197  memristor PARAMS: InitStateVar=0.255067
X5748   58   197  memristor PARAMS: InitStateVar=0.330602
X5848   59   197  memristor PARAMS: InitStateVar=0.227275
X5948   60   197  memristor PARAMS: InitStateVar=0.375841
X6048   61   197  memristor PARAMS: InitStateVar=0.387699
X6148   62   197  memristor PARAMS: InitStateVar=0.136401
X6248   63   197  memristor PARAMS: InitStateVar=0.346687
X6348   64   197  memristor PARAMS: InitStateVar=0.310115
X6448   65   197  memristor PARAMS: InitStateVar=0.268613
X6548   66   197  memristor PARAMS: InitStateVar=0.257593
X6648   67   197  memristor PARAMS: InitStateVar=0.303609
X6748   68   197  memristor PARAMS: InitStateVar=0.311647
X6848   69   197  memristor PARAMS: InitStateVar=0.356766
X6948   70   197  memristor PARAMS: InitStateVar=0.316271
X7048   71   197  memristor PARAMS: InitStateVar=0.431937
X7148   72   197  memristor PARAMS: InitStateVar=0.357062
X7248   73   197  memristor PARAMS: InitStateVar=0.276084
X7348   74   197  memristor PARAMS: InitStateVar=0.335639
X7448   75   197  memristor PARAMS: InitStateVar=0.248821
X7548   76   197  memristor PARAMS: InitStateVar=0.233677
X7648   77   197  memristor PARAMS: InitStateVar=0.332779
X7748   78   197  memristor PARAMS: InitStateVar=0.221178
X7848   79   197  memristor PARAMS: InitStateVar=0.244206
X7948   80   197  memristor PARAMS: InitStateVar=0.19048
X8048   81   197  memristor PARAMS: InitStateVar=0.287232
X8148   82   197  memristor PARAMS: InitStateVar=0.372961
X8248   83   197  memristor PARAMS: InitStateVar=0.366445
X8348   84   197  memristor PARAMS: InitStateVar=0.291649
X8448   85   197  memristor PARAMS: InitStateVar=0.188878
X8548   86   197  memristor PARAMS: InitStateVar=0.366738
X8648   87   197  memristor PARAMS: InitStateVar=0.305961
X8748   88   197  memristor PARAMS: InitStateVar=0.184845
X8848   89   197  memristor PARAMS: InitStateVar=0.307331
X8948   90   197  memristor PARAMS: InitStateVar=0.328802
X9048   91   197  memristor PARAMS: InitStateVar=0.292113
X9148   92   197  memristor PARAMS: InitStateVar=0.413857
X9248   93   197  memristor PARAMS: InitStateVar=0.301395
X9348   94   197  memristor PARAMS: InitStateVar=0.241476
X9448   95   197  memristor PARAMS: InitStateVar=0.316274
X9548   96   197  memristor PARAMS: InitStateVar=0.464711
X9648   97   197  memristor PARAMS: InitStateVar=0.069793
X9748   98   197  memristor PARAMS: InitStateVar=0.378295
X9848   99   197  memristor PARAMS: InitStateVar=0.209515
X9948   100  197  memristor PARAMS: InitStateVar=0.27974
Xo49    197  198  OutputModule PARAMS: Rval=100
*------------------- Column 50 -------------------------------------------------
X49     1    199  memristor PARAMS: InitStateVar=0.293455
X149    2    199  memristor PARAMS: InitStateVar=0.264259
X249    3    199  memristor PARAMS: InitStateVar=0.384374
X349    4    199  memristor PARAMS: InitStateVar=0.274351
X449    5    199  memristor PARAMS: InitStateVar=0.259823
X549    6    199  memristor PARAMS: InitStateVar=0.417442
X649    7    199  memristor PARAMS: InitStateVar=0.33256
X749    8    199  memristor PARAMS: InitStateVar=0.216253
X849    9    199  memristor PARAMS: InitStateVar=0.259968
X949    10   199  memristor PARAMS: InitStateVar=0.287775
X1049   11   199  memristor PARAMS: InitStateVar=0.28875
X1149   12   199  memristor PARAMS: InitStateVar=0.298195
X1249   13   199  memristor PARAMS: InitStateVar=0.298607
X1349   14   199  memristor PARAMS: InitStateVar=0.210043
X1449   15   199  memristor PARAMS: InitStateVar=0.200181
X1549   16   199  memristor PARAMS: InitStateVar=0.252114
X1649   17   199  memristor PARAMS: InitStateVar=0.132043
X1749   18   199  memristor PARAMS: InitStateVar=0.417721
X1849   19   199  memristor PARAMS: InitStateVar=0.327035
X1949   20   199  memristor PARAMS: InitStateVar=0.233894
X2049   21   199  memristor PARAMS: InitStateVar=0.277919
X2149   22   199  memristor PARAMS: InitStateVar=0.362535
X2249   23   199  memristor PARAMS: InitStateVar=0.251831
X2349   24   199  memristor PARAMS: InitStateVar=0.402497
X2449   25   199  memristor PARAMS: InitStateVar=0.254572
X2549   26   199  memristor PARAMS: InitStateVar=0.470372
X2649   27   199  memristor PARAMS: InitStateVar=0.145164
X2749   28   199  memristor PARAMS: InitStateVar=0.404302
X2849   29   199  memristor PARAMS: InitStateVar=0.315677
X2949   30   199  memristor PARAMS: InitStateVar=0.271388
X3049   31   199  memristor PARAMS: InitStateVar=0.265764
X3149   32   199  memristor PARAMS: InitStateVar=0.292774
X3249   33   199  memristor PARAMS: InitStateVar=0.350153
X3349   34   199  memristor PARAMS: InitStateVar=0.169675
X3449   35   199  memristor PARAMS: InitStateVar=0.268628
X3549   36   199  memristor PARAMS: InitStateVar=0.378887
X3649   37   199  memristor PARAMS: InitStateVar=0.21292
X3749   38   199  memristor PARAMS: InitStateVar=0.235146
X3849   39   199  memristor PARAMS: InitStateVar=0.146555
X3949   40   199  memristor PARAMS: InitStateVar=0.203562
X4049   41   199  memristor PARAMS: InitStateVar=0.295466
X4149   42   199  memristor PARAMS: InitStateVar=0.428246
X4249   43   199  memristor PARAMS: InitStateVar=0.496115
X4349   44   199  memristor PARAMS: InitStateVar=0.485197
X4449   45   199  memristor PARAMS: InitStateVar=0.404909
X4549   46   199  memristor PARAMS: InitStateVar=0.161923
X4649   47   199  memristor PARAMS: InitStateVar=0.233102
X4749   48   199  memristor PARAMS: InitStateVar=0.508059
X4849   49   199  memristor PARAMS: InitStateVar=0.35309
X4949   50   199  memristor PARAMS: InitStateVar=0.207526
X5049   51   199  memristor PARAMS: InitStateVar=0.198966
X5149   52   199  memristor PARAMS: InitStateVar=0.297532
X5249   53   199  memristor PARAMS: InitStateVar=0.135172
X5349   54   199  memristor PARAMS: InitStateVar=0.268444
X5449   55   199  memristor PARAMS: InitStateVar=0.348016
X5549   56   199  memristor PARAMS: InitStateVar=0.274802
X5649   57   199  memristor PARAMS: InitStateVar=0.202937
X5749   58   199  memristor PARAMS: InitStateVar=0.230044
X5849   59   199  memristor PARAMS: InitStateVar=0.231519
X5949   60   199  memristor PARAMS: InitStateVar=0.305888
X6049   61   199  memristor PARAMS: InitStateVar=0.197803
X6149   62   199  memristor PARAMS: InitStateVar=0.349243
X6249   63   199  memristor PARAMS: InitStateVar=0.162567
X6349   64   199  memristor PARAMS: InitStateVar=0.402978
X6449   65   199  memristor PARAMS: InitStateVar=0.422905
X6549   66   199  memristor PARAMS: InitStateVar=0.336968
X6649   67   199  memristor PARAMS: InitStateVar=0.275158
X6749   68   199  memristor PARAMS: InitStateVar=0.347092
X6849   69   199  memristor PARAMS: InitStateVar=0.399782
X6949   70   199  memristor PARAMS: InitStateVar=0.232494
X7049   71   199  memristor PARAMS: InitStateVar=0.263031
X7149   72   199  memristor PARAMS: InitStateVar=0.317969
X7249   73   199  memristor PARAMS: InitStateVar=0.104401
X7349   74   199  memristor PARAMS: InitStateVar=0.355813
X7449   75   199  memristor PARAMS: InitStateVar=0.314857
X7549   76   199  memristor PARAMS: InitStateVar=0.456373
X7649   77   199  memristor PARAMS: InitStateVar=0.286468
X7749   78   199  memristor PARAMS: InitStateVar=0.233087
X7849   79   199  memristor PARAMS: InitStateVar=0.248063
X7949   80   199  memristor PARAMS: InitStateVar=0.18716
X8049   81   199  memristor PARAMS: InitStateVar=0.278726
X8149   82   199  memristor PARAMS: InitStateVar=0.225642
X8249   83   199  memristor PARAMS: InitStateVar=0.296559
X8349   84   199  memristor PARAMS: InitStateVar=0.313093
X8449   85   199  memristor PARAMS: InitStateVar=0.416516
X8549   86   199  memristor PARAMS: InitStateVar=0.0670463
X8649   87   199  memristor PARAMS: InitStateVar=0.304275
X8749   88   199  memristor PARAMS: InitStateVar=0.425651
X8849   89   199  memristor PARAMS: InitStateVar=0.454922
X8949   90   199  memristor PARAMS: InitStateVar=0.272914
X9049   91   199  memristor PARAMS: InitStateVar=0.287448
X9149   92   199  memristor PARAMS: InitStateVar=0.296811
X9249   93   199  memristor PARAMS: InitStateVar=0.482906
X9349   94   199  memristor PARAMS: InitStateVar=0.349452
X9449   95   199  memristor PARAMS: InitStateVar=0.43228
X9549   96   199  memristor PARAMS: InitStateVar=0.181481
X9649   97   199  memristor PARAMS: InitStateVar=0.226763
X9749   98   199  memristor PARAMS: InitStateVar=0.270681
X9849   99   199  memristor PARAMS: InitStateVar=0.356239
X9949   100  199  memristor PARAMS: InitStateVar=0.298179
Xo50    199  200  OutputModule PARAMS: Rval=100
*------------------- Column 51 -------------------------------------------------
X50     1    201  memristor PARAMS: InitStateVar=0.364959
X150    2    201  memristor PARAMS: InitStateVar=0.293265
X250    3    201  memristor PARAMS: InitStateVar=0.288331
X350    4    201  memristor PARAMS: InitStateVar=0.332937
X450    5    201  memristor PARAMS: InitStateVar=0.37433
X550    6    201  memristor PARAMS: InitStateVar=0.360621
X650    7    201  memristor PARAMS: InitStateVar=0.50324
X750    8    201  memristor PARAMS: InitStateVar=0.30154
X850    9    201  memristor PARAMS: InitStateVar=0.206498
X950    10   201  memristor PARAMS: InitStateVar=0.330327
X1050   11   201  memristor PARAMS: InitStateVar=0.211316
X1150   12   201  memristor PARAMS: InitStateVar=0.206737
X1250   13   201  memristor PARAMS: InitStateVar=0.288168
X1350   14   201  memristor PARAMS: InitStateVar=0.379723
X1450   15   201  memristor PARAMS: InitStateVar=0.397063
X1550   16   201  memristor PARAMS: InitStateVar=0.117348
X1650   17   201  memristor PARAMS: InitStateVar=0.199678
X1750   18   201  memristor PARAMS: InitStateVar=0.356843
X1850   19   201  memristor PARAMS: InitStateVar=0.164734
X1950   20   201  memristor PARAMS: InitStateVar=0.254972
X2050   21   201  memristor PARAMS: InitStateVar=0.320116
X2150   22   201  memristor PARAMS: InitStateVar=0.194044
X2250   23   201  memristor PARAMS: InitStateVar=0.327507
X2350   24   201  memristor PARAMS: InitStateVar=0.341446
X2450   25   201  memristor PARAMS: InitStateVar=0.363245
X2550   26   201  memristor PARAMS: InitStateVar=0.412966
X2650   27   201  memristor PARAMS: InitStateVar=0.33321
X2750   28   201  memristor PARAMS: InitStateVar=0.269484
X2850   29   201  memristor PARAMS: InitStateVar=0.293579
X2950   30   201  memristor PARAMS: InitStateVar=0.341699
X3050   31   201  memristor PARAMS: InitStateVar=0.334056
X3150   32   201  memristor PARAMS: InitStateVar=0.343516
X3250   33   201  memristor PARAMS: InitStateVar=0.21415
X3350   34   201  memristor PARAMS: InitStateVar=0.277876
X3450   35   201  memristor PARAMS: InitStateVar=0.409639
X3550   36   201  memristor PARAMS: InitStateVar=0.0959188
X3650   37   201  memristor PARAMS: InitStateVar=0.183621
X3750   38   201  memristor PARAMS: InitStateVar=0.400544
X3850   39   201  memristor PARAMS: InitStateVar=0.271135
X3950   40   201  memristor PARAMS: InitStateVar=0.521768
X4050   41   201  memristor PARAMS: InitStateVar=0.223285
X4150   42   201  memristor PARAMS: InitStateVar=0.32573
X4250   43   201  memristor PARAMS: InitStateVar=0.242543
X4350   44   201  memristor PARAMS: InitStateVar=0.358221
X4450   45   201  memristor PARAMS: InitStateVar=0.177258
X4550   46   201  memristor PARAMS: InitStateVar=0.264364
X4650   47   201  memristor PARAMS: InitStateVar=0.262396
X4750   48   201  memristor PARAMS: InitStateVar=0.314645
X4850   49   201  memristor PARAMS: InitStateVar=0.283653
X4950   50   201  memristor PARAMS: InitStateVar=0.379591
X5050   51   201  memristor PARAMS: InitStateVar=0.238477
X5150   52   201  memristor PARAMS: InitStateVar=0.364277
X5250   53   201  memristor PARAMS: InitStateVar=0.326176
X5350   54   201  memristor PARAMS: InitStateVar=0.154525
X5450   55   201  memristor PARAMS: InitStateVar=0.470375
X5550   56   201  memristor PARAMS: InitStateVar=0.332689
X5650   57   201  memristor PARAMS: InitStateVar=0.301569
X5750   58   201  memristor PARAMS: InitStateVar=0.11067
X5850   59   201  memristor PARAMS: InitStateVar=0.317857
X5950   60   201  memristor PARAMS: InitStateVar=0.273015
X6050   61   201  memristor PARAMS: InitStateVar=0.357006
X6150   62   201  memristor PARAMS: InitStateVar=0.348371
X6250   63   201  memristor PARAMS: InitStateVar=0.37766
X6350   64   201  memristor PARAMS: InitStateVar=0.112994
X6450   65   201  memristor PARAMS: InitStateVar=0.113491
X6550   66   201  memristor PARAMS: InitStateVar=0.339874
X6650   67   201  memristor PARAMS: InitStateVar=0.261885
X6750   68   201  memristor PARAMS: InitStateVar=0.326931
X6850   69   201  memristor PARAMS: InitStateVar=0.297409
X6950   70   201  memristor PARAMS: InitStateVar=0.197348
X7050   71   201  memristor PARAMS: InitStateVar=0.378899
X7150   72   201  memristor PARAMS: InitStateVar=0.27734
X7250   73   201  memristor PARAMS: InitStateVar=0.193821
X7350   74   201  memristor PARAMS: InitStateVar=0.341787
X7450   75   201  memristor PARAMS: InitStateVar=0.418924
X7550   76   201  memristor PARAMS: InitStateVar=0.373553
X7650   77   201  memristor PARAMS: InitStateVar=0.459144
X7750   78   201  memristor PARAMS: InitStateVar=0.376261
X7850   79   201  memristor PARAMS: InitStateVar=0.214087
X7950   80   201  memristor PARAMS: InitStateVar=0.337065
X8050   81   201  memristor PARAMS: InitStateVar=0.180332
X8150   82   201  memristor PARAMS: InitStateVar=0.54642
X8250   83   201  memristor PARAMS: InitStateVar=0.366552
X8350   84   201  memristor PARAMS: InitStateVar=0.378633
X8450   85   201  memristor PARAMS: InitStateVar=0.389349
X8550   86   201  memristor PARAMS: InitStateVar=0.287379
X8650   87   201  memristor PARAMS: InitStateVar=0.213499
X8750   88   201  memristor PARAMS: InitStateVar=0.0574174
X8850   89   201  memristor PARAMS: InitStateVar=0.267413
X8950   90   201  memristor PARAMS: InitStateVar=0.297404
X9050   91   201  memristor PARAMS: InitStateVar=0.140316
X9150   92   201  memristor PARAMS: InitStateVar=0.295644
X9250   93   201  memristor PARAMS: InitStateVar=0.24415
X9350   94   201  memristor PARAMS: InitStateVar=0.19257
X9450   95   201  memristor PARAMS: InitStateVar=0.381792
X9550   96   201  memristor PARAMS: InitStateVar=0.195691
X9650   97   201  memristor PARAMS: InitStateVar=0.441893
X9750   98   201  memristor PARAMS: InitStateVar=0.164248
X9850   99   201  memristor PARAMS: InitStateVar=0.499764
X9950   100  201  memristor PARAMS: InitStateVar=0.469464
Xo51    201  202  OutputModule PARAMS: Rval=100
*------------------- Column 52 -------------------------------------------------
X51     1    203  memristor PARAMS: InitStateVar=0.398627
X151    2    203  memristor PARAMS: InitStateVar=0.386675
X251    3    203  memristor PARAMS: InitStateVar=0.359838
X351    4    203  memristor PARAMS: InitStateVar=0.169377
X451    5    203  memristor PARAMS: InitStateVar=0.355481
X551    6    203  memristor PARAMS: InitStateVar=0.243686
X651    7    203  memristor PARAMS: InitStateVar=0.346961
X751    8    203  memristor PARAMS: InitStateVar=0.30912
X851    9    203  memristor PARAMS: InitStateVar=0.423262
X951    10   203  memristor PARAMS: InitStateVar=0.31513
X1051   11   203  memristor PARAMS: InitStateVar=0.35735
X1151   12   203  memristor PARAMS: InitStateVar=0.337735
X1251   13   203  memristor PARAMS: InitStateVar=0.31304
X1351   14   203  memristor PARAMS: InitStateVar=0.234471
X1451   15   203  memristor PARAMS: InitStateVar=0.225877
X1551   16   203  memristor PARAMS: InitStateVar=0.226547
X1651   17   203  memristor PARAMS: InitStateVar=0.463484
X1751   18   203  memristor PARAMS: InitStateVar=0.327453
X1851   19   203  memristor PARAMS: InitStateVar=0.206345
X1951   20   203  memristor PARAMS: InitStateVar=0.316219
X2051   21   203  memristor PARAMS: InitStateVar=0.363131
X2151   22   203  memristor PARAMS: InitStateVar=0.370822
X2251   23   203  memristor PARAMS: InitStateVar=0.0811001
X2351   24   203  memristor PARAMS: InitStateVar=0.191837
X2451   25   203  memristor PARAMS: InitStateVar=0.245274
X2551   26   203  memristor PARAMS: InitStateVar=0.179995
X2651   27   203  memristor PARAMS: InitStateVar=0.33993
X2751   28   203  memristor PARAMS: InitStateVar=0.392229
X2851   29   203  memristor PARAMS: InitStateVar=0.22814
X2951   30   203  memristor PARAMS: InitStateVar=0.243846
X3051   31   203  memristor PARAMS: InitStateVar=0.281091
X3151   32   203  memristor PARAMS: InitStateVar=0.296281
X3251   33   203  memristor PARAMS: InitStateVar=0.314607
X3351   34   203  memristor PARAMS: InitStateVar=0.216679
X3451   35   203  memristor PARAMS: InitStateVar=0.283
X3551   36   203  memristor PARAMS: InitStateVar=0.226675
X3651   37   203  memristor PARAMS: InitStateVar=0.061437
X3751   38   203  memristor PARAMS: InitStateVar=0.423991
X3851   39   203  memristor PARAMS: InitStateVar=0.212347
X3951   40   203  memristor PARAMS: InitStateVar=0.341574
X4051   41   203  memristor PARAMS: InitStateVar=0.440034
X4151   42   203  memristor PARAMS: InitStateVar=0.215734
X4251   43   203  memristor PARAMS: InitStateVar=0.264635
X4351   44   203  memristor PARAMS: InitStateVar=0.295227
X4451   45   203  memristor PARAMS: InitStateVar=0.366121
X4551   46   203  memristor PARAMS: InitStateVar=0.0973695
X4651   47   203  memristor PARAMS: InitStateVar=0.28305
X4751   48   203  memristor PARAMS: InitStateVar=0.340735
X4851   49   203  memristor PARAMS: InitStateVar=0.203106
X4951   50   203  memristor PARAMS: InitStateVar=0.418389
X5051   51   203  memristor PARAMS: InitStateVar=0.445046
X5151   52   203  memristor PARAMS: InitStateVar=0.229687
X5251   53   203  memristor PARAMS: InitStateVar=0.282366
X5351   54   203  memristor PARAMS: InitStateVar=0.425985
X5451   55   203  memristor PARAMS: InitStateVar=0.370104
X5551   56   203  memristor PARAMS: InitStateVar=0.392624
X5651   57   203  memristor PARAMS: InitStateVar=0.467671
X5751   58   203  memristor PARAMS: InitStateVar=0.282835
X5851   59   203  memristor PARAMS: InitStateVar=0.315528
X5951   60   203  memristor PARAMS: InitStateVar=0.259904
X6051   61   203  memristor PARAMS: InitStateVar=0.258293
X6151   62   203  memristor PARAMS: InitStateVar=0.253929
X6251   63   203  memristor PARAMS: InitStateVar=0.343821
X6351   64   203  memristor PARAMS: InitStateVar=0.115521
X6451   65   203  memristor PARAMS: InitStateVar=0.175547
X6551   66   203  memristor PARAMS: InitStateVar=0.344634
X6651   67   203  memristor PARAMS: InitStateVar=0.318599
X6751   68   203  memristor PARAMS: InitStateVar=0.245188
X6851   69   203  memristor PARAMS: InitStateVar=0.236423
X6951   70   203  memristor PARAMS: InitStateVar=0.298895
X7051   71   203  memristor PARAMS: InitStateVar=0.400758
X7151   72   203  memristor PARAMS: InitStateVar=0.11065
X7251   73   203  memristor PARAMS: InitStateVar=0.293422
X7351   74   203  memristor PARAMS: InitStateVar=0.22367
X7451   75   203  memristor PARAMS: InitStateVar=0.393515
X7551   76   203  memristor PARAMS: InitStateVar=0.33022
X7651   77   203  memristor PARAMS: InitStateVar=0.316243
X7751   78   203  memristor PARAMS: InitStateVar=0.229488
X7851   79   203  memristor PARAMS: InitStateVar=0.125223
X7951   80   203  memristor PARAMS: InitStateVar=0.542624
X8051   81   203  memristor PARAMS: InitStateVar=0.338373
X8151   82   203  memristor PARAMS: InitStateVar=0.34129
X8251   83   203  memristor PARAMS: InitStateVar=0.368613
X8351   84   203  memristor PARAMS: InitStateVar=0.509711
X8451   85   203  memristor PARAMS: InitStateVar=0.376865
X8551   86   203  memristor PARAMS: InitStateVar=0.363256
X8651   87   203  memristor PARAMS: InitStateVar=0.342256
X8751   88   203  memristor PARAMS: InitStateVar=0.329502
X8851   89   203  memristor PARAMS: InitStateVar=0.365474
X8951   90   203  memristor PARAMS: InitStateVar=0.351776
X9051   91   203  memristor PARAMS: InitStateVar=0.392082
X9151   92   203  memristor PARAMS: InitStateVar=0.398153
X9251   93   203  memristor PARAMS: InitStateVar=0.355928
X9351   94   203  memristor PARAMS: InitStateVar=0.192449
X9451   95   203  memristor PARAMS: InitStateVar=0.357727
X9551   96   203  memristor PARAMS: InitStateVar=0.357385
X9651   97   203  memristor PARAMS: InitStateVar=0.208598
X9751   98   203  memristor PARAMS: InitStateVar=0.400139
X9851   99   203  memristor PARAMS: InitStateVar=0.309556
X9951   100  203  memristor PARAMS: InitStateVar=0.425841
Xo52    203  204  OutputModule PARAMS: Rval=100
*------------------- Column 53 -------------------------------------------------
X52     1    205  memristor PARAMS: InitStateVar=0.264662
X152    2    205  memristor PARAMS: InitStateVar=0.301206
X252    3    205  memristor PARAMS: InitStateVar=0.339099
X352    4    205  memristor PARAMS: InitStateVar=0.343543
X452    5    205  memristor PARAMS: InitStateVar=0.256466
X552    6    205  memristor PARAMS: InitStateVar=0.312058
X652    7    205  memristor PARAMS: InitStateVar=0.269261
X752    8    205  memristor PARAMS: InitStateVar=0.36466
X852    9    205  memristor PARAMS: InitStateVar=0.169048
X952    10   205  memristor PARAMS: InitStateVar=0.334922
X1052   11   205  memristor PARAMS: InitStateVar=0.168907
X1152   12   205  memristor PARAMS: InitStateVar=0.350185
X1252   13   205  memristor PARAMS: InitStateVar=0.304508
X1352   14   205  memristor PARAMS: InitStateVar=0.36053
X1452   15   205  memristor PARAMS: InitStateVar=0.112855
X1552   16   205  memristor PARAMS: InitStateVar=0.314822
X1652   17   205  memristor PARAMS: InitStateVar=0.36821
X1752   18   205  memristor PARAMS: InitStateVar=0.399015
X1852   19   205  memristor PARAMS: InitStateVar=0.284498
X1952   20   205  memristor PARAMS: InitStateVar=0.302546
X2052   21   205  memristor PARAMS: InitStateVar=0.313072
X2152   22   205  memristor PARAMS: InitStateVar=0.400183
X2252   23   205  memristor PARAMS: InitStateVar=0.373885
X2352   24   205  memristor PARAMS: InitStateVar=0.292744
X2452   25   205  memristor PARAMS: InitStateVar=0.138408
X2552   26   205  memristor PARAMS: InitStateVar=0.221124
X2652   27   205  memristor PARAMS: InitStateVar=0.322954
X2752   28   205  memristor PARAMS: InitStateVar=0.246781
X2852   29   205  memristor PARAMS: InitStateVar=0.225801
X2952   30   205  memristor PARAMS: InitStateVar=0.182731
X3052   31   205  memristor PARAMS: InitStateVar=0.328853
X3152   32   205  memristor PARAMS: InitStateVar=0.344022
X3252   33   205  memristor PARAMS: InitStateVar=0.397389
X3352   34   205  memristor PARAMS: InitStateVar=0.305169
X3452   35   205  memristor PARAMS: InitStateVar=0.0689066
X3552   36   205  memristor PARAMS: InitStateVar=0.325698
X3652   37   205  memristor PARAMS: InitStateVar=0.342385
X3752   38   205  memristor PARAMS: InitStateVar=0.428632
X3852   39   205  memristor PARAMS: InitStateVar=0.354459
X3952   40   205  memristor PARAMS: InitStateVar=0.33109
X4052   41   205  memristor PARAMS: InitStateVar=0.230978
X4152   42   205  memristor PARAMS: InitStateVar=0.236822
X4252   43   205  memristor PARAMS: InitStateVar=0.413245
X4352   44   205  memristor PARAMS: InitStateVar=0.242486
X4452   45   205  memristor PARAMS: InitStateVar=0.317538
X4552   46   205  memristor PARAMS: InitStateVar=0.37698
X4652   47   205  memristor PARAMS: InitStateVar=0.208781
X4752   48   205  memristor PARAMS: InitStateVar=0.224317
X4852   49   205  memristor PARAMS: InitStateVar=0.439217
X4952   50   205  memristor PARAMS: InitStateVar=0.222486
X5052   51   205  memristor PARAMS: InitStateVar=0.154389
X5152   52   205  memristor PARAMS: InitStateVar=0.249221
X5252   53   205  memristor PARAMS: InitStateVar=0.240211
X5352   54   205  memristor PARAMS: InitStateVar=0.132524
X5452   55   205  memristor PARAMS: InitStateVar=0.216156
X5552   56   205  memristor PARAMS: InitStateVar=0.220764
X5652   57   205  memristor PARAMS: InitStateVar=0.399724
X5752   58   205  memristor PARAMS: InitStateVar=0.303994
X5852   59   205  memristor PARAMS: InitStateVar=0.343292
X5952   60   205  memristor PARAMS: InitStateVar=0.450583
X6052   61   205  memristor PARAMS: InitStateVar=0.28235
X6152   62   205  memristor PARAMS: InitStateVar=0.0722728
X6252   63   205  memristor PARAMS: InitStateVar=0.110878
X6352   64   205  memristor PARAMS: InitStateVar=0.296808
X6452   65   205  memristor PARAMS: InitStateVar=0.117036
X6552   66   205  memristor PARAMS: InitStateVar=0.376262
X6652   67   205  memristor PARAMS: InitStateVar=0.288212
X6752   68   205  memristor PARAMS: InitStateVar=0.187126
X6852   69   205  memristor PARAMS: InitStateVar=0.350624
X6952   70   205  memristor PARAMS: InitStateVar=0.176625
X7052   71   205  memristor PARAMS: InitStateVar=0.215782
X7152   72   205  memristor PARAMS: InitStateVar=0.453833
X7252   73   205  memristor PARAMS: InitStateVar=0.455588
X7352   74   205  memristor PARAMS: InitStateVar=0.208022
X7452   75   205  memristor PARAMS: InitStateVar=0.215031
X7552   76   205  memristor PARAMS: InitStateVar=0.235646
X7652   77   205  memristor PARAMS: InitStateVar=0.285514
X7752   78   205  memristor PARAMS: InitStateVar=0.181125
X7852   79   205  memristor PARAMS: InitStateVar=0.254216
X7952   80   205  memristor PARAMS: InitStateVar=0.281831
X8052   81   205  memristor PARAMS: InitStateVar=0.231298
X8152   82   205  memristor PARAMS: InitStateVar=0.286197
X8252   83   205  memristor PARAMS: InitStateVar=0.300448
X8352   84   205  memristor PARAMS: InitStateVar=0.241554
X8452   85   205  memristor PARAMS: InitStateVar=0.374573
X8552   86   205  memristor PARAMS: InitStateVar=0.409436
X8652   87   205  memristor PARAMS: InitStateVar=0.447065
X8752   88   205  memristor PARAMS: InitStateVar=0.191142
X8852   89   205  memristor PARAMS: InitStateVar=0.143889
X8952   90   205  memristor PARAMS: InitStateVar=0.360863
X9052   91   205  memristor PARAMS: InitStateVar=0.21027
X9152   92   205  memristor PARAMS: InitStateVar=0.198435
X9252   93   205  memristor PARAMS: InitStateVar=0.185629
X9352   94   205  memristor PARAMS: InitStateVar=0.310086
X9452   95   205  memristor PARAMS: InitStateVar=0.377544
X9552   96   205  memristor PARAMS: InitStateVar=0.457239
X9652   97   205  memristor PARAMS: InitStateVar=0.277653
X9752   98   205  memristor PARAMS: InitStateVar=0.379379
X9852   99   205  memristor PARAMS: InitStateVar=0.326684
X9952   100  205  memristor PARAMS: InitStateVar=0.343095
Xo53    205  206  OutputModule PARAMS: Rval=100
*------------------- Column 54 -------------------------------------------------
X53     1    207  memristor PARAMS: InitStateVar=0.372336
X153    2    207  memristor PARAMS: InitStateVar=0.296293
X253    3    207  memristor PARAMS: InitStateVar=0.320338
X353    4    207  memristor PARAMS: InitStateVar=0.168788
X453    5    207  memristor PARAMS: InitStateVar=0.29742
X553    6    207  memristor PARAMS: InitStateVar=0.277041
X653    7    207  memristor PARAMS: InitStateVar=0.216808
X753    8    207  memristor PARAMS: InitStateVar=0.290172
X853    9    207  memristor PARAMS: InitStateVar=0.324192
X953    10   207  memristor PARAMS: InitStateVar=0.50121
X1053   11   207  memristor PARAMS: InitStateVar=0.282301
X1153   12   207  memristor PARAMS: InitStateVar=0.418478
X1253   13   207  memristor PARAMS: InitStateVar=0.223586
X1353   14   207  memristor PARAMS: InitStateVar=0.3363
X1453   15   207  memristor PARAMS: InitStateVar=0.339979
X1553   16   207  memristor PARAMS: InitStateVar=0.383559
X1653   17   207  memristor PARAMS: InitStateVar=0.290044
X1753   18   207  memristor PARAMS: InitStateVar=0.2165
X1853   19   207  memristor PARAMS: InitStateVar=0.233441
X1953   20   207  memristor PARAMS: InitStateVar=0.281896
X2053   21   207  memristor PARAMS: InitStateVar=0.511078
X2153   22   207  memristor PARAMS: InitStateVar=0.176059
X2253   23   207  memristor PARAMS: InitStateVar=0.265196
X2353   24   207  memristor PARAMS: InitStateVar=0.16596
X2453   25   207  memristor PARAMS: InitStateVar=0.111597
X2553   26   207  memristor PARAMS: InitStateVar=0.237465
X2653   27   207  memristor PARAMS: InitStateVar=0.394593
X2753   28   207  memristor PARAMS: InitStateVar=0.242314
X2853   29   207  memristor PARAMS: InitStateVar=0.317838
X2953   30   207  memristor PARAMS: InitStateVar=0.454112
X3053   31   207  memristor PARAMS: InitStateVar=0.367689
X3153   32   207  memristor PARAMS: InitStateVar=0.444218
X3253   33   207  memristor PARAMS: InitStateVar=0.421052
X3353   34   207  memristor PARAMS: InitStateVar=0.35869
X3453   35   207  memristor PARAMS: InitStateVar=0.345871
X3553   36   207  memristor PARAMS: InitStateVar=0.274633
X3653   37   207  memristor PARAMS: InitStateVar=0.461096
X3753   38   207  memristor PARAMS: InitStateVar=0.287411
X3853   39   207  memristor PARAMS: InitStateVar=0.242214
X3953   40   207  memristor PARAMS: InitStateVar=0.409397
X4053   41   207  memristor PARAMS: InitStateVar=0.163309
X4153   42   207  memristor PARAMS: InitStateVar=0.416282
X4253   43   207  memristor PARAMS: InitStateVar=0.218097
X4353   44   207  memristor PARAMS: InitStateVar=0.257604
X4453   45   207  memristor PARAMS: InitStateVar=0.21714
X4553   46   207  memristor PARAMS: InitStateVar=0.142746
X4653   47   207  memristor PARAMS: InitStateVar=0.287092
X4753   48   207  memristor PARAMS: InitStateVar=0.44106
X4853   49   207  memristor PARAMS: InitStateVar=0.434328
X4953   50   207  memristor PARAMS: InitStateVar=0.334007
X5053   51   207  memristor PARAMS: InitStateVar=0.357273
X5153   52   207  memristor PARAMS: InitStateVar=0.524606
X5253   53   207  memristor PARAMS: InitStateVar=0.453283
X5353   54   207  memristor PARAMS: InitStateVar=0.340323
X5453   55   207  memristor PARAMS: InitStateVar=0.301917
X5553   56   207  memristor PARAMS: InitStateVar=0.460289
X5653   57   207  memristor PARAMS: InitStateVar=0.222797
X5753   58   207  memristor PARAMS: InitStateVar=0.376431
X5853   59   207  memristor PARAMS: InitStateVar=0.414404
X5953   60   207  memristor PARAMS: InitStateVar=0.169035
X6053   61   207  memristor PARAMS: InitStateVar=0.31543
X6153   62   207  memristor PARAMS: InitStateVar=0.440891
X6253   63   207  memristor PARAMS: InitStateVar=0.476778
X6353   64   207  memristor PARAMS: InitStateVar=0.317029
X6453   65   207  memristor PARAMS: InitStateVar=0.327629
X6553   66   207  memristor PARAMS: InitStateVar=0.288016
X6653   67   207  memristor PARAMS: InitStateVar=0.386221
X6753   68   207  memristor PARAMS: InitStateVar=0.253908
X6853   69   207  memristor PARAMS: InitStateVar=0.220097
X6953   70   207  memristor PARAMS: InitStateVar=0.181135
X7053   71   207  memristor PARAMS: InitStateVar=0.232701
X7153   72   207  memristor PARAMS: InitStateVar=0.49404
X7253   73   207  memristor PARAMS: InitStateVar=0.479717
X7353   74   207  memristor PARAMS: InitStateVar=0.401077
X7453   75   207  memristor PARAMS: InitStateVar=0.381296
X7553   76   207  memristor PARAMS: InitStateVar=0.220792
X7653   77   207  memristor PARAMS: InitStateVar=0.292843
X7753   78   207  memristor PARAMS: InitStateVar=0.31822
X7853   79   207  memristor PARAMS: InitStateVar=0.239712
X7953   80   207  memristor PARAMS: InitStateVar=0.238188
X8053   81   207  memristor PARAMS: InitStateVar=0.262782
X8153   82   207  memristor PARAMS: InitStateVar=0.382301
X8253   83   207  memristor PARAMS: InitStateVar=0.51568
X8353   84   207  memristor PARAMS: InitStateVar=0.157673
X8453   85   207  memristor PARAMS: InitStateVar=0.298644
X8553   86   207  memristor PARAMS: InitStateVar=0.31233
X8653   87   207  memristor PARAMS: InitStateVar=0.310921
X8753   88   207  memristor PARAMS: InitStateVar=0.407178
X8853   89   207  memristor PARAMS: InitStateVar=0.350357
X8953   90   207  memristor PARAMS: InitStateVar=0.257504
X9053   91   207  memristor PARAMS: InitStateVar=0.3359
X9153   92   207  memristor PARAMS: InitStateVar=0.178509
X9253   93   207  memristor PARAMS: InitStateVar=0.520106
X9353   94   207  memristor PARAMS: InitStateVar=0.43283
X9453   95   207  memristor PARAMS: InitStateVar=0.283036
X9553   96   207  memristor PARAMS: InitStateVar=0.339246
X9653   97   207  memristor PARAMS: InitStateVar=0.385973
X9753   98   207  memristor PARAMS: InitStateVar=0.222253
X9853   99   207  memristor PARAMS: InitStateVar=0.343456
X9953   100  207  memristor PARAMS: InitStateVar=0.10828
Xo54    207  208  OutputModule PARAMS: Rval=100
*------------------- Column 55 -------------------------------------------------
X54     1    209  memristor PARAMS: InitStateVar=0.309617
X154    2    209  memristor PARAMS: InitStateVar=0.387715
X254    3    209  memristor PARAMS: InitStateVar=0.327062
X354    4    209  memristor PARAMS: InitStateVar=0.370521
X454    5    209  memristor PARAMS: InitStateVar=0.334649
X554    6    209  memristor PARAMS: InitStateVar=0.193633
X654    7    209  memristor PARAMS: InitStateVar=0.116277
X754    8    209  memristor PARAMS: InitStateVar=0.369429
X854    9    209  memristor PARAMS: InitStateVar=0.155457
X954    10   209  memristor PARAMS: InitStateVar=0.321083
X1054   11   209  memristor PARAMS: InitStateVar=0.521638
X1154   12   209  memristor PARAMS: InitStateVar=0.286133
X1254   13   209  memristor PARAMS: InitStateVar=0.359984
X1354   14   209  memristor PARAMS: InitStateVar=0.213109
X1454   15   209  memristor PARAMS: InitStateVar=0.215368
X1554   16   209  memristor PARAMS: InitStateVar=0.299173
X1654   17   209  memristor PARAMS: InitStateVar=0.441197
X1754   18   209  memristor PARAMS: InitStateVar=0.280521
X1854   19   209  memristor PARAMS: InitStateVar=0.312158
X1954   20   209  memristor PARAMS: InitStateVar=0.369524
X2054   21   209  memristor PARAMS: InitStateVar=0.35094
X2154   22   209  memristor PARAMS: InitStateVar=0.466855
X2254   23   209  memristor PARAMS: InitStateVar=0.105526
X2354   24   209  memristor PARAMS: InitStateVar=0.278673
X2454   25   209  memristor PARAMS: InitStateVar=0.310873
X2554   26   209  memristor PARAMS: InitStateVar=0.401205
X2654   27   209  memristor PARAMS: InitStateVar=0.451682
X2754   28   209  memristor PARAMS: InitStateVar=0.494605
X2854   29   209  memristor PARAMS: InitStateVar=0.487227
X2954   30   209  memristor PARAMS: InitStateVar=0.205351
X3054   31   209  memristor PARAMS: InitStateVar=0.328905
X3154   32   209  memristor PARAMS: InitStateVar=0.287215
X3254   33   209  memristor PARAMS: InitStateVar=0.473212
X3354   34   209  memristor PARAMS: InitStateVar=0.32139
X3454   35   209  memristor PARAMS: InitStateVar=0.329839
X3554   36   209  memristor PARAMS: InitStateVar=0.218671
X3654   37   209  memristor PARAMS: InitStateVar=0.173938
X3754   38   209  memristor PARAMS: InitStateVar=0.369543
X3854   39   209  memristor PARAMS: InitStateVar=0.232522
X3954   40   209  memristor PARAMS: InitStateVar=0.505268
X4054   41   209  memristor PARAMS: InitStateVar=0.182621
X4154   42   209  memristor PARAMS: InitStateVar=0.28221
X4254   43   209  memristor PARAMS: InitStateVar=0.321818
X4354   44   209  memristor PARAMS: InitStateVar=0.267279
X4454   45   209  memristor PARAMS: InitStateVar=0.479737
X4554   46   209  memristor PARAMS: InitStateVar=0.34429
X4654   47   209  memristor PARAMS: InitStateVar=0.414132
X4754   48   209  memristor PARAMS: InitStateVar=0.162856
X4854   49   209  memristor PARAMS: InitStateVar=0.44053
X4954   50   209  memristor PARAMS: InitStateVar=0.221211
X5054   51   209  memristor PARAMS: InitStateVar=0.314888
X5154   52   209  memristor PARAMS: InitStateVar=0.288387
X5254   53   209  memristor PARAMS: InitStateVar=0.110686
X5354   54   209  memristor PARAMS: InitStateVar=0.335081
X5454   55   209  memristor PARAMS: InitStateVar=0.401271
X5554   56   209  memristor PARAMS: InitStateVar=0.180178
X5654   57   209  memristor PARAMS: InitStateVar=0.287406
X5754   58   209  memristor PARAMS: InitStateVar=0.220169
X5854   59   209  memristor PARAMS: InitStateVar=0.488145
X5954   60   209  memristor PARAMS: InitStateVar=0.29299
X6054   61   209  memristor PARAMS: InitStateVar=0.211831
X6154   62   209  memristor PARAMS: InitStateVar=0.306291
X6254   63   209  memristor PARAMS: InitStateVar=0.22317
X6354   64   209  memristor PARAMS: InitStateVar=0.374037
X6454   65   209  memristor PARAMS: InitStateVar=0.299365
X6554   66   209  memristor PARAMS: InitStateVar=0.214242
X6654   67   209  memristor PARAMS: InitStateVar=0.274128
X6754   68   209  memristor PARAMS: InitStateVar=0.419195
X6854   69   209  memristor PARAMS: InitStateVar=0.225757
X6954   70   209  memristor PARAMS: InitStateVar=0.389765
X7054   71   209  memristor PARAMS: InitStateVar=0.267947
X7154   72   209  memristor PARAMS: InitStateVar=0.25828
X7254   73   209  memristor PARAMS: InitStateVar=0.192001
X7354   74   209  memristor PARAMS: InitStateVar=0.209854
X7454   75   209  memristor PARAMS: InitStateVar=0.333918
X7554   76   209  memristor PARAMS: InitStateVar=0.47459
X7654   77   209  memristor PARAMS: InitStateVar=0.368623
X7754   78   209  memristor PARAMS: InitStateVar=0.104318
X7854   79   209  memristor PARAMS: InitStateVar=0.492276
X7954   80   209  memristor PARAMS: InitStateVar=0.244558
X8054   81   209  memristor PARAMS: InitStateVar=0.243194
X8154   82   209  memristor PARAMS: InitStateVar=0.233823
X8254   83   209  memristor PARAMS: InitStateVar=0.347509
X8354   84   209  memristor PARAMS: InitStateVar=0.393358
X8454   85   209  memristor PARAMS: InitStateVar=0.287814
X8554   86   209  memristor PARAMS: InitStateVar=0.199133
X8654   87   209  memristor PARAMS: InitStateVar=0.260696
X8754   88   209  memristor PARAMS: InitStateVar=0.232023
X8854   89   209  memristor PARAMS: InitStateVar=0.461327
X8954   90   209  memristor PARAMS: InitStateVar=0.256523
X9054   91   209  memristor PARAMS: InitStateVar=0.302854
X9154   92   209  memristor PARAMS: InitStateVar=0.393584
X9254   93   209  memristor PARAMS: InitStateVar=0.277293
X9354   94   209  memristor PARAMS: InitStateVar=0.398516
X9454   95   209  memristor PARAMS: InitStateVar=0.354266
X9554   96   209  memristor PARAMS: InitStateVar=0.223436
X9654   97   209  memristor PARAMS: InitStateVar=0.464335
X9754   98   209  memristor PARAMS: InitStateVar=0.257472
X9854   99   209  memristor PARAMS: InitStateVar=0.247444
X9954   100  209  memristor PARAMS: InitStateVar=0.376728
Xo55    209  210  OutputModule PARAMS: Rval=100
*------------------- Column 56 -------------------------------------------------
X55     1    211  memristor PARAMS: InitStateVar=0.276685
X155    2    211  memristor PARAMS: InitStateVar=0.290578
X255    3    211  memristor PARAMS: InitStateVar=0.327161
X355    4    211  memristor PARAMS: InitStateVar=0.311382
X455    5    211  memristor PARAMS: InitStateVar=0.179745
X555    6    211  memristor PARAMS: InitStateVar=0.226769
X655    7    211  memristor PARAMS: InitStateVar=0.277903
X755    8    211  memristor PARAMS: InitStateVar=0.106331
X855    9    211  memristor PARAMS: InitStateVar=0.37624
X955    10   211  memristor PARAMS: InitStateVar=0.284793
X1055   11   211  memristor PARAMS: InitStateVar=0.376807
X1155   12   211  memristor PARAMS: InitStateVar=0.229602
X1255   13   211  memristor PARAMS: InitStateVar=0.310527
X1355   14   211  memristor PARAMS: InitStateVar=0.280663
X1455   15   211  memristor PARAMS: InitStateVar=0.248469
X1555   16   211  memristor PARAMS: InitStateVar=0.43833
X1655   17   211  memristor PARAMS: InitStateVar=0.367462
X1755   18   211  memristor PARAMS: InitStateVar=0.391077
X1855   19   211  memristor PARAMS: InitStateVar=0.319064
X1955   20   211  memristor PARAMS: InitStateVar=0.346513
X2055   21   211  memristor PARAMS: InitStateVar=0.32592
X2155   22   211  memristor PARAMS: InitStateVar=0.492206
X2255   23   211  memristor PARAMS: InitStateVar=0.244875
X2355   24   211  memristor PARAMS: InitStateVar=0.459123
X2455   25   211  memristor PARAMS: InitStateVar=0.345364
X2555   26   211  memristor PARAMS: InitStateVar=0.316124
X2655   27   211  memristor PARAMS: InitStateVar=0.387471
X2755   28   211  memristor PARAMS: InitStateVar=0.167503
X2855   29   211  memristor PARAMS: InitStateVar=0.337892
X2955   30   211  memristor PARAMS: InitStateVar=0.153033
X3055   31   211  memristor PARAMS: InitStateVar=0.468689
X3155   32   211  memristor PARAMS: InitStateVar=0.183809
X3255   33   211  memristor PARAMS: InitStateVar=0.337821
X3355   34   211  memristor PARAMS: InitStateVar=0.408529
X3455   35   211  memristor PARAMS: InitStateVar=0.300165
X3555   36   211  memristor PARAMS: InitStateVar=0.229402
X3655   37   211  memristor PARAMS: InitStateVar=0.33585
X3755   38   211  memristor PARAMS: InitStateVar=0.36641
X3855   39   211  memristor PARAMS: InitStateVar=0.119142
X3955   40   211  memristor PARAMS: InitStateVar=0.379718
X4055   41   211  memristor PARAMS: InitStateVar=0.110349
X4155   42   211  memristor PARAMS: InitStateVar=0.36678
X4255   43   211  memristor PARAMS: InitStateVar=0.373643
X4355   44   211  memristor PARAMS: InitStateVar=0.309015
X4455   45   211  memristor PARAMS: InitStateVar=0.258754
X4555   46   211  memristor PARAMS: InitStateVar=0.418409
X4655   47   211  memristor PARAMS: InitStateVar=0.376325
X4755   48   211  memristor PARAMS: InitStateVar=0.294278
X4855   49   211  memristor PARAMS: InitStateVar=0.477468
X4955   50   211  memristor PARAMS: InitStateVar=0.153845
X5055   51   211  memristor PARAMS: InitStateVar=0.459686
X5155   52   211  memristor PARAMS: InitStateVar=0.444787
X5255   53   211  memristor PARAMS: InitStateVar=0.330274
X5355   54   211  memristor PARAMS: InitStateVar=0.377525
X5455   55   211  memristor PARAMS: InitStateVar=0.503568
X5555   56   211  memristor PARAMS: InitStateVar=0.150186
X5655   57   211  memristor PARAMS: InitStateVar=0.231456
X5755   58   211  memristor PARAMS: InitStateVar=0.361984
X5855   59   211  memristor PARAMS: InitStateVar=0.35669
X5955   60   211  memristor PARAMS: InitStateVar=0.195878
X6055   61   211  memristor PARAMS: InitStateVar=0.207111
X6155   62   211  memristor PARAMS: InitStateVar=0.231437
X6255   63   211  memristor PARAMS: InitStateVar=0.288486
X6355   64   211  memristor PARAMS: InitStateVar=0.340733
X6455   65   211  memristor PARAMS: InitStateVar=0.30718
X6555   66   211  memristor PARAMS: InitStateVar=0.139154
X6655   67   211  memristor PARAMS: InitStateVar=0.280011
X6755   68   211  memristor PARAMS: InitStateVar=0.444354
X6855   69   211  memristor PARAMS: InitStateVar=0.402717
X6955   70   211  memristor PARAMS: InitStateVar=0.466159
X7055   71   211  memristor PARAMS: InitStateVar=0.333441
X7155   72   211  memristor PARAMS: InitStateVar=0.298888
X7255   73   211  memristor PARAMS: InitStateVar=0.240214
X7355   74   211  memristor PARAMS: InitStateVar=0.289157
X7455   75   211  memristor PARAMS: InitStateVar=0.141503
X7555   76   211  memristor PARAMS: InitStateVar=0.48841
X7655   77   211  memristor PARAMS: InitStateVar=0.340725
X7755   78   211  memristor PARAMS: InitStateVar=0.389208
X7855   79   211  memristor PARAMS: InitStateVar=0.249114
X7955   80   211  memristor PARAMS: InitStateVar=0.330003
X8055   81   211  memristor PARAMS: InitStateVar=0.300964
X8155   82   211  memristor PARAMS: InitStateVar=0.136113
X8255   83   211  memristor PARAMS: InitStateVar=0.419152
X8355   84   211  memristor PARAMS: InitStateVar=0.364725
X8455   85   211  memristor PARAMS: InitStateVar=0.20938
X8555   86   211  memristor PARAMS: InitStateVar=0.450032
X8655   87   211  memristor PARAMS: InitStateVar=0.350194
X8755   88   211  memristor PARAMS: InitStateVar=0.226279
X8855   89   211  memristor PARAMS: InitStateVar=0.317734
X8955   90   211  memristor PARAMS: InitStateVar=0.218048
X9055   91   211  memristor PARAMS: InitStateVar=0.29202
X9155   92   211  memristor PARAMS: InitStateVar=0.320609
X9255   93   211  memristor PARAMS: InitStateVar=0.291479
X9355   94   211  memristor PARAMS: InitStateVar=0.387457
X9455   95   211  memristor PARAMS: InitStateVar=0.437909
X9555   96   211  memristor PARAMS: InitStateVar=0.447856
X9655   97   211  memristor PARAMS: InitStateVar=0.394265
X9755   98   211  memristor PARAMS: InitStateVar=0.39539
X9855   99   211  memristor PARAMS: InitStateVar=0.0434965
X9955   100  211  memristor PARAMS: InitStateVar=0.177616
Xo56    211  212  OutputModule PARAMS: Rval=100
*------------------- Column 57 -------------------------------------------------
X56     1    213  memristor PARAMS: InitStateVar=0.185818
X156    2    213  memristor PARAMS: InitStateVar=0.434534
X256    3    213  memristor PARAMS: InitStateVar=0.310163
X356    4    213  memristor PARAMS: InitStateVar=0.221012
X456    5    213  memristor PARAMS: InitStateVar=0.344889
X556    6    213  memristor PARAMS: InitStateVar=0.340795
X656    7    213  memristor PARAMS: InitStateVar=0.190959
X756    8    213  memristor PARAMS: InitStateVar=0.471822
X856    9    213  memristor PARAMS: InitStateVar=0.161811
X956    10   213  memristor PARAMS: InitStateVar=0.433869
X1056   11   213  memristor PARAMS: InitStateVar=0.204392
X1156   12   213  memristor PARAMS: InitStateVar=0.272287
X1256   13   213  memristor PARAMS: InitStateVar=0.316981
X1356   14   213  memristor PARAMS: InitStateVar=0.247434
X1456   15   213  memristor PARAMS: InitStateVar=0.432208
X1556   16   213  memristor PARAMS: InitStateVar=0.268914
X1656   17   213  memristor PARAMS: InitStateVar=0.210602
X1756   18   213  memristor PARAMS: InitStateVar=0.301028
X1856   19   213  memristor PARAMS: InitStateVar=0.38819
X1956   20   213  memristor PARAMS: InitStateVar=0.143157
X2056   21   213  memristor PARAMS: InitStateVar=0.526333
X2156   22   213  memristor PARAMS: InitStateVar=0.231847
X2256   23   213  memristor PARAMS: InitStateVar=0.128269
X2356   24   213  memristor PARAMS: InitStateVar=0.45543
X2456   25   213  memristor PARAMS: InitStateVar=0.280366
X2556   26   213  memristor PARAMS: InitStateVar=0.24797
X2656   27   213  memristor PARAMS: InitStateVar=0.250625
X2756   28   213  memristor PARAMS: InitStateVar=0.316932
X2856   29   213  memristor PARAMS: InitStateVar=0.223831
X2956   30   213  memristor PARAMS: InitStateVar=0.324483
X3056   31   213  memristor PARAMS: InitStateVar=0.299637
X3156   32   213  memristor PARAMS: InitStateVar=0.286975
X3256   33   213  memristor PARAMS: InitStateVar=0.245629
X3356   34   213  memristor PARAMS: InitStateVar=0.266848
X3456   35   213  memristor PARAMS: InitStateVar=0.272815
X3556   36   213  memristor PARAMS: InitStateVar=0.232382
X3656   37   213  memristor PARAMS: InitStateVar=0.356701
X3756   38   213  memristor PARAMS: InitStateVar=0.312456
X3856   39   213  memristor PARAMS: InitStateVar=0.197641
X3956   40   213  memristor PARAMS: InitStateVar=0.146046
X4056   41   213  memristor PARAMS: InitStateVar=0.32028
X4156   42   213  memristor PARAMS: InitStateVar=0.411499
X4256   43   213  memristor PARAMS: InitStateVar=0.325577
X4356   44   213  memristor PARAMS: InitStateVar=0.32673
X4456   45   213  memristor PARAMS: InitStateVar=0.218116
X4556   46   213  memristor PARAMS: InitStateVar=0.365432
X4656   47   213  memristor PARAMS: InitStateVar=0.547802
X4756   48   213  memristor PARAMS: InitStateVar=0.365829
X4856   49   213  memristor PARAMS: InitStateVar=0.295674
X4956   50   213  memristor PARAMS: InitStateVar=0.332255
X5056   51   213  memristor PARAMS: InitStateVar=0.455135
X5156   52   213  memristor PARAMS: InitStateVar=0.393506
X5256   53   213  memristor PARAMS: InitStateVar=0.263217
X5356   54   213  memristor PARAMS: InitStateVar=0.354706
X5456   55   213  memristor PARAMS: InitStateVar=0.167402
X5556   56   213  memristor PARAMS: InitStateVar=0.269008
X5656   57   213  memristor PARAMS: InitStateVar=0.295943
X5756   58   213  memristor PARAMS: InitStateVar=0.420105
X5856   59   213  memristor PARAMS: InitStateVar=0.398439
X5956   60   213  memristor PARAMS: InitStateVar=0.162344
X6056   61   213  memristor PARAMS: InitStateVar=0.362644
X6156   62   213  memristor PARAMS: InitStateVar=0.40551
X6256   63   213  memristor PARAMS: InitStateVar=0.374094
X6356   64   213  memristor PARAMS: InitStateVar=0.228339
X6456   65   213  memristor PARAMS: InitStateVar=0.353379
X6556   66   213  memristor PARAMS: InitStateVar=0.0737393
X6656   67   213  memristor PARAMS: InitStateVar=0.161645
X6756   68   213  memristor PARAMS: InitStateVar=0.234432
X6856   69   213  memristor PARAMS: InitStateVar=0.418744
X6956   70   213  memristor PARAMS: InitStateVar=0.132105
X7056   71   213  memristor PARAMS: InitStateVar=0.381707
X7156   72   213  memristor PARAMS: InitStateVar=0.400744
X7256   73   213  memristor PARAMS: InitStateVar=0.214029
X7356   74   213  memristor PARAMS: InitStateVar=0.180671
X7456   75   213  memristor PARAMS: InitStateVar=0.31327
X7556   76   213  memristor PARAMS: InitStateVar=0.362837
X7656   77   213  memristor PARAMS: InitStateVar=0.304427
X7756   78   213  memristor PARAMS: InitStateVar=0.445327
X7856   79   213  memristor PARAMS: InitStateVar=0.423832
X7956   80   213  memristor PARAMS: InitStateVar=0.405507
X8056   81   213  memristor PARAMS: InitStateVar=0.455272
X8156   82   213  memristor PARAMS: InitStateVar=0.389665
X8256   83   213  memristor PARAMS: InitStateVar=0.332471
X8356   84   213  memristor PARAMS: InitStateVar=0.309004
X8456   85   213  memristor PARAMS: InitStateVar=0.245127
X8556   86   213  memristor PARAMS: InitStateVar=0.391884
X8656   87   213  memristor PARAMS: InitStateVar=0.293195
X8756   88   213  memristor PARAMS: InitStateVar=0.260147
X8856   89   213  memristor PARAMS: InitStateVar=0.37017
X8956   90   213  memristor PARAMS: InitStateVar=0.200322
X9056   91   213  memristor PARAMS: InitStateVar=0.146724
X9156   92   213  memristor PARAMS: InitStateVar=0.312529
X9256   93   213  memristor PARAMS: InitStateVar=0.269706
X9356   94   213  memristor PARAMS: InitStateVar=0.212131
X9456   95   213  memristor PARAMS: InitStateVar=0.427102
X9556   96   213  memristor PARAMS: InitStateVar=0.331408
X9656   97   213  memristor PARAMS: InitStateVar=0.44465
X9756   98   213  memristor PARAMS: InitStateVar=0.357627
X9856   99   213  memristor PARAMS: InitStateVar=0.137248
X9956   100  213  memristor PARAMS: InitStateVar=0.364258
Xo57    213  214  OutputModule PARAMS: Rval=100
*------------------- Column 58 -------------------------------------------------
X57     1    215  memristor PARAMS: InitStateVar=0.295242
X157    2    215  memristor PARAMS: InitStateVar=0.182452
X257    3    215  memristor PARAMS: InitStateVar=0.237126
X357    4    215  memristor PARAMS: InitStateVar=0.48875
X457    5    215  memristor PARAMS: InitStateVar=0.197041
X557    6    215  memristor PARAMS: InitStateVar=0.348801
X657    7    215  memristor PARAMS: InitStateVar=0.458773
X757    8    215  memristor PARAMS: InitStateVar=0.393578
X857    9    215  memristor PARAMS: InitStateVar=0.326361
X957    10   215  memristor PARAMS: InitStateVar=0.445117
X1057   11   215  memristor PARAMS: InitStateVar=0.466694
X1157   12   215  memristor PARAMS: InitStateVar=0.254482
X1257   13   215  memristor PARAMS: InitStateVar=0.259218
X1357   14   215  memristor PARAMS: InitStateVar=0.240241
X1457   15   215  memristor PARAMS: InitStateVar=0.327236
X1557   16   215  memristor PARAMS: InitStateVar=0.36131
X1657   17   215  memristor PARAMS: InitStateVar=0.150918
X1757   18   215  memristor PARAMS: InitStateVar=0.256439
X1857   19   215  memristor PARAMS: InitStateVar=0.2814
X1957   20   215  memristor PARAMS: InitStateVar=0.501961
X2057   21   215  memristor PARAMS: InitStateVar=0.238012
X2157   22   215  memristor PARAMS: InitStateVar=0.46857
X2257   23   215  memristor PARAMS: InitStateVar=0.151301
X2357   24   215  memristor PARAMS: InitStateVar=0.335653
X2457   25   215  memristor PARAMS: InitStateVar=0.311116
X2557   26   215  memristor PARAMS: InitStateVar=0.171103
X2657   27   215  memristor PARAMS: InitStateVar=0.427338
X2757   28   215  memristor PARAMS: InitStateVar=0.564678
X2857   29   215  memristor PARAMS: InitStateVar=0.449863
X2957   30   215  memristor PARAMS: InitStateVar=0.26823
X3057   31   215  memristor PARAMS: InitStateVar=0.382995
X3157   32   215  memristor PARAMS: InitStateVar=0.220805
X3257   33   215  memristor PARAMS: InitStateVar=0.421781
X3357   34   215  memristor PARAMS: InitStateVar=0.310104
X3457   35   215  memristor PARAMS: InitStateVar=0.297311
X3557   36   215  memristor PARAMS: InitStateVar=0.279677
X3657   37   215  memristor PARAMS: InitStateVar=0.458231
X3757   38   215  memristor PARAMS: InitStateVar=0.324837
X3857   39   215  memristor PARAMS: InitStateVar=0.288372
X3957   40   215  memristor PARAMS: InitStateVar=0.344365
X4057   41   215  memristor PARAMS: InitStateVar=0.232763
X4157   42   215  memristor PARAMS: InitStateVar=0.313076
X4257   43   215  memristor PARAMS: InitStateVar=0.472585
X4357   44   215  memristor PARAMS: InitStateVar=0.309
X4457   45   215  memristor PARAMS: InitStateVar=0.223788
X4557   46   215  memristor PARAMS: InitStateVar=0.18584
X4657   47   215  memristor PARAMS: InitStateVar=0.26817
X4757   48   215  memristor PARAMS: InitStateVar=0.383394
X4857   49   215  memristor PARAMS: InitStateVar=0.177625
X4957   50   215  memristor PARAMS: InitStateVar=0.225818
X5057   51   215  memristor PARAMS: InitStateVar=0.238771
X5157   52   215  memristor PARAMS: InitStateVar=0.266353
X5257   53   215  memristor PARAMS: InitStateVar=0.157249
X5357   54   215  memristor PARAMS: InitStateVar=0.301735
X5457   55   215  memristor PARAMS: InitStateVar=0.268488
X5557   56   215  memristor PARAMS: InitStateVar=0.358279
X5657   57   215  memristor PARAMS: InitStateVar=0.246182
X5757   58   215  memristor PARAMS: InitStateVar=0.457944
X5857   59   215  memristor PARAMS: InitStateVar=0.34851
X5957   60   215  memristor PARAMS: InitStateVar=0.371781
X6057   61   215  memristor PARAMS: InitStateVar=0.223479
X6157   62   215  memristor PARAMS: InitStateVar=0.141418
X6257   63   215  memristor PARAMS: InitStateVar=0.25147
X6357   64   215  memristor PARAMS: InitStateVar=0.367501
X6457   65   215  memristor PARAMS: InitStateVar=0.181393
X6557   66   215  memristor PARAMS: InitStateVar=0.303708
X6657   67   215  memristor PARAMS: InitStateVar=0.19907
X6757   68   215  memristor PARAMS: InitStateVar=0.246987
X6857   69   215  memristor PARAMS: InitStateVar=0.365805
X6957   70   215  memristor PARAMS: InitStateVar=0.35188
X7057   71   215  memristor PARAMS: InitStateVar=0.217022
X7157   72   215  memristor PARAMS: InitStateVar=0.362154
X7257   73   215  memristor PARAMS: InitStateVar=0.270109
X7357   74   215  memristor PARAMS: InitStateVar=0.457101
X7457   75   215  memristor PARAMS: InitStateVar=0.31761
X7557   76   215  memristor PARAMS: InitStateVar=0.463823
X7657   77   215  memristor PARAMS: InitStateVar=0.175932
X7757   78   215  memristor PARAMS: InitStateVar=0.193837
X7857   79   215  memristor PARAMS: InitStateVar=0.165848
X7957   80   215  memristor PARAMS: InitStateVar=0.309656
X8057   81   215  memristor PARAMS: InitStateVar=0.258402
X8157   82   215  memristor PARAMS: InitStateVar=0.257181
X8257   83   215  memristor PARAMS: InitStateVar=0.334162
X8357   84   215  memristor PARAMS: InitStateVar=0.208793
X8457   85   215  memristor PARAMS: InitStateVar=0.243767
X8557   86   215  memristor PARAMS: InitStateVar=0.250513
X8657   87   215  memristor PARAMS: InitStateVar=0.258879
X8757   88   215  memristor PARAMS: InitStateVar=0.242145
X8857   89   215  memristor PARAMS: InitStateVar=0.200938
X8957   90   215  memristor PARAMS: InitStateVar=0.132408
X9057   91   215  memristor PARAMS: InitStateVar=0.321719
X9157   92   215  memristor PARAMS: InitStateVar=0.402754
X9257   93   215  memristor PARAMS: InitStateVar=0.397386
X9357   94   215  memristor PARAMS: InitStateVar=0.537752
X9457   95   215  memristor PARAMS: InitStateVar=0.483226
X9557   96   215  memristor PARAMS: InitStateVar=0.17199
X9657   97   215  memristor PARAMS: InitStateVar=0.306739
X9757   98   215  memristor PARAMS: InitStateVar=0.376773
X9857   99   215  memristor PARAMS: InitStateVar=0.535337
X9957   100  215  memristor PARAMS: InitStateVar=0.190645
Xo58    215  216  OutputModule PARAMS: Rval=100
*------------------- Column 59 -------------------------------------------------
X58     1    217  memristor PARAMS: InitStateVar=0.342328
X158    2    217  memristor PARAMS: InitStateVar=0.399745
X258    3    217  memristor PARAMS: InitStateVar=0.230276
X358    4    217  memristor PARAMS: InitStateVar=0.211808
X458    5    217  memristor PARAMS: InitStateVar=0.266766
X558    6    217  memristor PARAMS: InitStateVar=0.40486
X658    7    217  memristor PARAMS: InitStateVar=0.359313
X758    8    217  memristor PARAMS: InitStateVar=0.327178
X858    9    217  memristor PARAMS: InitStateVar=0.325426
X958    10   217  memristor PARAMS: InitStateVar=0.33515
X1058   11   217  memristor PARAMS: InitStateVar=0.495323
X1158   12   217  memristor PARAMS: InitStateVar=0.199432
X1258   13   217  memristor PARAMS: InitStateVar=0.274079
X1358   14   217  memristor PARAMS: InitStateVar=0.153894
X1458   15   217  memristor PARAMS: InitStateVar=0.250226
X1558   16   217  memristor PARAMS: InitStateVar=0.322601
X1658   17   217  memristor PARAMS: InitStateVar=0.414059
X1758   18   217  memristor PARAMS: InitStateVar=0.328671
X1858   19   217  memristor PARAMS: InitStateVar=0.235555
X1958   20   217  memristor PARAMS: InitStateVar=0.202986
X2058   21   217  memristor PARAMS: InitStateVar=0.277307
X2158   22   217  memristor PARAMS: InitStateVar=0.173075
X2258   23   217  memristor PARAMS: InitStateVar=0.331626
X2358   24   217  memristor PARAMS: InitStateVar=0.260248
X2458   25   217  memristor PARAMS: InitStateVar=0.366872
X2558   26   217  memristor PARAMS: InitStateVar=0.286549
X2658   27   217  memristor PARAMS: InitStateVar=0.171929
X2758   28   217  memristor PARAMS: InitStateVar=0.0655101
X2858   29   217  memristor PARAMS: InitStateVar=0.210775
X2958   30   217  memristor PARAMS: InitStateVar=0.311063
X3058   31   217  memristor PARAMS: InitStateVar=0.210666
X3158   32   217  memristor PARAMS: InitStateVar=0.443164
X3258   33   217  memristor PARAMS: InitStateVar=0.363994
X3358   34   217  memristor PARAMS: InitStateVar=0.151724
X3458   35   217  memristor PARAMS: InitStateVar=0.384051
X3558   36   217  memristor PARAMS: InitStateVar=0.212135
X3658   37   217  memristor PARAMS: InitStateVar=0.314712
X3758   38   217  memristor PARAMS: InitStateVar=0.132236
X3858   39   217  memristor PARAMS: InitStateVar=0.438336
X3958   40   217  memristor PARAMS: InitStateVar=0.108805
X4058   41   217  memristor PARAMS: InitStateVar=0.296413
X4158   42   217  memristor PARAMS: InitStateVar=0.27121
X4258   43   217  memristor PARAMS: InitStateVar=0.162167
X4358   44   217  memristor PARAMS: InitStateVar=0.189988
X4458   45   217  memristor PARAMS: InitStateVar=0.359839
X4558   46   217  memristor PARAMS: InitStateVar=0.302688
X4658   47   217  memristor PARAMS: InitStateVar=0.168144
X4758   48   217  memristor PARAMS: InitStateVar=0.215211
X4858   49   217  memristor PARAMS: InitStateVar=0.251468
X4958   50   217  memristor PARAMS: InitStateVar=0.166427
X5058   51   217  memristor PARAMS: InitStateVar=0.385311
X5158   52   217  memristor PARAMS: InitStateVar=0.332584
X5258   53   217  memristor PARAMS: InitStateVar=0.273854
X5358   54   217  memristor PARAMS: InitStateVar=0.249627
X5458   55   217  memristor PARAMS: InitStateVar=0.279094
X5558   56   217  memristor PARAMS: InitStateVar=0.261076
X5658   57   217  memristor PARAMS: InitStateVar=0.385529
X5758   58   217  memristor PARAMS: InitStateVar=0.295705
X5858   59   217  memristor PARAMS: InitStateVar=0.139506
X5958   60   217  memristor PARAMS: InitStateVar=0.255746
X6058   61   217  memristor PARAMS: InitStateVar=0.328025
X6158   62   217  memristor PARAMS: InitStateVar=0.244311
X6258   63   217  memristor PARAMS: InitStateVar=0.478665
X6358   64   217  memristor PARAMS: InitStateVar=0.371578
X6458   65   217  memristor PARAMS: InitStateVar=0.330329
X6558   66   217  memristor PARAMS: InitStateVar=0.292462
X6658   67   217  memristor PARAMS: InitStateVar=0.397174
X6758   68   217  memristor PARAMS: InitStateVar=0.211052
X6858   69   217  memristor PARAMS: InitStateVar=0.274885
X6958   70   217  memristor PARAMS: InitStateVar=0.300113
X7058   71   217  memristor PARAMS: InitStateVar=0.274337
X7158   72   217  memristor PARAMS: InitStateVar=0.0729291
X7258   73   217  memristor PARAMS: InitStateVar=0.390931
X7358   74   217  memristor PARAMS: InitStateVar=0.247603
X7458   75   217  memristor PARAMS: InitStateVar=0.191958
X7558   76   217  memristor PARAMS: InitStateVar=0.0708178
X7658   77   217  memristor PARAMS: InitStateVar=0.313691
X7758   78   217  memristor PARAMS: InitStateVar=0.197026
X7858   79   217  memristor PARAMS: InitStateVar=0.188948
X7958   80   217  memristor PARAMS: InitStateVar=0.403668
X8058   81   217  memristor PARAMS: InitStateVar=0.360196
X8158   82   217  memristor PARAMS: InitStateVar=0.266754
X8258   83   217  memristor PARAMS: InitStateVar=0.291453
X8358   84   217  memristor PARAMS: InitStateVar=0.3151
X8458   85   217  memristor PARAMS: InitStateVar=0.179157
X8558   86   217  memristor PARAMS: InitStateVar=0.278831
X8658   87   217  memristor PARAMS: InitStateVar=0.157475
X8758   88   217  memristor PARAMS: InitStateVar=0.292624
X8858   89   217  memristor PARAMS: InitStateVar=0.293583
X8958   90   217  memristor PARAMS: InitStateVar=0.481309
X9058   91   217  memristor PARAMS: InitStateVar=0.254605
X9158   92   217  memristor PARAMS: InitStateVar=0.354807
X9258   93   217  memristor PARAMS: InitStateVar=0.261457
X9358   94   217  memristor PARAMS: InitStateVar=0.248928
X9458   95   217  memristor PARAMS: InitStateVar=0.383399
X9558   96   217  memristor PARAMS: InitStateVar=0.32395
X9658   97   217  memristor PARAMS: InitStateVar=0.393537
X9758   98   217  memristor PARAMS: InitStateVar=0.504733
X9858   99   217  memristor PARAMS: InitStateVar=0.287261
X9958   100  217  memristor PARAMS: InitStateVar=0.368831
Xo59    217  218  OutputModule PARAMS: Rval=100
*------------------- Column 60 -------------------------------------------------
X59     1    219  memristor PARAMS: InitStateVar=0.331434
X159    2    219  memristor PARAMS: InitStateVar=0.290533
X259    3    219  memristor PARAMS: InitStateVar=0.10151
X359    4    219  memristor PARAMS: InitStateVar=0.4146
X459    5    219  memristor PARAMS: InitStateVar=0.402166
X559    6    219  memristor PARAMS: InitStateVar=0.249799
X659    7    219  memristor PARAMS: InitStateVar=0.514032
X759    8    219  memristor PARAMS: InitStateVar=0.349399
X859    9    219  memristor PARAMS: InitStateVar=0.259555
X959    10   219  memristor PARAMS: InitStateVar=0.290857
X1059   11   219  memristor PARAMS: InitStateVar=0.107454
X1159   12   219  memristor PARAMS: InitStateVar=0.312826
X1259   13   219  memristor PARAMS: InitStateVar=0.393658
X1359   14   219  memristor PARAMS: InitStateVar=0.220869
X1459   15   219  memristor PARAMS: InitStateVar=0.253751
X1559   16   219  memristor PARAMS: InitStateVar=0.322355
X1659   17   219  memristor PARAMS: InitStateVar=0.349012
X1759   18   219  memristor PARAMS: InitStateVar=0.351608
X1859   19   219  memristor PARAMS: InitStateVar=0.290012
X1959   20   219  memristor PARAMS: InitStateVar=0.417241
X2059   21   219  memristor PARAMS: InitStateVar=0.244711
X2159   22   219  memristor PARAMS: InitStateVar=0.493262
X2259   23   219  memristor PARAMS: InitStateVar=0.38966
X2359   24   219  memristor PARAMS: InitStateVar=0.462327
X2459   25   219  memristor PARAMS: InitStateVar=0.202706
X2559   26   219  memristor PARAMS: InitStateVar=0.266362
X2659   27   219  memristor PARAMS: InitStateVar=0.324503
X2759   28   219  memristor PARAMS: InitStateVar=0.21851
X2859   29   219  memristor PARAMS: InitStateVar=0.37097
X2959   30   219  memristor PARAMS: InitStateVar=0.392071
X3059   31   219  memristor PARAMS: InitStateVar=0.176354
X3159   32   219  memristor PARAMS: InitStateVar=0.276927
X3259   33   219  memristor PARAMS: InitStateVar=0.291079
X3359   34   219  memristor PARAMS: InitStateVar=0.28064
X3459   35   219  memristor PARAMS: InitStateVar=0.470767
X3559   36   219  memristor PARAMS: InitStateVar=0.31825
X3659   37   219  memristor PARAMS: InitStateVar=0.31886
X3759   38   219  memristor PARAMS: InitStateVar=0.0915934
X3859   39   219  memristor PARAMS: InitStateVar=0.282173
X3959   40   219  memristor PARAMS: InitStateVar=0.111583
X4059   41   219  memristor PARAMS: InitStateVar=0.30542
X4159   42   219  memristor PARAMS: InitStateVar=0.369049
X4259   43   219  memristor PARAMS: InitStateVar=0.300598
X4359   44   219  memristor PARAMS: InitStateVar=0.258196
X4459   45   219  memristor PARAMS: InitStateVar=0.300864
X4559   46   219  memristor PARAMS: InitStateVar=0.40617
X4659   47   219  memristor PARAMS: InitStateVar=0.280529
X4759   48   219  memristor PARAMS: InitStateVar=0.161296
X4859   49   219  memristor PARAMS: InitStateVar=0.213373
X4959   50   219  memristor PARAMS: InitStateVar=0.338437
X5059   51   219  memristor PARAMS: InitStateVar=0.162698
X5159   52   219  memristor PARAMS: InitStateVar=0.461081
X5259   53   219  memristor PARAMS: InitStateVar=0.400559
X5359   54   219  memristor PARAMS: InitStateVar=0.370606
X5459   55   219  memristor PARAMS: InitStateVar=0.35245
X5559   56   219  memristor PARAMS: InitStateVar=0.2893
X5659   57   219  memristor PARAMS: InitStateVar=0.103113
X5759   58   219  memristor PARAMS: InitStateVar=0.290886
X5859   59   219  memristor PARAMS: InitStateVar=0.307362
X5959   60   219  memristor PARAMS: InitStateVar=0.161904
X6059   61   219  memristor PARAMS: InitStateVar=0.292985
X6159   62   219  memristor PARAMS: InitStateVar=0.231688
X6259   63   219  memristor PARAMS: InitStateVar=0.200629
X6359   64   219  memristor PARAMS: InitStateVar=0.229172
X6459   65   219  memristor PARAMS: InitStateVar=0.160955
X6559   66   219  memristor PARAMS: InitStateVar=0.394813
X6659   67   219  memristor PARAMS: InitStateVar=0.254532
X6759   68   219  memristor PARAMS: InitStateVar=0.427643
X6859   69   219  memristor PARAMS: InitStateVar=0.254858
X6959   70   219  memristor PARAMS: InitStateVar=0.378517
X7059   71   219  memristor PARAMS: InitStateVar=0.44843
X7159   72   219  memristor PARAMS: InitStateVar=0.33197
X7259   73   219  memristor PARAMS: InitStateVar=0.346528
X7359   74   219  memristor PARAMS: InitStateVar=0.368056
X7459   75   219  memristor PARAMS: InitStateVar=0.238474
X7559   76   219  memristor PARAMS: InitStateVar=0.288432
X7659   77   219  memristor PARAMS: InitStateVar=0.396501
X7759   78   219  memristor PARAMS: InitStateVar=0.535739
X7859   79   219  memristor PARAMS: InitStateVar=0.31206
X7959   80   219  memristor PARAMS: InitStateVar=0.265583
X8059   81   219  memristor PARAMS: InitStateVar=0.0786211
X8159   82   219  memristor PARAMS: InitStateVar=0.35874
X8259   83   219  memristor PARAMS: InitStateVar=0.411044
X8359   84   219  memristor PARAMS: InitStateVar=0.290134
X8459   85   219  memristor PARAMS: InitStateVar=0.307917
X8559   86   219  memristor PARAMS: InitStateVar=0.0825337
X8659   87   219  memristor PARAMS: InitStateVar=0.0759491
X8759   88   219  memristor PARAMS: InitStateVar=0.496984
X8859   89   219  memristor PARAMS: InitStateVar=0.29285
X8959   90   219  memristor PARAMS: InitStateVar=0.348789
X9059   91   219  memristor PARAMS: InitStateVar=0.274209
X9159   92   219  memristor PARAMS: InitStateVar=0.0978273
X9259   93   219  memristor PARAMS: InitStateVar=0.214698
X9359   94   219  memristor PARAMS: InitStateVar=0.211198
X9459   95   219  memristor PARAMS: InitStateVar=0.305834
X9559   96   219  memristor PARAMS: InitStateVar=0.187635
X9659   97   219  memristor PARAMS: InitStateVar=0.326879
X9759   98   219  memristor PARAMS: InitStateVar=0.340404
X9859   99   219  memristor PARAMS: InitStateVar=0.298988
X9959   100  219  memristor PARAMS: InitStateVar=0.287124
Xo60    219  220  OutputModule PARAMS: Rval=100
*------------------- Column 61 -------------------------------------------------
X60     1    221  memristor PARAMS: InitStateVar=0.455044
X160    2    221  memristor PARAMS: InitStateVar=0.165522
X260    3    221  memristor PARAMS: InitStateVar=0.214499
X360    4    221  memristor PARAMS: InitStateVar=0.417182
X460    5    221  memristor PARAMS: InitStateVar=0.199578
X560    6    221  memristor PARAMS: InitStateVar=0.317405
X660    7    221  memristor PARAMS: InitStateVar=0.286914
X760    8    221  memristor PARAMS: InitStateVar=0.297016
X860    9    221  memristor PARAMS: InitStateVar=0.433816
X960    10   221  memristor PARAMS: InitStateVar=0.411949
X1060   11   221  memristor PARAMS: InitStateVar=0.493981
X1160   12   221  memristor PARAMS: InitStateVar=0.134285
X1260   13   221  memristor PARAMS: InitStateVar=0.282884
X1360   14   221  memristor PARAMS: InitStateVar=0.289033
X1460   15   221  memristor PARAMS: InitStateVar=0.246381
X1560   16   221  memristor PARAMS: InitStateVar=0.324233
X1660   17   221  memristor PARAMS: InitStateVar=0.329077
X1760   18   221  memristor PARAMS: InitStateVar=0.207195
X1860   19   221  memristor PARAMS: InitStateVar=0.358123
X1960   20   221  memristor PARAMS: InitStateVar=0.239567
X2060   21   221  memristor PARAMS: InitStateVar=0.0678276
X2160   22   221  memristor PARAMS: InitStateVar=0.303802
X2260   23   221  memristor PARAMS: InitStateVar=0.325094
X2360   24   221  memristor PARAMS: InitStateVar=0.265292
X2460   25   221  memristor PARAMS: InitStateVar=0.34232
X2560   26   221  memristor PARAMS: InitStateVar=0.282917
X2660   27   221  memristor PARAMS: InitStateVar=0.452667
X2760   28   221  memristor PARAMS: InitStateVar=0.245274
X2860   29   221  memristor PARAMS: InitStateVar=0.397612
X2960   30   221  memristor PARAMS: InitStateVar=0.482933
X3060   31   221  memristor PARAMS: InitStateVar=0.262144
X3160   32   221  memristor PARAMS: InitStateVar=0.276259
X3260   33   221  memristor PARAMS: InitStateVar=0.259176
X3360   34   221  memristor PARAMS: InitStateVar=0.34567
X3460   35   221  memristor PARAMS: InitStateVar=0.232074
X3560   36   221  memristor PARAMS: InitStateVar=0.386075
X3660   37   221  memristor PARAMS: InitStateVar=0.502484
X3760   38   221  memristor PARAMS: InitStateVar=0.333281
X3860   39   221  memristor PARAMS: InitStateVar=0.294023
X3960   40   221  memristor PARAMS: InitStateVar=0.35915
X4060   41   221  memristor PARAMS: InitStateVar=0.184162
X4160   42   221  memristor PARAMS: InitStateVar=0.370891
X4260   43   221  memristor PARAMS: InitStateVar=0.193263
X4360   44   221  memristor PARAMS: InitStateVar=0.218218
X4460   45   221  memristor PARAMS: InitStateVar=0.17346
X4560   46   221  memristor PARAMS: InitStateVar=0.0683852
X4660   47   221  memristor PARAMS: InitStateVar=0.378449
X4760   48   221  memristor PARAMS: InitStateVar=0.435163
X4860   49   221  memristor PARAMS: InitStateVar=0.372995
X4960   50   221  memristor PARAMS: InitStateVar=0.145546
X5060   51   221  memristor PARAMS: InitStateVar=0.264596
X5160   52   221  memristor PARAMS: InitStateVar=0.355848
X5260   53   221  memristor PARAMS: InitStateVar=0.343076
X5360   54   221  memristor PARAMS: InitStateVar=0.431941
X5460   55   221  memristor PARAMS: InitStateVar=0.36497
X5560   56   221  memristor PARAMS: InitStateVar=0.25279
X5660   57   221  memristor PARAMS: InitStateVar=0.25937
X5760   58   221  memristor PARAMS: InitStateVar=0.332375
X5860   59   221  memristor PARAMS: InitStateVar=0.246612
X5960   60   221  memristor PARAMS: InitStateVar=0.302805
X6060   61   221  memristor PARAMS: InitStateVar=0.330153
X6160   62   221  memristor PARAMS: InitStateVar=0.218926
X6260   63   221  memristor PARAMS: InitStateVar=0.376123
X6360   64   221  memristor PARAMS: InitStateVar=0.260679
X6460   65   221  memristor PARAMS: InitStateVar=0.374179
X6560   66   221  memristor PARAMS: InitStateVar=0.393633
X6660   67   221  memristor PARAMS: InitStateVar=0.330395
X6760   68   221  memristor PARAMS: InitStateVar=0.354542
X6860   69   221  memristor PARAMS: InitStateVar=0.17923
X6960   70   221  memristor PARAMS: InitStateVar=0.437411
X7060   71   221  memristor PARAMS: InitStateVar=0.311086
X7160   72   221  memristor PARAMS: InitStateVar=0.32841
X7260   73   221  memristor PARAMS: InitStateVar=0.290501
X7360   74   221  memristor PARAMS: InitStateVar=0.407129
X7460   75   221  memristor PARAMS: InitStateVar=0.471018
X7560   76   221  memristor PARAMS: InitStateVar=0.140751
X7660   77   221  memristor PARAMS: InitStateVar=0.345273
X7760   78   221  memristor PARAMS: InitStateVar=0.403038
X7860   79   221  memristor PARAMS: InitStateVar=0.419303
X7960   80   221  memristor PARAMS: InitStateVar=0.140359
X8060   81   221  memristor PARAMS: InitStateVar=0.175199
X8160   82   221  memristor PARAMS: InitStateVar=0.362879
X8260   83   221  memristor PARAMS: InitStateVar=0.133587
X8360   84   221  memristor PARAMS: InitStateVar=0.380381
X8460   85   221  memristor PARAMS: InitStateVar=0.338402
X8560   86   221  memristor PARAMS: InitStateVar=0.353103
X8660   87   221  memristor PARAMS: InitStateVar=0.210462
X8760   88   221  memristor PARAMS: InitStateVar=0.404691
X8860   89   221  memristor PARAMS: InitStateVar=0.279214
X8960   90   221  memristor PARAMS: InitStateVar=0.167839
X9060   91   221  memristor PARAMS: InitStateVar=0.29394
X9160   92   221  memristor PARAMS: InitStateVar=0.362547
X9260   93   221  memristor PARAMS: InitStateVar=0.272457
X9360   94   221  memristor PARAMS: InitStateVar=0.224592
X9460   95   221  memristor PARAMS: InitStateVar=0.413615
X9560   96   221  memristor PARAMS: InitStateVar=0.416278
X9660   97   221  memristor PARAMS: InitStateVar=0.407894
X9760   98   221  memristor PARAMS: InitStateVar=0.401955
X9860   99   221  memristor PARAMS: InitStateVar=0.372092
X9960   100  221  memristor PARAMS: InitStateVar=0.323275
Xo61    221  222  OutputModule PARAMS: Rval=100
*------------------- Column 62 -------------------------------------------------
X61     1    223  memristor PARAMS: InitStateVar=0.344187
X161    2    223  memristor PARAMS: InitStateVar=0.260542
X261    3    223  memristor PARAMS: InitStateVar=0.329335
X361    4    223  memristor PARAMS: InitStateVar=0.269877
X461    5    223  memristor PARAMS: InitStateVar=0.318429
X561    6    223  memristor PARAMS: InitStateVar=0.183873
X661    7    223  memristor PARAMS: InitStateVar=0.252799
X761    8    223  memristor PARAMS: InitStateVar=0.276784
X861    9    223  memristor PARAMS: InitStateVar=0.162769
X961    10   223  memristor PARAMS: InitStateVar=0.266585
X1061   11   223  memristor PARAMS: InitStateVar=0.294363
X1161   12   223  memristor PARAMS: InitStateVar=0.263646
X1261   13   223  memristor PARAMS: InitStateVar=0.120449
X1361   14   223  memristor PARAMS: InitStateVar=0.33334
X1461   15   223  memristor PARAMS: InitStateVar=0.427162
X1561   16   223  memristor PARAMS: InitStateVar=0.399007
X1661   17   223  memristor PARAMS: InitStateVar=0.254565
X1761   18   223  memristor PARAMS: InitStateVar=0.367627
X1861   19   223  memristor PARAMS: InitStateVar=0.271763
X1961   20   223  memristor PARAMS: InitStateVar=0.491252
X2061   21   223  memristor PARAMS: InitStateVar=0.430967
X2161   22   223  memristor PARAMS: InitStateVar=0.229161
X2261   23   223  memristor PARAMS: InitStateVar=0.263566
X2361   24   223  memristor PARAMS: InitStateVar=0.482781
X2461   25   223  memristor PARAMS: InitStateVar=0.404404
X2561   26   223  memristor PARAMS: InitStateVar=0.28323
X2661   27   223  memristor PARAMS: InitStateVar=0.333238
X2761   28   223  memristor PARAMS: InitStateVar=0.39041
X2861   29   223  memristor PARAMS: InitStateVar=0.194827
X2961   30   223  memristor PARAMS: InitStateVar=0.279689
X3061   31   223  memristor PARAMS: InitStateVar=0.221041
X3161   32   223  memristor PARAMS: InitStateVar=0.275303
X3261   33   223  memristor PARAMS: InitStateVar=0.390472
X3361   34   223  memristor PARAMS: InitStateVar=0.218347
X3461   35   223  memristor PARAMS: InitStateVar=0.382043
X3561   36   223  memristor PARAMS: InitStateVar=0.208787
X3661   37   223  memristor PARAMS: InitStateVar=0.294757
X3761   38   223  memristor PARAMS: InitStateVar=0.269612
X3861   39   223  memristor PARAMS: InitStateVar=0.317561
X3961   40   223  memristor PARAMS: InitStateVar=0.494425
X4061   41   223  memristor PARAMS: InitStateVar=0.382533
X4161   42   223  memristor PARAMS: InitStateVar=0.328096
X4261   43   223  memristor PARAMS: InitStateVar=0.304889
X4361   44   223  memristor PARAMS: InitStateVar=0.457354
X4461   45   223  memristor PARAMS: InitStateVar=0.074959
X4561   46   223  memristor PARAMS: InitStateVar=0.434404
X4661   47   223  memristor PARAMS: InitStateVar=0.452174
X4761   48   223  memristor PARAMS: InitStateVar=0.28372
X4861   49   223  memristor PARAMS: InitStateVar=0.365274
X4961   50   223  memristor PARAMS: InitStateVar=0.442434
X5061   51   223  memristor PARAMS: InitStateVar=0.250826
X5161   52   223  memristor PARAMS: InitStateVar=0.243054
X5261   53   223  memristor PARAMS: InitStateVar=0.260693
X5361   54   223  memristor PARAMS: InitStateVar=0.302319
X5461   55   223  memristor PARAMS: InitStateVar=0.288042
X5561   56   223  memristor PARAMS: InitStateVar=0.442539
X5661   57   223  memristor PARAMS: InitStateVar=0.340053
X5761   58   223  memristor PARAMS: InitStateVar=0.322459
X5861   59   223  memristor PARAMS: InitStateVar=0.260971
X5961   60   223  memristor PARAMS: InitStateVar=0.302319
X6061   61   223  memristor PARAMS: InitStateVar=0.447793
X6161   62   223  memristor PARAMS: InitStateVar=0.392989
X6261   63   223  memristor PARAMS: InitStateVar=0.284972
X6361   64   223  memristor PARAMS: InitStateVar=0.334432
X6461   65   223  memristor PARAMS: InitStateVar=0.419547
X6561   66   223  memristor PARAMS: InitStateVar=0.185553
X6661   67   223  memristor PARAMS: InitStateVar=0.401369
X6761   68   223  memristor PARAMS: InitStateVar=0.196699
X6861   69   223  memristor PARAMS: InitStateVar=0.239675
X6961   70   223  memristor PARAMS: InitStateVar=0.332811
X7061   71   223  memristor PARAMS: InitStateVar=0.097022
X7161   72   223  memristor PARAMS: InitStateVar=0.150074
X7261   73   223  memristor PARAMS: InitStateVar=0.26138
X7361   74   223  memristor PARAMS: InitStateVar=0.260382
X7461   75   223  memristor PARAMS: InitStateVar=0.404612
X7561   76   223  memristor PARAMS: InitStateVar=0.293642
X7661   77   223  memristor PARAMS: InitStateVar=0.424338
X7761   78   223  memristor PARAMS: InitStateVar=0.231033
X7861   79   223  memristor PARAMS: InitStateVar=0.421726
X7961   80   223  memristor PARAMS: InitStateVar=0.0824415
X8061   81   223  memristor PARAMS: InitStateVar=0.245944
X8161   82   223  memristor PARAMS: InitStateVar=0.27092
X8261   83   223  memristor PARAMS: InitStateVar=0.291985
X8361   84   223  memristor PARAMS: InitStateVar=0.31605
X8461   85   223  memristor PARAMS: InitStateVar=0.22773
X8561   86   223  memristor PARAMS: InitStateVar=0.26704
X8661   87   223  memristor PARAMS: InitStateVar=0.331341
X8761   88   223  memristor PARAMS: InitStateVar=0.234154
X8861   89   223  memristor PARAMS: InitStateVar=0.0870731
X8961   90   223  memristor PARAMS: InitStateVar=0.159453
X9061   91   223  memristor PARAMS: InitStateVar=0.181308
X9161   92   223  memristor PARAMS: InitStateVar=0.292895
X9261   93   223  memristor PARAMS: InitStateVar=0.0897894
X9361   94   223  memristor PARAMS: InitStateVar=0.27289
X9461   95   223  memristor PARAMS: InitStateVar=0.299866
X9561   96   223  memristor PARAMS: InitStateVar=0.184798
X9661   97   223  memristor PARAMS: InitStateVar=0.334534
X9761   98   223  memristor PARAMS: InitStateVar=0.289514
X9861   99   223  memristor PARAMS: InitStateVar=0.340546
X9961   100  223  memristor PARAMS: InitStateVar=0.233131
Xo62    223  224  OutputModule PARAMS: Rval=100
*------------------- Column 63 -------------------------------------------------
X62     1    225  memristor PARAMS: InitStateVar=0.25623
X162    2    225  memristor PARAMS: InitStateVar=0.572418
X262    3    225  memristor PARAMS: InitStateVar=0.289343
X362    4    225  memristor PARAMS: InitStateVar=0.170558
X462    5    225  memristor PARAMS: InitStateVar=0.334809
X562    6    225  memristor PARAMS: InitStateVar=0.327916
X662    7    225  memristor PARAMS: InitStateVar=0.349794
X762    8    225  memristor PARAMS: InitStateVar=0.359351
X862    9    225  memristor PARAMS: InitStateVar=0.290775
X962    10   225  memristor PARAMS: InitStateVar=0.274881
X1062   11   225  memristor PARAMS: InitStateVar=0.327343
X1162   12   225  memristor PARAMS: InitStateVar=0.320509
X1262   13   225  memristor PARAMS: InitStateVar=0.305419
X1362   14   225  memristor PARAMS: InitStateVar=0.360905
X1462   15   225  memristor PARAMS: InitStateVar=0.248641
X1562   16   225  memristor PARAMS: InitStateVar=0.202097
X1662   17   225  memristor PARAMS: InitStateVar=0.255741
X1762   18   225  memristor PARAMS: InitStateVar=0.411027
X1862   19   225  memristor PARAMS: InitStateVar=0.291039
X1962   20   225  memristor PARAMS: InitStateVar=0.368343
X2062   21   225  memristor PARAMS: InitStateVar=0.31923
X2162   22   225  memristor PARAMS: InitStateVar=0.0984534
X2262   23   225  memristor PARAMS: InitStateVar=0.278437
X2362   24   225  memristor PARAMS: InitStateVar=0.218428
X2462   25   225  memristor PARAMS: InitStateVar=0.352056
X2562   26   225  memristor PARAMS: InitStateVar=0.338728
X2662   27   225  memristor PARAMS: InitStateVar=0.358265
X2762   28   225  memristor PARAMS: InitStateVar=0.280627
X2862   29   225  memristor PARAMS: InitStateVar=0.345213
X2962   30   225  memristor PARAMS: InitStateVar=0.275718
X3062   31   225  memristor PARAMS: InitStateVar=0.23969
X3162   32   225  memristor PARAMS: InitStateVar=0.502603
X3262   33   225  memristor PARAMS: InitStateVar=0.374878
X3362   34   225  memristor PARAMS: InitStateVar=0.252257
X3462   35   225  memristor PARAMS: InitStateVar=0.437865
X3562   36   225  memristor PARAMS: InitStateVar=0.36813
X3662   37   225  memristor PARAMS: InitStateVar=0.266448
X3762   38   225  memristor PARAMS: InitStateVar=0.284714
X3862   39   225  memristor PARAMS: InitStateVar=0.185755
X3962   40   225  memristor PARAMS: InitStateVar=0.416284
X4062   41   225  memristor PARAMS: InitStateVar=0.176737
X4162   42   225  memristor PARAMS: InitStateVar=0.2624
X4262   43   225  memristor PARAMS: InitStateVar=0.0636172
X4362   44   225  memristor PARAMS: InitStateVar=0.268005
X4462   45   225  memristor PARAMS: InitStateVar=0.276747
X4562   46   225  memristor PARAMS: InitStateVar=0.433987
X4662   47   225  memristor PARAMS: InitStateVar=0.291995
X4762   48   225  memristor PARAMS: InitStateVar=0.324217
X4862   49   225  memristor PARAMS: InitStateVar=-0.00663186
X4962   50   225  memristor PARAMS: InitStateVar=0.256227
X5062   51   225  memristor PARAMS: InitStateVar=0.133847
X5162   52   225  memristor PARAMS: InitStateVar=0.36505
X5262   53   225  memristor PARAMS: InitStateVar=0.297715
X5362   54   225  memristor PARAMS: InitStateVar=0.389143
X5462   55   225  memristor PARAMS: InitStateVar=0.367505
X5562   56   225  memristor PARAMS: InitStateVar=0.337656
X5662   57   225  memristor PARAMS: InitStateVar=0.277829
X5762   58   225  memristor PARAMS: InitStateVar=0.270917
X5862   59   225  memristor PARAMS: InitStateVar=0.165719
X5962   60   225  memristor PARAMS: InitStateVar=0.338417
X6062   61   225  memristor PARAMS: InitStateVar=0.218856
X6162   62   225  memristor PARAMS: InitStateVar=0.349628
X6262   63   225  memristor PARAMS: InitStateVar=0.343949
X6362   64   225  memristor PARAMS: InitStateVar=0.339974
X6462   65   225  memristor PARAMS: InitStateVar=0.377341
X6562   66   225  memristor PARAMS: InitStateVar=0.283999
X6662   67   225  memristor PARAMS: InitStateVar=0.183899
X6762   68   225  memristor PARAMS: InitStateVar=0.0587313
X6862   69   225  memristor PARAMS: InitStateVar=0.438356
X6962   70   225  memristor PARAMS: InitStateVar=0.334059
X7062   71   225  memristor PARAMS: InitStateVar=0.227633
X7162   72   225  memristor PARAMS: InitStateVar=0.315673
X7262   73   225  memristor PARAMS: InitStateVar=0.231717
X7362   74   225  memristor PARAMS: InitStateVar=0.184522
X7462   75   225  memristor PARAMS: InitStateVar=0.355514
X7562   76   225  memristor PARAMS: InitStateVar=0.300049
X7662   77   225  memristor PARAMS: InitStateVar=0.511831
X7762   78   225  memristor PARAMS: InitStateVar=0.281309
X7862   79   225  memristor PARAMS: InitStateVar=0.229858
X7962   80   225  memristor PARAMS: InitStateVar=0.179074
X8062   81   225  memristor PARAMS: InitStateVar=0.339703
X8162   82   225  memristor PARAMS: InitStateVar=0.410715
X8262   83   225  memristor PARAMS: InitStateVar=0.369216
X8362   84   225  memristor PARAMS: InitStateVar=0.341646
X8462   85   225  memristor PARAMS: InitStateVar=0.320349
X8562   86   225  memristor PARAMS: InitStateVar=0.420392
X8662   87   225  memristor PARAMS: InitStateVar=0.372208
X8762   88   225  memristor PARAMS: InitStateVar=0.194975
X8862   89   225  memristor PARAMS: InitStateVar=0.329221
X8962   90   225  memristor PARAMS: InitStateVar=0.292605
X9062   91   225  memristor PARAMS: InitStateVar=0.418851
X9162   92   225  memristor PARAMS: InitStateVar=0.355886
X9262   93   225  memristor PARAMS: InitStateVar=0.298924
X9362   94   225  memristor PARAMS: InitStateVar=0.329984
X9462   95   225  memristor PARAMS: InitStateVar=0.235388
X9562   96   225  memristor PARAMS: InitStateVar=0.25504
X9662   97   225  memristor PARAMS: InitStateVar=0.265146
X9762   98   225  memristor PARAMS: InitStateVar=0.300714
X9862   99   225  memristor PARAMS: InitStateVar=0.445962
X9962   100  225  memristor PARAMS: InitStateVar=0.39532
Xo63    225  226  OutputModule PARAMS: Rval=100
*------------------- Column 64 -------------------------------------------------
X63     1    227  memristor PARAMS: InitStateVar=0.28246
X163    2    227  memristor PARAMS: InitStateVar=0.402765
X263    3    227  memristor PARAMS: InitStateVar=0.171794
X363    4    227  memristor PARAMS: InitStateVar=0.435959
X463    5    227  memristor PARAMS: InitStateVar=0.379415
X563    6    227  memristor PARAMS: InitStateVar=0.24004
X663    7    227  memristor PARAMS: InitStateVar=0.349226
X763    8    227  memristor PARAMS: InitStateVar=0.453588
X863    9    227  memristor PARAMS: InitStateVar=0.146946
X963    10   227  memristor PARAMS: InitStateVar=0.450994
X1063   11   227  memristor PARAMS: InitStateVar=0.318689
X1163   12   227  memristor PARAMS: InitStateVar=0.255791
X1263   13   227  memristor PARAMS: InitStateVar=0.343527
X1363   14   227  memristor PARAMS: InitStateVar=0.418184
X1463   15   227  memristor PARAMS: InitStateVar=0.407464
X1563   16   227  memristor PARAMS: InitStateVar=0.33235
X1663   17   227  memristor PARAMS: InitStateVar=0.481741
X1763   18   227  memristor PARAMS: InitStateVar=0.281062
X1863   19   227  memristor PARAMS: InitStateVar=0.239413
X1963   20   227  memristor PARAMS: InitStateVar=0.0600539
X2063   21   227  memristor PARAMS: InitStateVar=0.279312
X2163   22   227  memristor PARAMS: InitStateVar=0.336368
X2263   23   227  memristor PARAMS: InitStateVar=0.133518
X2363   24   227  memristor PARAMS: InitStateVar=0.404859
X2463   25   227  memristor PARAMS: InitStateVar=0.31852
X2563   26   227  memristor PARAMS: InitStateVar=0.218497
X2663   27   227  memristor PARAMS: InitStateVar=0.247862
X2763   28   227  memristor PARAMS: InitStateVar=0.0962928
X2863   29   227  memristor PARAMS: InitStateVar=0.209108
X2963   30   227  memristor PARAMS: InitStateVar=0.423873
X3063   31   227  memristor PARAMS: InitStateVar=0.0938364
X3163   32   227  memristor PARAMS: InitStateVar=0.455522
X3263   33   227  memristor PARAMS: InitStateVar=0.454131
X3363   34   227  memristor PARAMS: InitStateVar=0.449934
X3463   35   227  memristor PARAMS: InitStateVar=0.529239
X3563   36   227  memristor PARAMS: InitStateVar=0.368957
X3663   37   227  memristor PARAMS: InitStateVar=0.34791
X3763   38   227  memristor PARAMS: InitStateVar=0.382494
X3863   39   227  memristor PARAMS: InitStateVar=0.307572
X3963   40   227  memristor PARAMS: InitStateVar=0.362212
X4063   41   227  memristor PARAMS: InitStateVar=0.148573
X4163   42   227  memristor PARAMS: InitStateVar=0.2277
X4263   43   227  memristor PARAMS: InitStateVar=0.192534
X4363   44   227  memristor PARAMS: InitStateVar=0.286846
X4463   45   227  memristor PARAMS: InitStateVar=0.264552
X4563   46   227  memristor PARAMS: InitStateVar=0.479108
X4663   47   227  memristor PARAMS: InitStateVar=0.178523
X4763   48   227  memristor PARAMS: InitStateVar=0.381614
X4863   49   227  memristor PARAMS: InitStateVar=0.253761
X4963   50   227  memristor PARAMS: InitStateVar=0.385188
X5063   51   227  memristor PARAMS: InitStateVar=0.223667
X5163   52   227  memristor PARAMS: InitStateVar=0.439616
X5263   53   227  memristor PARAMS: InitStateVar=0.318553
X5363   54   227  memristor PARAMS: InitStateVar=0.0819542
X5463   55   227  memristor PARAMS: InitStateVar=0.177967
X5563   56   227  memristor PARAMS: InitStateVar=0.356075
X5663   57   227  memristor PARAMS: InitStateVar=0.306105
X5763   58   227  memristor PARAMS: InitStateVar=0.212307
X5863   59   227  memristor PARAMS: InitStateVar=0.395298
X5963   60   227  memristor PARAMS: InitStateVar=0.197266
X6063   61   227  memristor PARAMS: InitStateVar=0.330005
X6163   62   227  memristor PARAMS: InitStateVar=0.175594
X6263   63   227  memristor PARAMS: InitStateVar=0.223435
X6363   64   227  memristor PARAMS: InitStateVar=0.304283
X6463   65   227  memristor PARAMS: InitStateVar=0.219189
X6563   66   227  memristor PARAMS: InitStateVar=0.414386
X6663   67   227  memristor PARAMS: InitStateVar=0.322556
X6763   68   227  memristor PARAMS: InitStateVar=0.230077
X6863   69   227  memristor PARAMS: InitStateVar=0.459026
X6963   70   227  memristor PARAMS: InitStateVar=0.267076
X7063   71   227  memristor PARAMS: InitStateVar=0.265503
X7163   72   227  memristor PARAMS: InitStateVar=0.453992
X7263   73   227  memristor PARAMS: InitStateVar=0.297529
X7363   74   227  memristor PARAMS: InitStateVar=0.36894
X7463   75   227  memristor PARAMS: InitStateVar=0.354369
X7563   76   227  memristor PARAMS: InitStateVar=0.271858
X7663   77   227  memristor PARAMS: InitStateVar=0.278615
X7763   78   227  memristor PARAMS: InitStateVar=0.326477
X7863   79   227  memristor PARAMS: InitStateVar=0.310135
X7963   80   227  memristor PARAMS: InitStateVar=0.387493
X8063   81   227  memristor PARAMS: InitStateVar=0.292812
X8163   82   227  memristor PARAMS: InitStateVar=0.42669
X8263   83   227  memristor PARAMS: InitStateVar=0.351848
X8363   84   227  memristor PARAMS: InitStateVar=0.414318
X8463   85   227  memristor PARAMS: InitStateVar=0.271814
X8563   86   227  memristor PARAMS: InitStateVar=0.34554
X8663   87   227  memristor PARAMS: InitStateVar=0.213702
X8763   88   227  memristor PARAMS: InitStateVar=0.301427
X8863   89   227  memristor PARAMS: InitStateVar=0.270573
X8963   90   227  memristor PARAMS: InitStateVar=0.449234
X9063   91   227  memristor PARAMS: InitStateVar=0.333152
X9163   92   227  memristor PARAMS: InitStateVar=0.573778
X9263   93   227  memristor PARAMS: InitStateVar=0.211604
X9363   94   227  memristor PARAMS: InitStateVar=0.207406
X9463   95   227  memristor PARAMS: InitStateVar=0.075137
X9563   96   227  memristor PARAMS: InitStateVar=0.222819
X9663   97   227  memristor PARAMS: InitStateVar=0.265539
X9763   98   227  memristor PARAMS: InitStateVar=0.23237
X9863   99   227  memristor PARAMS: InitStateVar=0.318172
X9963   100  227  memristor PARAMS: InitStateVar=0.505616
Xo64    227  228  OutputModule PARAMS: Rval=100
*------------------- Column 65 -------------------------------------------------
X64     1    229  memristor PARAMS: InitStateVar=0.375269
X164    2    229  memristor PARAMS: InitStateVar=0.229464
X264    3    229  memristor PARAMS: InitStateVar=0.421927
X364    4    229  memristor PARAMS: InitStateVar=0.240644
X464    5    229  memristor PARAMS: InitStateVar=0.175497
X564    6    229  memristor PARAMS: InitStateVar=0.461652
X664    7    229  memristor PARAMS: InitStateVar=0.513977
X764    8    229  memristor PARAMS: InitStateVar=0.2866
X864    9    229  memristor PARAMS: InitStateVar=0.278013
X964    10   229  memristor PARAMS: InitStateVar=0.387878
X1064   11   229  memristor PARAMS: InitStateVar=0.231545
X1164   12   229  memristor PARAMS: InitStateVar=0.333249
X1264   13   229  memristor PARAMS: InitStateVar=0.37588
X1364   14   229  memristor PARAMS: InitStateVar=0.413923
X1464   15   229  memristor PARAMS: InitStateVar=0.318272
X1564   16   229  memristor PARAMS: InitStateVar=0.172592
X1664   17   229  memristor PARAMS: InitStateVar=0.360224
X1764   18   229  memristor PARAMS: InitStateVar=0.342196
X1864   19   229  memristor PARAMS: InitStateVar=0.299825
X1964   20   229  memristor PARAMS: InitStateVar=0.311724
X2064   21   229  memristor PARAMS: InitStateVar=0.327315
X2164   22   229  memristor PARAMS: InitStateVar=0.20184
X2264   23   229  memristor PARAMS: InitStateVar=0.231909
X2364   24   229  memristor PARAMS: InitStateVar=0.334497
X2464   25   229  memristor PARAMS: InitStateVar=0.203846
X2564   26   229  memristor PARAMS: InitStateVar=0.368551
X2664   27   229  memristor PARAMS: InitStateVar=0.439078
X2764   28   229  memristor PARAMS: InitStateVar=0.309477
X2864   29   229  memristor PARAMS: InitStateVar=0.354316
X2964   30   229  memristor PARAMS: InitStateVar=0.10837
X3064   31   229  memristor PARAMS: InitStateVar=0.446446
X3164   32   229  memristor PARAMS: InitStateVar=0.280427
X3264   33   229  memristor PARAMS: InitStateVar=0.25477
X3364   34   229  memristor PARAMS: InitStateVar=0.262587
X3464   35   229  memristor PARAMS: InitStateVar=0.312133
X3564   36   229  memristor PARAMS: InitStateVar=0.43764
X3664   37   229  memristor PARAMS: InitStateVar=0.325789
X3764   38   229  memristor PARAMS: InitStateVar=0.211581
X3864   39   229  memristor PARAMS: InitStateVar=0.261036
X3964   40   229  memristor PARAMS: InitStateVar=0.173481
X4064   41   229  memristor PARAMS: InitStateVar=0.349646
X4164   42   229  memristor PARAMS: InitStateVar=0.255633
X4264   43   229  memristor PARAMS: InitStateVar=0.269862
X4364   44   229  memristor PARAMS: InitStateVar=0.19436
X4464   45   229  memristor PARAMS: InitStateVar=0.377536
X4564   46   229  memristor PARAMS: InitStateVar=0.313112
X4664   47   229  memristor PARAMS: InitStateVar=0.320902
X4764   48   229  memristor PARAMS: InitStateVar=0.21476
X4864   49   229  memristor PARAMS: InitStateVar=0.217639
X4964   50   229  memristor PARAMS: InitStateVar=0.318664
X5064   51   229  memristor PARAMS: InitStateVar=0.432858
X5164   52   229  memristor PARAMS: InitStateVar=0.265138
X5264   53   229  memristor PARAMS: InitStateVar=0.409066
X5364   54   229  memristor PARAMS: InitStateVar=0.334117
X5464   55   229  memristor PARAMS: InitStateVar=0.306619
X5564   56   229  memristor PARAMS: InitStateVar=0.41328
X5664   57   229  memristor PARAMS: InitStateVar=0.278133
X5764   58   229  memristor PARAMS: InitStateVar=0.344505
X5864   59   229  memristor PARAMS: InitStateVar=0.306756
X5964   60   229  memristor PARAMS: InitStateVar=0.457953
X6064   61   229  memristor PARAMS: InitStateVar=0.403675
X6164   62   229  memristor PARAMS: InitStateVar=0.194771
X6264   63   229  memristor PARAMS: InitStateVar=-0.0354126
X6364   64   229  memristor PARAMS: InitStateVar=0.153574
X6464   65   229  memristor PARAMS: InitStateVar=0.155111
X6564   66   229  memristor PARAMS: InitStateVar=0.342806
X6664   67   229  memristor PARAMS: InitStateVar=0.381946
X6764   68   229  memristor PARAMS: InitStateVar=0.273462
X6864   69   229  memristor PARAMS: InitStateVar=0.191776
X6964   70   229  memristor PARAMS: InitStateVar=0.234802
X7064   71   229  memristor PARAMS: InitStateVar=0.00644987
X7164   72   229  memristor PARAMS: InitStateVar=0.463125
X7264   73   229  memristor PARAMS: InitStateVar=0.24229
X7364   74   229  memristor PARAMS: InitStateVar=0.161101
X7464   75   229  memristor PARAMS: InitStateVar=0.222314
X7564   76   229  memristor PARAMS: InitStateVar=0.334565
X7664   77   229  memristor PARAMS: InitStateVar=0.408562
X7764   78   229  memristor PARAMS: InitStateVar=0.31792
X7864   79   229  memristor PARAMS: InitStateVar=0.173457
X7964   80   229  memristor PARAMS: InitStateVar=0.469267
X8064   81   229  memristor PARAMS: InitStateVar=0.382344
X8164   82   229  memristor PARAMS: InitStateVar=0.267077
X8264   83   229  memristor PARAMS: InitStateVar=0.242184
X8364   84   229  memristor PARAMS: InitStateVar=0.43363
X8464   85   229  memristor PARAMS: InitStateVar=0.379928
X8564   86   229  memristor PARAMS: InitStateVar=0.13937
X8664   87   229  memristor PARAMS: InitStateVar=0.320467
X8764   88   229  memristor PARAMS: InitStateVar=0.231502
X8864   89   229  memristor PARAMS: InitStateVar=0.247179
X8964   90   229  memristor PARAMS: InitStateVar=0.380633
X9064   91   229  memristor PARAMS: InitStateVar=0.149998
X9164   92   229  memristor PARAMS: InitStateVar=0.307201
X9264   93   229  memristor PARAMS: InitStateVar=0.409984
X9364   94   229  memristor PARAMS: InitStateVar=0.442835
X9464   95   229  memristor PARAMS: InitStateVar=0.263436
X9564   96   229  memristor PARAMS: InitStateVar=0.143113
X9664   97   229  memristor PARAMS: InitStateVar=0.36904
X9764   98   229  memristor PARAMS: InitStateVar=0.371277
X9864   99   229  memristor PARAMS: InitStateVar=0.246898
X9964   100  229  memristor PARAMS: InitStateVar=0.326313
Xo65    229  230  OutputModule PARAMS: Rval=100
*------------------- Column 66 -------------------------------------------------
X65     1    231  memristor PARAMS: InitStateVar=0.269208
X165    2    231  memristor PARAMS: InitStateVar=0.281409
X265    3    231  memristor PARAMS: InitStateVar=0.610996
X365    4    231  memristor PARAMS: InitStateVar=0.451005
X465    5    231  memristor PARAMS: InitStateVar=0.460833
X565    6    231  memristor PARAMS: InitStateVar=0.274031
X665    7    231  memristor PARAMS: InitStateVar=0.317391
X765    8    231  memristor PARAMS: InitStateVar=0.211411
X865    9    231  memristor PARAMS: InitStateVar=0.262089
X965    10   231  memristor PARAMS: InitStateVar=0.308386
X1065   11   231  memristor PARAMS: InitStateVar=0.217825
X1165   12   231  memristor PARAMS: InitStateVar=0.396208
X1265   13   231  memristor PARAMS: InitStateVar=0.345444
X1365   14   231  memristor PARAMS: InitStateVar=0.271356
X1465   15   231  memristor PARAMS: InitStateVar=0.284538
X1565   16   231  memristor PARAMS: InitStateVar=0.214452
X1665   17   231  memristor PARAMS: InitStateVar=0.333361
X1765   18   231  memristor PARAMS: InitStateVar=0.302383
X1865   19   231  memristor PARAMS: InitStateVar=0.331554
X1965   20   231  memristor PARAMS: InitStateVar=0.144942
X2065   21   231  memristor PARAMS: InitStateVar=0.113549
X2165   22   231  memristor PARAMS: InitStateVar=0.394762
X2265   23   231  memristor PARAMS: InitStateVar=0.346718
X2365   24   231  memristor PARAMS: InitStateVar=0.274581
X2465   25   231  memristor PARAMS: InitStateVar=0.360826
X2565   26   231  memristor PARAMS: InitStateVar=0.299568
X2665   27   231  memristor PARAMS: InitStateVar=0.317667
X2765   28   231  memristor PARAMS: InitStateVar=0.416977
X2865   29   231  memristor PARAMS: InitStateVar=0.356852
X2965   30   231  memristor PARAMS: InitStateVar=0.383789
X3065   31   231  memristor PARAMS: InitStateVar=0.308388
X3165   32   231  memristor PARAMS: InitStateVar=0.389219
X3265   33   231  memristor PARAMS: InitStateVar=0.515905
X3365   34   231  memristor PARAMS: InitStateVar=0.193351
X3465   35   231  memristor PARAMS: InitStateVar=0.214592
X3565   36   231  memristor PARAMS: InitStateVar=0.175864
X3665   37   231  memristor PARAMS: InitStateVar=0.287506
X3765   38   231  memristor PARAMS: InitStateVar=0.218114
X3865   39   231  memristor PARAMS: InitStateVar=0.3906
X3965   40   231  memristor PARAMS: InitStateVar=0.345036
X4065   41   231  memristor PARAMS: InitStateVar=0.252847
X4165   42   231  memristor PARAMS: InitStateVar=0.28135
X4265   43   231  memristor PARAMS: InitStateVar=0.244315
X4365   44   231  memristor PARAMS: InitStateVar=0.236317
X4465   45   231  memristor PARAMS: InitStateVar=0.246842
X4565   46   231  memristor PARAMS: InitStateVar=0.0851995
X4665   47   231  memristor PARAMS: InitStateVar=0.238936
X4765   48   231  memristor PARAMS: InitStateVar=0.186359
X4865   49   231  memristor PARAMS: InitStateVar=0.401373
X4965   50   231  memristor PARAMS: InitStateVar=0.157237
X5065   51   231  memristor PARAMS: InitStateVar=0.27776
X5165   52   231  memristor PARAMS: InitStateVar=0.178401
X5265   53   231  memristor PARAMS: InitStateVar=0.329675
X5365   54   231  memristor PARAMS: InitStateVar=0.251349
X5465   55   231  memristor PARAMS: InitStateVar=0.240411
X5565   56   231  memristor PARAMS: InitStateVar=0.219211
X5665   57   231  memristor PARAMS: InitStateVar=0.38529
X5765   58   231  memristor PARAMS: InitStateVar=0.36128
X5865   59   231  memristor PARAMS: InitStateVar=0.316182
X5965   60   231  memristor PARAMS: InitStateVar=0.305479
X6065   61   231  memristor PARAMS: InitStateVar=0.353669
X6165   62   231  memristor PARAMS: InitStateVar=0.342822
X6265   63   231  memristor PARAMS: InitStateVar=0.0648989
X6365   64   231  memristor PARAMS: InitStateVar=0.254744
X6465   65   231  memristor PARAMS: InitStateVar=0.387249
X6565   66   231  memristor PARAMS: InitStateVar=0.26329
X6665   67   231  memristor PARAMS: InitStateVar=0.281568
X6765   68   231  memristor PARAMS: InitStateVar=0.269369
X6865   69   231  memristor PARAMS: InitStateVar=0.305217
X6965   70   231  memristor PARAMS: InitStateVar=0.408452
X7065   71   231  memristor PARAMS: InitStateVar=0.297335
X7165   72   231  memristor PARAMS: InitStateVar=0.239308
X7265   73   231  memristor PARAMS: InitStateVar=0.406292
X7365   74   231  memristor PARAMS: InitStateVar=0.400974
X7465   75   231  memristor PARAMS: InitStateVar=0.250274
X7565   76   231  memristor PARAMS: InitStateVar=0.214648
X7665   77   231  memristor PARAMS: InitStateVar=0.312927
X7765   78   231  memristor PARAMS: InitStateVar=0.219027
X7865   79   231  memristor PARAMS: InitStateVar=0.234694
X7965   80   231  memristor PARAMS: InitStateVar=0.0558988
X8065   81   231  memristor PARAMS: InitStateVar=0.199006
X8165   82   231  memristor PARAMS: InitStateVar=0.32182
X8265   83   231  memristor PARAMS: InitStateVar=0.253595
X8365   84   231  memristor PARAMS: InitStateVar=0.400505
X8465   85   231  memristor PARAMS: InitStateVar=0.26611
X8565   86   231  memristor PARAMS: InitStateVar=0.262854
X8665   87   231  memristor PARAMS: InitStateVar=0.436571
X8765   88   231  memristor PARAMS: InitStateVar=0.470924
X8865   89   231  memristor PARAMS: InitStateVar=0.431477
X8965   90   231  memristor PARAMS: InitStateVar=0.222901
X9065   91   231  memristor PARAMS: InitStateVar=0.261547
X9165   92   231  memristor PARAMS: InitStateVar=0.104808
X9265   93   231  memristor PARAMS: InitStateVar=0.315794
X9365   94   231  memristor PARAMS: InitStateVar=0.230155
X9465   95   231  memristor PARAMS: InitStateVar=0.197657
X9565   96   231  memristor PARAMS: InitStateVar=0.355096
X9665   97   231  memristor PARAMS: InitStateVar=0.298062
X9765   98   231  memristor PARAMS: InitStateVar=0.230826
X9865   99   231  memristor PARAMS: InitStateVar=0.292596
X9965   100  231  memristor PARAMS: InitStateVar=0.387175
Xo66    231  232  OutputModule PARAMS: Rval=100
*------------------- Column 67 -------------------------------------------------
X66     1    233  memristor PARAMS: InitStateVar=0.0873333
X166    2    233  memristor PARAMS: InitStateVar=0.247784
X266    3    233  memristor PARAMS: InitStateVar=0.222418
X366    4    233  memristor PARAMS: InitStateVar=0.127454
X466    5    233  memristor PARAMS: InitStateVar=0.464724
X566    6    233  memristor PARAMS: InitStateVar=0.1293
X666    7    233  memristor PARAMS: InitStateVar=0.223149
X766    8    233  memristor PARAMS: InitStateVar=0.174788
X866    9    233  memristor PARAMS: InitStateVar=0.300064
X966    10   233  memristor PARAMS: InitStateVar=0.301091
X1066   11   233  memristor PARAMS: InitStateVar=0.431115
X1166   12   233  memristor PARAMS: InitStateVar=0.307605
X1266   13   233  memristor PARAMS: InitStateVar=0.353086
X1366   14   233  memristor PARAMS: InitStateVar=0.135332
X1466   15   233  memristor PARAMS: InitStateVar=0.317736
X1566   16   233  memristor PARAMS: InitStateVar=0.225324
X1666   17   233  memristor PARAMS: InitStateVar=0.243091
X1766   18   233  memristor PARAMS: InitStateVar=0.406469
X1866   19   233  memristor PARAMS: InitStateVar=0.338199
X1966   20   233  memristor PARAMS: InitStateVar=0.145173
X2066   21   233  memristor PARAMS: InitStateVar=0.438596
X2166   22   233  memristor PARAMS: InitStateVar=0.291275
X2266   23   233  memristor PARAMS: InitStateVar=0.375167
X2366   24   233  memristor PARAMS: InitStateVar=0.22083
X2466   25   233  memristor PARAMS: InitStateVar=0.33995
X2566   26   233  memristor PARAMS: InitStateVar=0.264361
X2666   27   233  memristor PARAMS: InitStateVar=0.27191
X2766   28   233  memristor PARAMS: InitStateVar=0.245982
X2866   29   233  memristor PARAMS: InitStateVar=0.229848
X2966   30   233  memristor PARAMS: InitStateVar=0.384681
X3066   31   233  memristor PARAMS: InitStateVar=0.368601
X3166   32   233  memristor PARAMS: InitStateVar=0.318955
X3266   33   233  memristor PARAMS: InitStateVar=0.181721
X3366   34   233  memristor PARAMS: InitStateVar=0.248105
X3466   35   233  memristor PARAMS: InitStateVar=0.418666
X3566   36   233  memristor PARAMS: InitStateVar=0.222499
X3666   37   233  memristor PARAMS: InitStateVar=0.239789
X3766   38   233  memristor PARAMS: InitStateVar=0.464729
X3866   39   233  memristor PARAMS: InitStateVar=0.239696
X3966   40   233  memristor PARAMS: InitStateVar=0.269068
X4066   41   233  memristor PARAMS: InitStateVar=0.213894
X4166   42   233  memristor PARAMS: InitStateVar=0.3805
X4266   43   233  memristor PARAMS: InitStateVar=0.259756
X4366   44   233  memristor PARAMS: InitStateVar=0.456014
X4466   45   233  memristor PARAMS: InitStateVar=0.349422
X4566   46   233  memristor PARAMS: InitStateVar=0.408024
X4666   47   233  memristor PARAMS: InitStateVar=0.303835
X4766   48   233  memristor PARAMS: InitStateVar=0.403667
X4866   49   233  memristor PARAMS: InitStateVar=0.265278
X4966   50   233  memristor PARAMS: InitStateVar=0.347176
X5066   51   233  memristor PARAMS: InitStateVar=0.452783
X5166   52   233  memristor PARAMS: InitStateVar=0.418751
X5266   53   233  memristor PARAMS: InitStateVar=0.315393
X5366   54   233  memristor PARAMS: InitStateVar=0.227792
X5466   55   233  memristor PARAMS: InitStateVar=0.315069
X5566   56   233  memristor PARAMS: InitStateVar=0.501136
X5666   57   233  memristor PARAMS: InitStateVar=0.25032
X5766   58   233  memristor PARAMS: InitStateVar=0.148228
X5866   59   233  memristor PARAMS: InitStateVar=0.370188
X5966   60   233  memristor PARAMS: InitStateVar=0.26678
X6066   61   233  memristor PARAMS: InitStateVar=0.421913
X6166   62   233  memristor PARAMS: InitStateVar=0.321879
X6266   63   233  memristor PARAMS: InitStateVar=0.532148
X6366   64   233  memristor PARAMS: InitStateVar=0.203286
X6466   65   233  memristor PARAMS: InitStateVar=0.386986
X6566   66   233  memristor PARAMS: InitStateVar=0.31523
X6666   67   233  memristor PARAMS: InitStateVar=0.17299
X6766   68   233  memristor PARAMS: InitStateVar=0.40465
X6866   69   233  memristor PARAMS: InitStateVar=0.27614
X6966   70   233  memristor PARAMS: InitStateVar=0.290527
X7066   71   233  memristor PARAMS: InitStateVar=0.267409
X7166   72   233  memristor PARAMS: InitStateVar=0.21106
X7266   73   233  memristor PARAMS: InitStateVar=0.395707
X7366   74   233  memristor PARAMS: InitStateVar=0.091354
X7466   75   233  memristor PARAMS: InitStateVar=0.364663
X7566   76   233  memristor PARAMS: InitStateVar=0.400493
X7666   77   233  memristor PARAMS: InitStateVar=0.149548
X7766   78   233  memristor PARAMS: InitStateVar=0.316012
X7866   79   233  memristor PARAMS: InitStateVar=0.247602
X7966   80   233  memristor PARAMS: InitStateVar=0.108711
X8066   81   233  memristor PARAMS: InitStateVar=0.282964
X8166   82   233  memristor PARAMS: InitStateVar=0.219879
X8266   83   233  memristor PARAMS: InitStateVar=0.262344
X8366   84   233  memristor PARAMS: InitStateVar=0.321553
X8466   85   233  memristor PARAMS: InitStateVar=0.213673
X8566   86   233  memristor PARAMS: InitStateVar=0.32914
X8666   87   233  memristor PARAMS: InitStateVar=0.378323
X8766   88   233  memristor PARAMS: InitStateVar=0.144762
X8866   89   233  memristor PARAMS: InitStateVar=0.344944
X8966   90   233  memristor PARAMS: InitStateVar=0.379509
X9066   91   233  memristor PARAMS: InitStateVar=0.282294
X9166   92   233  memristor PARAMS: InitStateVar=0.385273
X9266   93   233  memristor PARAMS: InitStateVar=0.212941
X9366   94   233  memristor PARAMS: InitStateVar=0.343967
X9466   95   233  memristor PARAMS: InitStateVar=0.101797
X9566   96   233  memristor PARAMS: InitStateVar=0.315693
X9666   97   233  memristor PARAMS: InitStateVar=0.37278
X9766   98   233  memristor PARAMS: InitStateVar=0.259553
X9866   99   233  memristor PARAMS: InitStateVar=0.350466
X9966   100  233  memristor PARAMS: InitStateVar=0.43681
Xo67    233  234  OutputModule PARAMS: Rval=100
*------------------- Column 68 -------------------------------------------------
X67     1    235  memristor PARAMS: InitStateVar=0.360013
X167    2    235  memristor PARAMS: InitStateVar=0.392372
X267    3    235  memristor PARAMS: InitStateVar=0.119066
X367    4    235  memristor PARAMS: InitStateVar=0.192044
X467    5    235  memristor PARAMS: InitStateVar=0.596456
X567    6    235  memristor PARAMS: InitStateVar=0.301907
X667    7    235  memristor PARAMS: InitStateVar=0.308311
X767    8    235  memristor PARAMS: InitStateVar=0.260127
X867    9    235  memristor PARAMS: InitStateVar=0.185076
X967    10   235  memristor PARAMS: InitStateVar=0.384039
X1067   11   235  memristor PARAMS: InitStateVar=0.312928
X1167   12   235  memristor PARAMS: InitStateVar=0.280767
X1267   13   235  memristor PARAMS: InitStateVar=0.335957
X1367   14   235  memristor PARAMS: InitStateVar=0.344127
X1467   15   235  memristor PARAMS: InitStateVar=0.316094
X1567   16   235  memristor PARAMS: InitStateVar=0.254521
X1667   17   235  memristor PARAMS: InitStateVar=0.28461
X1767   18   235  memristor PARAMS: InitStateVar=0.324552
X1867   19   235  memristor PARAMS: InitStateVar=0.189909
X1967   20   235  memristor PARAMS: InitStateVar=0.336132
X2067   21   235  memristor PARAMS: InitStateVar=0.198853
X2167   22   235  memristor PARAMS: InitStateVar=0.166446
X2267   23   235  memristor PARAMS: InitStateVar=0.268125
X2367   24   235  memristor PARAMS: InitStateVar=0.2037
X2467   25   235  memristor PARAMS: InitStateVar=0.389777
X2567   26   235  memristor PARAMS: InitStateVar=0.376713
X2667   27   235  memristor PARAMS: InitStateVar=0.398
X2767   28   235  memristor PARAMS: InitStateVar=0.157362
X2867   29   235  memristor PARAMS: InitStateVar=0.272835
X2967   30   235  memristor PARAMS: InitStateVar=0.256632
X3067   31   235  memristor PARAMS: InitStateVar=0.397813
X3167   32   235  memristor PARAMS: InitStateVar=0.316219
X3267   33   235  memristor PARAMS: InitStateVar=0.268532
X3367   34   235  memristor PARAMS: InitStateVar=0.407102
X3467   35   235  memristor PARAMS: InitStateVar=0.202855
X3567   36   235  memristor PARAMS: InitStateVar=0.417338
X3667   37   235  memristor PARAMS: InitStateVar=0.334347
X3767   38   235  memristor PARAMS: InitStateVar=0.274192
X3867   39   235  memristor PARAMS: InitStateVar=0.362429
X3967   40   235  memristor PARAMS: InitStateVar=0.361306
X4067   41   235  memristor PARAMS: InitStateVar=0.114924
X4167   42   235  memristor PARAMS: InitStateVar=0.336675
X4267   43   235  memristor PARAMS: InitStateVar=0.171842
X4367   44   235  memristor PARAMS: InitStateVar=0.277681
X4467   45   235  memristor PARAMS: InitStateVar=0.414658
X4567   46   235  memristor PARAMS: InitStateVar=0.361941
X4667   47   235  memristor PARAMS: InitStateVar=0.432026
X4767   48   235  memristor PARAMS: InitStateVar=0.327652
X4867   49   235  memristor PARAMS: InitStateVar=0.295071
X4967   50   235  memristor PARAMS: InitStateVar=0.378109
X5067   51   235  memristor PARAMS: InitStateVar=0.234199
X5167   52   235  memristor PARAMS: InitStateVar=0.374578
X5267   53   235  memristor PARAMS: InitStateVar=0.248545
X5367   54   235  memristor PARAMS: InitStateVar=0.262747
X5467   55   235  memristor PARAMS: InitStateVar=0.236521
X5567   56   235  memristor PARAMS: InitStateVar=0.0729029
X5667   57   235  memristor PARAMS: InitStateVar=0.323336
X5767   58   235  memristor PARAMS: InitStateVar=0.357203
X5867   59   235  memristor PARAMS: InitStateVar=0.296607
X5967   60   235  memristor PARAMS: InitStateVar=0.317383
X6067   61   235  memristor PARAMS: InitStateVar=0.237236
X6167   62   235  memristor PARAMS: InitStateVar=0.254511
X6267   63   235  memristor PARAMS: InitStateVar=0.207608
X6367   64   235  memristor PARAMS: InitStateVar=0.17123
X6467   65   235  memristor PARAMS: InitStateVar=0.263515
X6567   66   235  memristor PARAMS: InitStateVar=0.301578
X6667   67   235  memristor PARAMS: InitStateVar=0.314046
X6767   68   235  memristor PARAMS: InitStateVar=0.0573579
X6867   69   235  memristor PARAMS: InitStateVar=0.166509
X6967   70   235  memristor PARAMS: InitStateVar=0.36238
X7067   71   235  memristor PARAMS: InitStateVar=0.348937
X7167   72   235  memristor PARAMS: InitStateVar=0.331213
X7267   73   235  memristor PARAMS: InitStateVar=0.22869
X7367   74   235  memristor PARAMS: InitStateVar=0.176608
X7467   75   235  memristor PARAMS: InitStateVar=0.347272
X7567   76   235  memristor PARAMS: InitStateVar=0.289475
X7667   77   235  memristor PARAMS: InitStateVar=0.199426
X7767   78   235  memristor PARAMS: InitStateVar=0.368833
X7867   79   235  memristor PARAMS: InitStateVar=0.376527
X7967   80   235  memristor PARAMS: InitStateVar=0.41392
X8067   81   235  memristor PARAMS: InitStateVar=0.27624
X8167   82   235  memristor PARAMS: InitStateVar=0.380499
X8267   83   235  memristor PARAMS: InitStateVar=0.371045
X8367   84   235  memristor PARAMS: InitStateVar=0.478911
X8467   85   235  memristor PARAMS: InitStateVar=0.194191
X8567   86   235  memristor PARAMS: InitStateVar=0.246684
X8667   87   235  memristor PARAMS: InitStateVar=0.22591
X8767   88   235  memristor PARAMS: InitStateVar=0.329845
X8867   89   235  memristor PARAMS: InitStateVar=0.249881
X8967   90   235  memristor PARAMS: InitStateVar=0.231188
X9067   91   235  memristor PARAMS: InitStateVar=0.265932
X9167   92   235  memristor PARAMS: InitStateVar=0.226322
X9267   93   235  memristor PARAMS: InitStateVar=0.405897
X9367   94   235  memristor PARAMS: InitStateVar=0.36016
X9467   95   235  memristor PARAMS: InitStateVar=0.391733
X9567   96   235  memristor PARAMS: InitStateVar=0.200562
X9667   97   235  memristor PARAMS: InitStateVar=0.495274
X9767   98   235  memristor PARAMS: InitStateVar=0.482103
X9867   99   235  memristor PARAMS: InitStateVar=0.342118
X9967   100  235  memristor PARAMS: InitStateVar=0.376954
Xo68    235  236  OutputModule PARAMS: Rval=100
*------------------- Column 69 -------------------------------------------------
X68     1    237  memristor PARAMS: InitStateVar=0.23551
X168    2    237  memristor PARAMS: InitStateVar=0.272414
X268    3    237  memristor PARAMS: InitStateVar=0.393632
X368    4    237  memristor PARAMS: InitStateVar=0.320906
X468    5    237  memristor PARAMS: InitStateVar=0.374341
X568    6    237  memristor PARAMS: InitStateVar=0.42694
X668    7    237  memristor PARAMS: InitStateVar=0.448436
X768    8    237  memristor PARAMS: InitStateVar=0.309355
X868    9    237  memristor PARAMS: InitStateVar=0.347741
X968    10   237  memristor PARAMS: InitStateVar=0.441112
X1068   11   237  memristor PARAMS: InitStateVar=0.114984
X1168   12   237  memristor PARAMS: InitStateVar=0.246741
X1268   13   237  memristor PARAMS: InitStateVar=0.375508
X1368   14   237  memristor PARAMS: InitStateVar=0.261584
X1468   15   237  memristor PARAMS: InitStateVar=0.29197
X1568   16   237  memristor PARAMS: InitStateVar=0.11514
X1668   17   237  memristor PARAMS: InitStateVar=0.224857
X1768   18   237  memristor PARAMS: InitStateVar=0.0430364
X1868   19   237  memristor PARAMS: InitStateVar=0.290879
X1968   20   237  memristor PARAMS: InitStateVar=0.399469
X2068   21   237  memristor PARAMS: InitStateVar=0.302399
X2168   22   237  memristor PARAMS: InitStateVar=0.0849897
X2268   23   237  memristor PARAMS: InitStateVar=0.304871
X2368   24   237  memristor PARAMS: InitStateVar=0.533949
X2468   25   237  memristor PARAMS: InitStateVar=0.454842
X2568   26   237  memristor PARAMS: InitStateVar=0.422082
X2668   27   237  memristor PARAMS: InitStateVar=0.429212
X2768   28   237  memristor PARAMS: InitStateVar=0.229569
X2868   29   237  memristor PARAMS: InitStateVar=0.270431
X2968   30   237  memristor PARAMS: InitStateVar=0.237832
X3068   31   237  memristor PARAMS: InitStateVar=0.395201
X3168   32   237  memristor PARAMS: InitStateVar=0.325583
X3268   33   237  memristor PARAMS: InitStateVar=0.240533
X3368   34   237  memristor PARAMS: InitStateVar=0.359704
X3468   35   237  memristor PARAMS: InitStateVar=0.436046
X3568   36   237  memristor PARAMS: InitStateVar=0.305492
X3668   37   237  memristor PARAMS: InitStateVar=0.308825
X3768   38   237  memristor PARAMS: InitStateVar=0.115349
X3868   39   237  memristor PARAMS: InitStateVar=0.15545
X3968   40   237  memristor PARAMS: InitStateVar=0.235399
X4068   41   237  memristor PARAMS: InitStateVar=0.322238
X4168   42   237  memristor PARAMS: InitStateVar=0.166755
X4268   43   237  memristor PARAMS: InitStateVar=0.095162
X4368   44   237  memristor PARAMS: InitStateVar=0.362507
X4468   45   237  memristor PARAMS: InitStateVar=0.387447
X4568   46   237  memristor PARAMS: InitStateVar=0.417432
X4668   47   237  memristor PARAMS: InitStateVar=0.324591
X4768   48   237  memristor PARAMS: InitStateVar=0.453464
X4868   49   237  memristor PARAMS: InitStateVar=0.425343
X4968   50   237  memristor PARAMS: InitStateVar=0.141816
X5068   51   237  memristor PARAMS: InitStateVar=0.112017
X5168   52   237  memristor PARAMS: InitStateVar=0.298189
X5268   53   237  memristor PARAMS: InitStateVar=0.183672
X5368   54   237  memristor PARAMS: InitStateVar=0.348184
X5468   55   237  memristor PARAMS: InitStateVar=0.206101
X5568   56   237  memristor PARAMS: InitStateVar=0.335054
X5668   57   237  memristor PARAMS: InitStateVar=0.361345
X5768   58   237  memristor PARAMS: InitStateVar=0.364762
X5868   59   237  memristor PARAMS: InitStateVar=0.207716
X5968   60   237  memristor PARAMS: InitStateVar=0.459272
X6068   61   237  memristor PARAMS: InitStateVar=0.450408
X6168   62   237  memristor PARAMS: InitStateVar=0.253575
X6268   63   237  memristor PARAMS: InitStateVar=0.350149
X6368   64   237  memristor PARAMS: InitStateVar=0.439039
X6468   65   237  memristor PARAMS: InitStateVar=0.106371
X6568   66   237  memristor PARAMS: InitStateVar=0.289768
X6668   67   237  memristor PARAMS: InitStateVar=0.163511
X6768   68   237  memristor PARAMS: InitStateVar=0.210323
X6868   69   237  memristor PARAMS: InitStateVar=0.361878
X6968   70   237  memristor PARAMS: InitStateVar=0.215546
X7068   71   237  memristor PARAMS: InitStateVar=0.456924
X7168   72   237  memristor PARAMS: InitStateVar=0.240597
X7268   73   237  memristor PARAMS: InitStateVar=0.256023
X7368   74   237  memristor PARAMS: InitStateVar=0.455456
X7468   75   237  memristor PARAMS: InitStateVar=0.167631
X7568   76   237  memristor PARAMS: InitStateVar=0.460482
X7668   77   237  memristor PARAMS: InitStateVar=0.266142
X7768   78   237  memristor PARAMS: InitStateVar=0.220329
X7868   79   237  memristor PARAMS: InitStateVar=0.337433
X7968   80   237  memristor PARAMS: InitStateVar=0.369215
X8068   81   237  memristor PARAMS: InitStateVar=0.354013
X8168   82   237  memristor PARAMS: InitStateVar=0.0739508
X8268   83   237  memristor PARAMS: InitStateVar=0.193849
X8368   84   237  memristor PARAMS: InitStateVar=0.3039
X8468   85   237  memristor PARAMS: InitStateVar=0.267021
X8568   86   237  memristor PARAMS: InitStateVar=0.229486
X8668   87   237  memristor PARAMS: InitStateVar=0.380194
X8768   88   237  memristor PARAMS: InitStateVar=0.182954
X8868   89   237  memristor PARAMS: InitStateVar=0.298518
X8968   90   237  memristor PARAMS: InitStateVar=0.263333
X9068   91   237  memristor PARAMS: InitStateVar=0.253884
X9168   92   237  memristor PARAMS: InitStateVar=0.294707
X9268   93   237  memristor PARAMS: InitStateVar=0.0406266
X9368   94   237  memristor PARAMS: InitStateVar=0.19271
X9468   95   237  memristor PARAMS: InitStateVar=0.213832
X9568   96   237  memristor PARAMS: InitStateVar=0.156284
X9668   97   237  memristor PARAMS: InitStateVar=0.339907
X9768   98   237  memristor PARAMS: InitStateVar=0.584473
X9868   99   237  memristor PARAMS: InitStateVar=0.243442
X9968   100  237  memristor PARAMS: InitStateVar=0.214046
Xo69    237  238  OutputModule PARAMS: Rval=100
*------------------- Column 70 -------------------------------------------------
X69     1    239  memristor PARAMS: InitStateVar=0.178223
X169    2    239  memristor PARAMS: InitStateVar=0.403336
X269    3    239  memristor PARAMS: InitStateVar=0.379612
X369    4    239  memristor PARAMS: InitStateVar=0.312996
X469    5    239  memristor PARAMS: InitStateVar=0.240714
X569    6    239  memristor PARAMS: InitStateVar=0.454723
X669    7    239  memristor PARAMS: InitStateVar=0.341501
X769    8    239  memristor PARAMS: InitStateVar=0.269349
X869    9    239  memristor PARAMS: InitStateVar=0.455038
X969    10   239  memristor PARAMS: InitStateVar=0.320155
X1069   11   239  memristor PARAMS: InitStateVar=0.298867
X1169   12   239  memristor PARAMS: InitStateVar=0.369878
X1269   13   239  memristor PARAMS: InitStateVar=0.268738
X1369   14   239  memristor PARAMS: InitStateVar=0.115285
X1469   15   239  memristor PARAMS: InitStateVar=0.187074
X1569   16   239  memristor PARAMS: InitStateVar=0.307625
X1669   17   239  memristor PARAMS: InitStateVar=0.220567
X1769   18   239  memristor PARAMS: InitStateVar=0.391575
X1869   19   239  memristor PARAMS: InitStateVar=0.183095
X1969   20   239  memristor PARAMS: InitStateVar=0.254705
X2069   21   239  memristor PARAMS: InitStateVar=0.392255
X2169   22   239  memristor PARAMS: InitStateVar=0.394243
X2269   23   239  memristor PARAMS: InitStateVar=0.260961
X2369   24   239  memristor PARAMS: InitStateVar=0.206451
X2469   25   239  memristor PARAMS: InitStateVar=0.302645
X2569   26   239  memristor PARAMS: InitStateVar=0.420908
X2669   27   239  memristor PARAMS: InitStateVar=0.179555
X2769   28   239  memristor PARAMS: InitStateVar=0.345605
X2869   29   239  memristor PARAMS: InitStateVar=0.298398
X2969   30   239  memristor PARAMS: InitStateVar=0.201722
X3069   31   239  memristor PARAMS: InitStateVar=0.184945
X3169   32   239  memristor PARAMS: InitStateVar=0.36019
X3269   33   239  memristor PARAMS: InitStateVar=0.201949
X3369   34   239  memristor PARAMS: InitStateVar=0.32942
X3469   35   239  memristor PARAMS: InitStateVar=0.172843
X3569   36   239  memristor PARAMS: InitStateVar=0.334473
X3669   37   239  memristor PARAMS: InitStateVar=0.251779
X3769   38   239  memristor PARAMS: InitStateVar=0.302113
X3869   39   239  memristor PARAMS: InitStateVar=0.264859
X3969   40   239  memristor PARAMS: InitStateVar=0.310206
X4069   41   239  memristor PARAMS: InitStateVar=0.488882
X4169   42   239  memristor PARAMS: InitStateVar=0.237387
X4269   43   239  memristor PARAMS: InitStateVar=0.318244
X4369   44   239  memristor PARAMS: InitStateVar=0.125547
X4469   45   239  memristor PARAMS: InitStateVar=0.4007
X4569   46   239  memristor PARAMS: InitStateVar=0.215883
X4669   47   239  memristor PARAMS: InitStateVar=0.192409
X4769   48   239  memristor PARAMS: InitStateVar=0.0394783
X4869   49   239  memristor PARAMS: InitStateVar=0.309695
X4969   50   239  memristor PARAMS: InitStateVar=0.302811
X5069   51   239  memristor PARAMS: InitStateVar=0.289452
X5169   52   239  memristor PARAMS: InitStateVar=0.104316
X5269   53   239  memristor PARAMS: InitStateVar=0.345834
X5369   54   239  memristor PARAMS: InitStateVar=0.322114
X5469   55   239  memristor PARAMS: InitStateVar=0.323343
X5569   56   239  memristor PARAMS: InitStateVar=0.43741
X5669   57   239  memristor PARAMS: InitStateVar=0.218745
X5769   58   239  memristor PARAMS: InitStateVar=0.0716067
X5869   59   239  memristor PARAMS: InitStateVar=0.192588
X5969   60   239  memristor PARAMS: InitStateVar=0.231382
X6069   61   239  memristor PARAMS: InitStateVar=0.0471755
X6169   62   239  memristor PARAMS: InitStateVar=0.260269
X6269   63   239  memristor PARAMS: InitStateVar=0.279557
X6369   64   239  memristor PARAMS: InitStateVar=0.251646
X6469   65   239  memristor PARAMS: InitStateVar=0.235287
X6569   66   239  memristor PARAMS: InitStateVar=0.25295
X6669   67   239  memristor PARAMS: InitStateVar=0.315075
X6769   68   239  memristor PARAMS: InitStateVar=0.445553
X6869   69   239  memristor PARAMS: InitStateVar=0.454145
X6969   70   239  memristor PARAMS: InitStateVar=0.430538
X7069   71   239  memristor PARAMS: InitStateVar=0.443753
X7169   72   239  memristor PARAMS: InitStateVar=0.330937
X7269   73   239  memristor PARAMS: InitStateVar=0.286404
X7369   74   239  memristor PARAMS: InitStateVar=0.231053
X7469   75   239  memristor PARAMS: InitStateVar=0.346286
X7569   76   239  memristor PARAMS: InitStateVar=0.330376
X7669   77   239  memristor PARAMS: InitStateVar=0.206708
X7769   78   239  memristor PARAMS: InitStateVar=0.181694
X7869   79   239  memristor PARAMS: InitStateVar=0.210393
X7969   80   239  memristor PARAMS: InitStateVar=0.397984
X8069   81   239  memristor PARAMS: InitStateVar=0.141938
X8169   82   239  memristor PARAMS: InitStateVar=0.410678
X8269   83   239  memristor PARAMS: InitStateVar=0.298131
X8369   84   239  memristor PARAMS: InitStateVar=0.158622
X8469   85   239  memristor PARAMS: InitStateVar=0.351344
X8569   86   239  memristor PARAMS: InitStateVar=0.287834
X8669   87   239  memristor PARAMS: InitStateVar=0.227846
X8769   88   239  memristor PARAMS: InitStateVar=0.428772
X8869   89   239  memristor PARAMS: InitStateVar=0.346649
X8969   90   239  memristor PARAMS: InitStateVar=0.174331
X9069   91   239  memristor PARAMS: InitStateVar=0.402379
X9169   92   239  memristor PARAMS: InitStateVar=0.295962
X9269   93   239  memristor PARAMS: InitStateVar=0.259847
X9369   94   239  memristor PARAMS: InitStateVar=0.377263
X9469   95   239  memristor PARAMS: InitStateVar=0.236562
X9569   96   239  memristor PARAMS: InitStateVar=0.326089
X9669   97   239  memristor PARAMS: InitStateVar=0.205787
X9769   98   239  memristor PARAMS: InitStateVar=0.338115
X9869   99   239  memristor PARAMS: InitStateVar=0.238854
X9969   100  239  memristor PARAMS: InitStateVar=0.185014
Xo70    239  240  OutputModule PARAMS: Rval=100
*------------------- Column 71 -------------------------------------------------
X70     1    241  memristor PARAMS: InitStateVar=0.24408
X170    2    241  memristor PARAMS: InitStateVar=0.224572
X270    3    241  memristor PARAMS: InitStateVar=0.363892
X370    4    241  memristor PARAMS: InitStateVar=0.232827
X470    5    241  memristor PARAMS: InitStateVar=0.34915
X570    6    241  memristor PARAMS: InitStateVar=0.155152
X670    7    241  memristor PARAMS: InitStateVar=0.220073
X770    8    241  memristor PARAMS: InitStateVar=0.218789
X870    9    241  memristor PARAMS: InitStateVar=0.239044
X970    10   241  memristor PARAMS: InitStateVar=0.46924
X1070   11   241  memristor PARAMS: InitStateVar=0.590097
X1170   12   241  memristor PARAMS: InitStateVar=0.159355
X1270   13   241  memristor PARAMS: InitStateVar=0.20509
X1370   14   241  memristor PARAMS: InitStateVar=0.297667
X1470   15   241  memristor PARAMS: InitStateVar=0.368212
X1570   16   241  memristor PARAMS: InitStateVar=0.424272
X1670   17   241  memristor PARAMS: InitStateVar=0.136744
X1770   18   241  memristor PARAMS: InitStateVar=0.224613
X1870   19   241  memristor PARAMS: InitStateVar=0.155155
X1970   20   241  memristor PARAMS: InitStateVar=0.44959
X2070   21   241  memristor PARAMS: InitStateVar=0.3716
X2170   22   241  memristor PARAMS: InitStateVar=0.455447
X2270   23   241  memristor PARAMS: InitStateVar=0.35363
X2370   24   241  memristor PARAMS: InitStateVar=0.342763
X2470   25   241  memristor PARAMS: InitStateVar=0.408063
X2570   26   241  memristor PARAMS: InitStateVar=0.388485
X2670   27   241  memristor PARAMS: InitStateVar=0.306813
X2770   28   241  memristor PARAMS: InitStateVar=0.583383
X2870   29   241  memristor PARAMS: InitStateVar=0.0338869
X2970   30   241  memristor PARAMS: InitStateVar=0.327743
X3070   31   241  memristor PARAMS: InitStateVar=0.473358
X3170   32   241  memristor PARAMS: InitStateVar=0.135966
X3270   33   241  memristor PARAMS: InitStateVar=0.263798
X3370   34   241  memristor PARAMS: InitStateVar=0.212185
X3470   35   241  memristor PARAMS: InitStateVar=0.199039
X3570   36   241  memristor PARAMS: InitStateVar=0.319705
X3670   37   241  memristor PARAMS: InitStateVar=0.281948
X3770   38   241  memristor PARAMS: InitStateVar=0.435146
X3870   39   241  memristor PARAMS: InitStateVar=0.452624
X3970   40   241  memristor PARAMS: InitStateVar=0.165966
X4070   41   241  memristor PARAMS: InitStateVar=0.313458
X4170   42   241  memristor PARAMS: InitStateVar=0.254049
X4270   43   241  memristor PARAMS: InitStateVar=0.484791
X4370   44   241  memristor PARAMS: InitStateVar=0.230964
X4470   45   241  memristor PARAMS: InitStateVar=0.326194
X4570   46   241  memristor PARAMS: InitStateVar=0.221568
X4670   47   241  memristor PARAMS: InitStateVar=0.361593
X4770   48   241  memristor PARAMS: InitStateVar=0.336341
X4870   49   241  memristor PARAMS: InitStateVar=0.252245
X4970   50   241  memristor PARAMS: InitStateVar=0.278057
X5070   51   241  memristor PARAMS: InitStateVar=0.404456
X5170   52   241  memristor PARAMS: InitStateVar=0.323061
X5270   53   241  memristor PARAMS: InitStateVar=0.385184
X5370   54   241  memristor PARAMS: InitStateVar=0.298023
X5470   55   241  memristor PARAMS: InitStateVar=0.439329
X5570   56   241  memristor PARAMS: InitStateVar=0.473602
X5670   57   241  memristor PARAMS: InitStateVar=0.436725
X5770   58   241  memristor PARAMS: InitStateVar=0.375235
X5870   59   241  memristor PARAMS: InitStateVar=0.139426
X5970   60   241  memristor PARAMS: InitStateVar=0.206698
X6070   61   241  memristor PARAMS: InitStateVar=0.246552
X6170   62   241  memristor PARAMS: InitStateVar=0.308124
X6270   63   241  memristor PARAMS: InitStateVar=0.270371
X6370   64   241  memristor PARAMS: InitStateVar=0.225966
X6470   65   241  memristor PARAMS: InitStateVar=0.287455
X6570   66   241  memristor PARAMS: InitStateVar=0.303437
X6670   67   241  memristor PARAMS: InitStateVar=0.101876
X6770   68   241  memristor PARAMS: InitStateVar=0.431761
X6870   69   241  memristor PARAMS: InitStateVar=0.419985
X6970   70   241  memristor PARAMS: InitStateVar=0.333374
X7070   71   241  memristor PARAMS: InitStateVar=0.246294
X7170   72   241  memristor PARAMS: InitStateVar=0.398959
X7270   73   241  memristor PARAMS: InitStateVar=0.222994
X7370   74   241  memristor PARAMS: InitStateVar=0.33821
X7470   75   241  memristor PARAMS: InitStateVar=0.35842
X7570   76   241  memristor PARAMS: InitStateVar=0.240382
X7670   77   241  memristor PARAMS: InitStateVar=0.234072
X7770   78   241  memristor PARAMS: InitStateVar=0.425027
X7870   79   241  memristor PARAMS: InitStateVar=0.32133
X7970   80   241  memristor PARAMS: InitStateVar=0.450649
X8070   81   241  memristor PARAMS: InitStateVar=0.262697
X8170   82   241  memristor PARAMS: InitStateVar=0.294953
X8270   83   241  memristor PARAMS: InitStateVar=0.321121
X8370   84   241  memristor PARAMS: InitStateVar=0.321279
X8470   85   241  memristor PARAMS: InitStateVar=0.348067
X8570   86   241  memristor PARAMS: InitStateVar=0.193881
X8670   87   241  memristor PARAMS: InitStateVar=0.386807
X8770   88   241  memristor PARAMS: InitStateVar=0.13788
X8870   89   241  memristor PARAMS: InitStateVar=0.368221
X8970   90   241  memristor PARAMS: InitStateVar=0.199341
X9070   91   241  memristor PARAMS: InitStateVar=0.173344
X9170   92   241  memristor PARAMS: InitStateVar=0.335304
X9270   93   241  memristor PARAMS: InitStateVar=0.228796
X9370   94   241  memristor PARAMS: InitStateVar=0.29485
X9470   95   241  memristor PARAMS: InitStateVar=0.155745
X9570   96   241  memristor PARAMS: InitStateVar=0.299825
X9670   97   241  memristor PARAMS: InitStateVar=0.259295
X9770   98   241  memristor PARAMS: InitStateVar=0.179772
X9870   99   241  memristor PARAMS: InitStateVar=0.388396
X9970   100  241  memristor PARAMS: InitStateVar=0.244339
Xo71    241  242  OutputModule PARAMS: Rval=100
*------------------- Column 72 -------------------------------------------------
X71     1    243  memristor PARAMS: InitStateVar=0.345511
X171    2    243  memristor PARAMS: InitStateVar=0.238639
X271    3    243  memristor PARAMS: InitStateVar=0.323473
X371    4    243  memristor PARAMS: InitStateVar=0.237598
X471    5    243  memristor PARAMS: InitStateVar=0.279664
X571    6    243  memristor PARAMS: InitStateVar=0.488117
X671    7    243  memristor PARAMS: InitStateVar=0.288327
X771    8    243  memristor PARAMS: InitStateVar=0.472763
X871    9    243  memristor PARAMS: InitStateVar=0.283179
X971    10   243  memristor PARAMS: InitStateVar=0.366913
X1071   11   243  memristor PARAMS: InitStateVar=0.165794
X1171   12   243  memristor PARAMS: InitStateVar=0.263303
X1271   13   243  memristor PARAMS: InitStateVar=0.255802
X1371   14   243  memristor PARAMS: InitStateVar=0.263711
X1471   15   243  memristor PARAMS: InitStateVar=0.541982
X1571   16   243  memristor PARAMS: InitStateVar=0.327263
X1671   17   243  memristor PARAMS: InitStateVar=0.0882153
X1771   18   243  memristor PARAMS: InitStateVar=0.314789
X1871   19   243  memristor PARAMS: InitStateVar=0.371992
X1971   20   243  memristor PARAMS: InitStateVar=0.223929
X2071   21   243  memristor PARAMS: InitStateVar=0.10308
X2171   22   243  memristor PARAMS: InitStateVar=0.246466
X2271   23   243  memristor PARAMS: InitStateVar=0.350346
X2371   24   243  memristor PARAMS: InitStateVar=0.277056
X2471   25   243  memristor PARAMS: InitStateVar=0.307265
X2571   26   243  memristor PARAMS: InitStateVar=0.263134
X2671   27   243  memristor PARAMS: InitStateVar=0.286673
X2771   28   243  memristor PARAMS: InitStateVar=0.348823
X2871   29   243  memristor PARAMS: InitStateVar=0.384933
X2971   30   243  memristor PARAMS: InitStateVar=0.323026
X3071   31   243  memristor PARAMS: InitStateVar=0.42899
X3171   32   243  memristor PARAMS: InitStateVar=0.295305
X3271   33   243  memristor PARAMS: InitStateVar=0.412127
X3371   34   243  memristor PARAMS: InitStateVar=0.273686
X3471   35   243  memristor PARAMS: InitStateVar=0.26006
X3571   36   243  memristor PARAMS: InitStateVar=0.222181
X3671   37   243  memristor PARAMS: InitStateVar=0.266741
X3771   38   243  memristor PARAMS: InitStateVar=0.408842
X3871   39   243  memristor PARAMS: InitStateVar=0.231173
X3971   40   243  memristor PARAMS: InitStateVar=0.401722
X4071   41   243  memristor PARAMS: InitStateVar=0.34436
X4171   42   243  memristor PARAMS: InitStateVar=0.315645
X4271   43   243  memristor PARAMS: InitStateVar=0.341197
X4371   44   243  memristor PARAMS: InitStateVar=0.340563
X4471   45   243  memristor PARAMS: InitStateVar=0.307064
X4571   46   243  memristor PARAMS: InitStateVar=0.341946
X4671   47   243  memristor PARAMS: InitStateVar=0.316415
X4771   48   243  memristor PARAMS: InitStateVar=0.209438
X4871   49   243  memristor PARAMS: InitStateVar=0.287319
X4971   50   243  memristor PARAMS: InitStateVar=0.312379
X5071   51   243  memristor PARAMS: InitStateVar=0.260987
X5171   52   243  memristor PARAMS: InitStateVar=0.262474
X5271   53   243  memristor PARAMS: InitStateVar=0.392391
X5371   54   243  memristor PARAMS: InitStateVar=0.267371
X5471   55   243  memristor PARAMS: InitStateVar=0.17164
X5571   56   243  memristor PARAMS: InitStateVar=0.213728
X5671   57   243  memristor PARAMS: InitStateVar=0.106745
X5771   58   243  memristor PARAMS: InitStateVar=0.360013
X5871   59   243  memristor PARAMS: InitStateVar=0.292013
X5971   60   243  memristor PARAMS: InitStateVar=0.164863
X6071   61   243  memristor PARAMS: InitStateVar=0.252685
X6171   62   243  memristor PARAMS: InitStateVar=0.304912
X6271   63   243  memristor PARAMS: InitStateVar=0.365134
X6371   64   243  memristor PARAMS: InitStateVar=0.268358
X6471   65   243  memristor PARAMS: InitStateVar=0.253921
X6571   66   243  memristor PARAMS: InitStateVar=0.136212
X6671   67   243  memristor PARAMS: InitStateVar=0.362613
X6771   68   243  memristor PARAMS: InitStateVar=0.161874
X6871   69   243  memristor PARAMS: InitStateVar=0.0718567
X6971   70   243  memristor PARAMS: InitStateVar=0.376643
X7071   71   243  memristor PARAMS: InitStateVar=0.268458
X7171   72   243  memristor PARAMS: InitStateVar=0.239336
X7271   73   243  memristor PARAMS: InitStateVar=0.26092
X7371   74   243  memristor PARAMS: InitStateVar=0.418151
X7471   75   243  memristor PARAMS: InitStateVar=0.436021
X7571   76   243  memristor PARAMS: InitStateVar=0.254521
X7671   77   243  memristor PARAMS: InitStateVar=0.493795
X7771   78   243  memristor PARAMS: InitStateVar=0.273038
X7871   79   243  memristor PARAMS: InitStateVar=0.233481
X7971   80   243  memristor PARAMS: InitStateVar=0.168534
X8071   81   243  memristor PARAMS: InitStateVar=0.27641
X8171   82   243  memristor PARAMS: InitStateVar=0.350253
X8271   83   243  memristor PARAMS: InitStateVar=0.506099
X8371   84   243  memristor PARAMS: InitStateVar=0.244028
X8471   85   243  memristor PARAMS: InitStateVar=0.52202
X8571   86   243  memristor PARAMS: InitStateVar=0.385699
X8671   87   243  memristor PARAMS: InitStateVar=0.456411
X8771   88   243  memristor PARAMS: InitStateVar=0.288524
X8871   89   243  memristor PARAMS: InitStateVar=0.331544
X8971   90   243  memristor PARAMS: InitStateVar=0.280859
X9071   91   243  memristor PARAMS: InitStateVar=0.457058
X9171   92   243  memristor PARAMS: InitStateVar=0.270382
X9271   93   243  memristor PARAMS: InitStateVar=0.236287
X9371   94   243  memristor PARAMS: InitStateVar=0.427559
X9471   95   243  memristor PARAMS: InitStateVar=0.274982
X9571   96   243  memristor PARAMS: InitStateVar=0.439993
X9671   97   243  memristor PARAMS: InitStateVar=0.157262
X9771   98   243  memristor PARAMS: InitStateVar=0.184314
X9871   99   243  memristor PARAMS: InitStateVar=0.197491
X9971   100  243  memristor PARAMS: InitStateVar=0.168462
Xo72    243  244  OutputModule PARAMS: Rval=100
*------------------- Column 73 -------------------------------------------------
X72     1    245  memristor PARAMS: InitStateVar=0.350224
X172    2    245  memristor PARAMS: InitStateVar=0.434132
X272    3    245  memristor PARAMS: InitStateVar=0.396547
X372    4    245  memristor PARAMS: InitStateVar=0.323396
X472    5    245  memristor PARAMS: InitStateVar=0.359956
X572    6    245  memristor PARAMS: InitStateVar=0.228879
X672    7    245  memristor PARAMS: InitStateVar=0.235178
X772    8    245  memristor PARAMS: InitStateVar=0.232127
X872    9    245  memristor PARAMS: InitStateVar=0.346694
X972    10   245  memristor PARAMS: InitStateVar=0.289319
X1072   11   245  memristor PARAMS: InitStateVar=0.27158
X1172   12   245  memristor PARAMS: InitStateVar=0.330139
X1272   13   245  memristor PARAMS: InitStateVar=0.414378
X1372   14   245  memristor PARAMS: InitStateVar=0.329778
X1472   15   245  memristor PARAMS: InitStateVar=0.28379
X1572   16   245  memristor PARAMS: InitStateVar=0.236156
X1672   17   245  memristor PARAMS: InitStateVar=0.204687
X1772   18   245  memristor PARAMS: InitStateVar=0.238274
X1872   19   245  memristor PARAMS: InitStateVar=0.0541422
X1972   20   245  memristor PARAMS: InitStateVar=0.313735
X2072   21   245  memristor PARAMS: InitStateVar=0.286017
X2172   22   245  memristor PARAMS: InitStateVar=0.317541
X2272   23   245  memristor PARAMS: InitStateVar=0.157328
X2372   24   245  memristor PARAMS: InitStateVar=0.177707
X2472   25   245  memristor PARAMS: InitStateVar=0.403523
X2572   26   245  memristor PARAMS: InitStateVar=0.216155
X2672   27   245  memristor PARAMS: InitStateVar=0.359388
X2772   28   245  memristor PARAMS: InitStateVar=0.355197
X2872   29   245  memristor PARAMS: InitStateVar=0.162346
X2972   30   245  memristor PARAMS: InitStateVar=0.392741
X3072   31   245  memristor PARAMS: InitStateVar=0.118265
X3172   32   245  memristor PARAMS: InitStateVar=0.224951
X3272   33   245  memristor PARAMS: InitStateVar=0.183065
X3372   34   245  memristor PARAMS: InitStateVar=0.172706
X3472   35   245  memristor PARAMS: InitStateVar=0.448067
X3572   36   245  memristor PARAMS: InitStateVar=0.322199
X3672   37   245  memristor PARAMS: InitStateVar=0.161657
X3772   38   245  memristor PARAMS: InitStateVar=0.340366
X3872   39   245  memristor PARAMS: InitStateVar=0.379426
X3972   40   245  memristor PARAMS: InitStateVar=0.25257
X4072   41   245  memristor PARAMS: InitStateVar=0.283707
X4172   42   245  memristor PARAMS: InitStateVar=0.326086
X4272   43   245  memristor PARAMS: InitStateVar=0.214719
X4372   44   245  memristor PARAMS: InitStateVar=0.229186
X4472   45   245  memristor PARAMS: InitStateVar=0.343671
X4572   46   245  memristor PARAMS: InitStateVar=0.139047
X4672   47   245  memristor PARAMS: InitStateVar=0.382453
X4772   48   245  memristor PARAMS: InitStateVar=0.582883
X4872   49   245  memristor PARAMS: InitStateVar=0.429232
X4972   50   245  memristor PARAMS: InitStateVar=0.330021
X5072   51   245  memristor PARAMS: InitStateVar=0.414646
X5172   52   245  memristor PARAMS: InitStateVar=0.288852
X5272   53   245  memristor PARAMS: InitStateVar=0.21774
X5372   54   245  memristor PARAMS: InitStateVar=0.154183
X5472   55   245  memristor PARAMS: InitStateVar=0.261524
X5572   56   245  memristor PARAMS: InitStateVar=0.421542
X5672   57   245  memristor PARAMS: InitStateVar=0.310561
X5772   58   245  memristor PARAMS: InitStateVar=0.345561
X5872   59   245  memristor PARAMS: InitStateVar=0.466794
X5972   60   245  memristor PARAMS: InitStateVar=0.139866
X6072   61   245  memristor PARAMS: InitStateVar=0.214737
X6172   62   245  memristor PARAMS: InitStateVar=0.36383
X6272   63   245  memristor PARAMS: InitStateVar=0.317607
X6372   64   245  memristor PARAMS: InitStateVar=0.212923
X6472   65   245  memristor PARAMS: InitStateVar=0.345602
X6572   66   245  memristor PARAMS: InitStateVar=0.297374
X6672   67   245  memristor PARAMS: InitStateVar=0.313743
X6772   68   245  memristor PARAMS: InitStateVar=0.357954
X6872   69   245  memristor PARAMS: InitStateVar=0.352107
X6972   70   245  memristor PARAMS: InitStateVar=0.230122
X7072   71   245  memristor PARAMS: InitStateVar=0.354637
X7172   72   245  memristor PARAMS: InitStateVar=0.360859
X7272   73   245  memristor PARAMS: InitStateVar=0.393011
X7372   74   245  memristor PARAMS: InitStateVar=0.380712
X7472   75   245  memristor PARAMS: InitStateVar=0.111765
X7572   76   245  memristor PARAMS: InitStateVar=0.296536
X7672   77   245  memristor PARAMS: InitStateVar=0.220279
X7772   78   245  memristor PARAMS: InitStateVar=0.250416
X7872   79   245  memristor PARAMS: InitStateVar=0.309684
X7972   80   245  memristor PARAMS: InitStateVar=0.463733
X8072   81   245  memristor PARAMS: InitStateVar=0.317625
X8172   82   245  memristor PARAMS: InitStateVar=0.365272
X8272   83   245  memristor PARAMS: InitStateVar=0.198921
X8372   84   245  memristor PARAMS: InitStateVar=0.381287
X8472   85   245  memristor PARAMS: InitStateVar=0.307505
X8572   86   245  memristor PARAMS: InitStateVar=0.206128
X8672   87   245  memristor PARAMS: InitStateVar=0.334632
X8772   88   245  memristor PARAMS: InitStateVar=0.608544
X8872   89   245  memristor PARAMS: InitStateVar=0.195424
X8972   90   245  memristor PARAMS: InitStateVar=0.350191
X9072   91   245  memristor PARAMS: InitStateVar=0.342585
X9172   92   245  memristor PARAMS: InitStateVar=0.322784
X9272   93   245  memristor PARAMS: InitStateVar=0.203316
X9372   94   245  memristor PARAMS: InitStateVar=0.332947
X9472   95   245  memristor PARAMS: InitStateVar=0.254168
X9572   96   245  memristor PARAMS: InitStateVar=0.338474
X9672   97   245  memristor PARAMS: InitStateVar=0.190757
X9772   98   245  memristor PARAMS: InitStateVar=0.139742
X9872   99   245  memristor PARAMS: InitStateVar=0.372943
X9972   100  245  memristor PARAMS: InitStateVar=0.205402
Xo73    245  246  OutputModule PARAMS: Rval=100
*------------------- Column 74 -------------------------------------------------
X73     1    247  memristor PARAMS: InitStateVar=0.29771
X173    2    247  memristor PARAMS: InitStateVar=0.315179
X273    3    247  memristor PARAMS: InitStateVar=0.373849
X373    4    247  memristor PARAMS: InitStateVar=0.275616
X473    5    247  memristor PARAMS: InitStateVar=0.288741
X573    6    247  memristor PARAMS: InitStateVar=0.284183
X673    7    247  memristor PARAMS: InitStateVar=0.210603
X773    8    247  memristor PARAMS: InitStateVar=0.303811
X873    9    247  memristor PARAMS: InitStateVar=0.235237
X973    10   247  memristor PARAMS: InitStateVar=0.242446
X1073   11   247  memristor PARAMS: InitStateVar=0.18999
X1173   12   247  memristor PARAMS: InitStateVar=0.322529
X1273   13   247  memristor PARAMS: InitStateVar=0.352761
X1373   14   247  memristor PARAMS: InitStateVar=0.317181
X1473   15   247  memristor PARAMS: InitStateVar=0.421089
X1573   16   247  memristor PARAMS: InitStateVar=0.459035
X1673   17   247  memristor PARAMS: InitStateVar=0.373745
X1773   18   247  memristor PARAMS: InitStateVar=0.285482
X1873   19   247  memristor PARAMS: InitStateVar=0.266699
X1973   20   247  memristor PARAMS: InitStateVar=0.246295
X2073   21   247  memristor PARAMS: InitStateVar=0.230824
X2173   22   247  memristor PARAMS: InitStateVar=0.197899
X2273   23   247  memristor PARAMS: InitStateVar=0.174044
X2373   24   247  memristor PARAMS: InitStateVar=0.176191
X2473   25   247  memristor PARAMS: InitStateVar=0.419604
X2573   26   247  memristor PARAMS: InitStateVar=0.394138
X2673   27   247  memristor PARAMS: InitStateVar=0.102111
X2773   28   247  memristor PARAMS: InitStateVar=0.481118
X2873   29   247  memristor PARAMS: InitStateVar=0.283287
X2973   30   247  memristor PARAMS: InitStateVar=0.310948
X3073   31   247  memristor PARAMS: InitStateVar=0.223018
X3173   32   247  memristor PARAMS: InitStateVar=0.123767
X3273   33   247  memristor PARAMS: InitStateVar=0.298419
X3373   34   247  memristor PARAMS: InitStateVar=0.164047
X3473   35   247  memristor PARAMS: InitStateVar=0.337205
X3573   36   247  memristor PARAMS: InitStateVar=0.279872
X3673   37   247  memristor PARAMS: InitStateVar=0.161687
X3773   38   247  memristor PARAMS: InitStateVar=0.346715
X3873   39   247  memristor PARAMS: InitStateVar=0.387168
X3973   40   247  memristor PARAMS: InitStateVar=0.237303
X4073   41   247  memristor PARAMS: InitStateVar=0.344666
X4173   42   247  memristor PARAMS: InitStateVar=0.349486
X4273   43   247  memristor PARAMS: InitStateVar=0.122061
X4373   44   247  memristor PARAMS: InitStateVar=0.442752
X4473   45   247  memristor PARAMS: InitStateVar=0.364767
X4573   46   247  memristor PARAMS: InitStateVar=0.388728
X4673   47   247  memristor PARAMS: InitStateVar=0.364162
X4773   48   247  memristor PARAMS: InitStateVar=0.313731
X4873   49   247  memristor PARAMS: InitStateVar=0.179919
X4973   50   247  memristor PARAMS: InitStateVar=0.4262
X5073   51   247  memristor PARAMS: InitStateVar=0.279317
X5173   52   247  memristor PARAMS: InitStateVar=0.219816
X5273   53   247  memristor PARAMS: InitStateVar=0.222766
X5373   54   247  memristor PARAMS: InitStateVar=0.364913
X5473   55   247  memristor PARAMS: InitStateVar=0.345389
X5573   56   247  memristor PARAMS: InitStateVar=0.31863
X5673   57   247  memristor PARAMS: InitStateVar=0.160414
X5773   58   247  memristor PARAMS: InitStateVar=0.338484
X5873   59   247  memristor PARAMS: InitStateVar=0.306705
X5973   60   247  memristor PARAMS: InitStateVar=0.278773
X6073   61   247  memristor PARAMS: InitStateVar=0.279528
X6173   62   247  memristor PARAMS: InitStateVar=0.220931
X6273   63   247  memristor PARAMS: InitStateVar=0.331933
X6373   64   247  memristor PARAMS: InitStateVar=0.0620882
X6473   65   247  memristor PARAMS: InitStateVar=0.330646
X6573   66   247  memristor PARAMS: InitStateVar=0.40986
X6673   67   247  memristor PARAMS: InitStateVar=0.203074
X6773   68   247  memristor PARAMS: InitStateVar=0.212844
X6873   69   247  memristor PARAMS: InitStateVar=0.342027
X6973   70   247  memristor PARAMS: InitStateVar=0.296672
X7073   71   247  memristor PARAMS: InitStateVar=0.266933
X7173   72   247  memristor PARAMS: InitStateVar=0.4217
X7273   73   247  memristor PARAMS: InitStateVar=0.202891
X7373   74   247  memristor PARAMS: InitStateVar=0.324164
X7473   75   247  memristor PARAMS: InitStateVar=0.322662
X7573   76   247  memristor PARAMS: InitStateVar=0.308883
X7673   77   247  memristor PARAMS: InitStateVar=0.399116
X7773   78   247  memristor PARAMS: InitStateVar=0.259051
X7873   79   247  memristor PARAMS: InitStateVar=0.327419
X7973   80   247  memristor PARAMS: InitStateVar=0.181253
X8073   81   247  memristor PARAMS: InitStateVar=0.415091
X8173   82   247  memristor PARAMS: InitStateVar=0.332617
X8273   83   247  memristor PARAMS: InitStateVar=0.330034
X8373   84   247  memristor PARAMS: InitStateVar=0.144603
X8473   85   247  memristor PARAMS: InitStateVar=0.420833
X8573   86   247  memristor PARAMS: InitStateVar=0.332452
X8673   87   247  memristor PARAMS: InitStateVar=0.282588
X8773   88   247  memristor PARAMS: InitStateVar=0.206568
X8873   89   247  memristor PARAMS: InitStateVar=0.243384
X8973   90   247  memristor PARAMS: InitStateVar=0.331072
X9073   91   247  memristor PARAMS: InitStateVar=0.308988
X9173   92   247  memristor PARAMS: InitStateVar=0.399315
X9273   93   247  memristor PARAMS: InitStateVar=0.116015
X9373   94   247  memristor PARAMS: InitStateVar=0.313767
X9473   95   247  memristor PARAMS: InitStateVar=0.273226
X9573   96   247  memristor PARAMS: InitStateVar=0.28488
X9673   97   247  memristor PARAMS: InitStateVar=0.414939
X9773   98   247  memristor PARAMS: InitStateVar=0.175847
X9873   99   247  memristor PARAMS: InitStateVar=0.440133
X9973   100  247  memristor PARAMS: InitStateVar=0.359792
Xo74    247  248  OutputModule PARAMS: Rval=100
*------------------- Column 75 -------------------------------------------------
X74     1    249  memristor PARAMS: InitStateVar=0.307631
X174    2    249  memristor PARAMS: InitStateVar=0.278106
X274    3    249  memristor PARAMS: InitStateVar=0.14382
X374    4    249  memristor PARAMS: InitStateVar=0.276797
X474    5    249  memristor PARAMS: InitStateVar=0.345191
X574    6    249  memristor PARAMS: InitStateVar=0.401814
X674    7    249  memristor PARAMS: InitStateVar=0.480011
X774    8    249  memristor PARAMS: InitStateVar=0.274932
X874    9    249  memristor PARAMS: InitStateVar=0.461272
X974    10   249  memristor PARAMS: InitStateVar=0.201463
X1074   11   249  memristor PARAMS: InitStateVar=0.340649
X1174   12   249  memristor PARAMS: InitStateVar=0.264075
X1274   13   249  memristor PARAMS: InitStateVar=0.364324
X1374   14   249  memristor PARAMS: InitStateVar=0.266032
X1474   15   249  memristor PARAMS: InitStateVar=0.387965
X1574   16   249  memristor PARAMS: InitStateVar=0.297414
X1674   17   249  memristor PARAMS: InitStateVar=-0.0525622
X1774   18   249  memristor PARAMS: InitStateVar=0.337112
X1874   19   249  memristor PARAMS: InitStateVar=0.466266
X1974   20   249  memristor PARAMS: InitStateVar=0.396169
X2074   21   249  memristor PARAMS: InitStateVar=0.311019
X2174   22   249  memristor PARAMS: InitStateVar=0.250641
X2274   23   249  memristor PARAMS: InitStateVar=0.269141
X2374   24   249  memristor PARAMS: InitStateVar=0.353085
X2474   25   249  memristor PARAMS: InitStateVar=0.430649
X2574   26   249  memristor PARAMS: InitStateVar=0.289957
X2674   27   249  memristor PARAMS: InitStateVar=0.18801
X2774   28   249  memristor PARAMS: InitStateVar=0.307331
X2874   29   249  memristor PARAMS: InitStateVar=0.493718
X2974   30   249  memristor PARAMS: InitStateVar=0.133604
X3074   31   249  memristor PARAMS: InitStateVar=0.0962816
X3174   32   249  memristor PARAMS: InitStateVar=0.191254
X3274   33   249  memristor PARAMS: InitStateVar=0.173416
X3374   34   249  memristor PARAMS: InitStateVar=0.421485
X3474   35   249  memristor PARAMS: InitStateVar=0.313318
X3574   36   249  memristor PARAMS: InitStateVar=0.380093
X3674   37   249  memristor PARAMS: InitStateVar=0.321096
X3774   38   249  memristor PARAMS: InitStateVar=0.29707
X3874   39   249  memristor PARAMS: InitStateVar=0.480647
X3974   40   249  memristor PARAMS: InitStateVar=0.506952
X4074   41   249  memristor PARAMS: InitStateVar=0.158947
X4174   42   249  memristor PARAMS: InitStateVar=0.226515
X4274   43   249  memristor PARAMS: InitStateVar=0.257228
X4374   44   249  memristor PARAMS: InitStateVar=0.406186
X4474   45   249  memristor PARAMS: InitStateVar=0.0336444
X4574   46   249  memristor PARAMS: InitStateVar=0.254944
X4674   47   249  memristor PARAMS: InitStateVar=0.196621
X4774   48   249  memristor PARAMS: InitStateVar=0.151207
X4874   49   249  memristor PARAMS: InitStateVar=0.337245
X4974   50   249  memristor PARAMS: InitStateVar=0.292914
X5074   51   249  memristor PARAMS: InitStateVar=0.299697
X5174   52   249  memristor PARAMS: InitStateVar=0.0825848
X5274   53   249  memristor PARAMS: InitStateVar=0.227952
X5374   54   249  memristor PARAMS: InitStateVar=0.302673
X5474   55   249  memristor PARAMS: InitStateVar=0.499954
X5574   56   249  memristor PARAMS: InitStateVar=0.327699
X5674   57   249  memristor PARAMS: InitStateVar=0.201192
X5774   58   249  memristor PARAMS: InitStateVar=0.197424
X5874   59   249  memristor PARAMS: InitStateVar=0.150219
X5974   60   249  memristor PARAMS: InitStateVar=0.505225
X6074   61   249  memristor PARAMS: InitStateVar=0.257934
X6174   62   249  memristor PARAMS: InitStateVar=0.438703
X6274   63   249  memristor PARAMS: InitStateVar=0.351501
X6374   64   249  memristor PARAMS: InitStateVar=0.097942
X6474   65   249  memristor PARAMS: InitStateVar=0.196939
X6574   66   249  memristor PARAMS: InitStateVar=0.211065
X6674   67   249  memristor PARAMS: InitStateVar=0.185853
X6774   68   249  memristor PARAMS: InitStateVar=0.298064
X6874   69   249  memristor PARAMS: InitStateVar=0.323747
X6974   70   249  memristor PARAMS: InitStateVar=0.259197
X7074   71   249  memristor PARAMS: InitStateVar=0.321091
X7174   72   249  memristor PARAMS: InitStateVar=0.393516
X7274   73   249  memristor PARAMS: InitStateVar=0.574427
X7374   74   249  memristor PARAMS: InitStateVar=0.393604
X7474   75   249  memristor PARAMS: InitStateVar=0.210799
X7574   76   249  memristor PARAMS: InitStateVar=0.30074
X7674   77   249  memristor PARAMS: InitStateVar=0.262924
X7774   78   249  memristor PARAMS: InitStateVar=0.219252
X7874   79   249  memristor PARAMS: InitStateVar=0.220034
X7974   80   249  memristor PARAMS: InitStateVar=0.279195
X8074   81   249  memristor PARAMS: InitStateVar=0.328123
X8174   82   249  memristor PARAMS: InitStateVar=0.404473
X8274   83   249  memristor PARAMS: InitStateVar=0.109635
X8374   84   249  memristor PARAMS: InitStateVar=0.393613
X8474   85   249  memristor PARAMS: InitStateVar=0.217641
X8574   86   249  memristor PARAMS: InitStateVar=0.106202
X8674   87   249  memristor PARAMS: InitStateVar=0.206173
X8774   88   249  memristor PARAMS: InitStateVar=0.372833
X8874   89   249  memristor PARAMS: InitStateVar=0.210175
X8974   90   249  memristor PARAMS: InitStateVar=0.460485
X9074   91   249  memristor PARAMS: InitStateVar=0.0640939
X9174   92   249  memristor PARAMS: InitStateVar=0.385234
X9274   93   249  memristor PARAMS: InitStateVar=0.144587
X9374   94   249  memristor PARAMS: InitStateVar=0.382148
X9474   95   249  memristor PARAMS: InitStateVar=0.349281
X9574   96   249  memristor PARAMS: InitStateVar=0.183442
X9674   97   249  memristor PARAMS: InitStateVar=0.455705
X9774   98   249  memristor PARAMS: InitStateVar=0.438612
X9874   99   249  memristor PARAMS: InitStateVar=0.161565
X9974   100  249  memristor PARAMS: InitStateVar=0.178585
Xo75    249  250  OutputModule PARAMS: Rval=100
*------------------- Column 76 -------------------------------------------------
X75     1    251  memristor PARAMS: InitStateVar=0.389038
X175    2    251  memristor PARAMS: InitStateVar=0.510178
X275    3    251  memristor PARAMS: InitStateVar=0.368928
X375    4    251  memristor PARAMS: InitStateVar=0.39863
X475    5    251  memristor PARAMS: InitStateVar=0.275275
X575    6    251  memristor PARAMS: InitStateVar=0.21631
X675    7    251  memristor PARAMS: InitStateVar=0.293242
X775    8    251  memristor PARAMS: InitStateVar=0.239821
X875    9    251  memristor PARAMS: InitStateVar=0.403204
X975    10   251  memristor PARAMS: InitStateVar=0.290177
X1075   11   251  memristor PARAMS: InitStateVar=0.278389
X1175   12   251  memristor PARAMS: InitStateVar=0.339819
X1275   13   251  memristor PARAMS: InitStateVar=0.195946
X1375   14   251  memristor PARAMS: InitStateVar=0.253647
X1475   15   251  memristor PARAMS: InitStateVar=0.260081
X1575   16   251  memristor PARAMS: InitStateVar=0.29422
X1675   17   251  memristor PARAMS: InitStateVar=0.492197
X1775   18   251  memristor PARAMS: InitStateVar=0.160917
X1875   19   251  memristor PARAMS: InitStateVar=0.23094
X1975   20   251  memristor PARAMS: InitStateVar=0.249129
X2075   21   251  memristor PARAMS: InitStateVar=0.308632
X2175   22   251  memristor PARAMS: InitStateVar=0.156995
X2275   23   251  memristor PARAMS: InitStateVar=0.323475
X2375   24   251  memristor PARAMS: InitStateVar=0.166628
X2475   25   251  memristor PARAMS: InitStateVar=0.356176
X2575   26   251  memristor PARAMS: InitStateVar=0.305616
X2675   27   251  memristor PARAMS: InitStateVar=0.177114
X2775   28   251  memristor PARAMS: InitStateVar=0.19221
X2875   29   251  memristor PARAMS: InitStateVar=0.178067
X2975   30   251  memristor PARAMS: InitStateVar=0.310757
X3075   31   251  memristor PARAMS: InitStateVar=0.281908
X3175   32   251  memristor PARAMS: InitStateVar=0.290621
X3275   33   251  memristor PARAMS: InitStateVar=0.232716
X3375   34   251  memristor PARAMS: InitStateVar=0.318866
X3475   35   251  memristor PARAMS: InitStateVar=0.360151
X3575   36   251  memristor PARAMS: InitStateVar=0.455821
X3675   37   251  memristor PARAMS: InitStateVar=0.175261
X3775   38   251  memristor PARAMS: InitStateVar=0.355234
X3875   39   251  memristor PARAMS: InitStateVar=0.143582
X3975   40   251  memristor PARAMS: InitStateVar=0.258835
X4075   41   251  memristor PARAMS: InitStateVar=0.257996
X4175   42   251  memristor PARAMS: InitStateVar=0.310749
X4275   43   251  memristor PARAMS: InitStateVar=0.23275
X4375   44   251  memristor PARAMS: InitStateVar=0.278587
X4475   45   251  memristor PARAMS: InitStateVar=0.372788
X4575   46   251  memristor PARAMS: InitStateVar=0.237095
X4675   47   251  memristor PARAMS: InitStateVar=0.334939
X4775   48   251  memristor PARAMS: InitStateVar=0.194167
X4875   49   251  memristor PARAMS: InitStateVar=0.0966463
X4975   50   251  memristor PARAMS: InitStateVar=0.226321
X5075   51   251  memristor PARAMS: InitStateVar=0.364429
X5175   52   251  memristor PARAMS: InitStateVar=0.187667
X5275   53   251  memristor PARAMS: InitStateVar=0.396747
X5375   54   251  memristor PARAMS: InitStateVar=0.179415
X5475   55   251  memristor PARAMS: InitStateVar=0.241579
X5575   56   251  memristor PARAMS: InitStateVar=0.217152
X5675   57   251  memristor PARAMS: InitStateVar=0.216967
X5775   58   251  memristor PARAMS: InitStateVar=0.364435
X5875   59   251  memristor PARAMS: InitStateVar=0.270942
X5975   60   251  memristor PARAMS: InitStateVar=0.286206
X6075   61   251  memristor PARAMS: InitStateVar=0.280746
X6175   62   251  memristor PARAMS: InitStateVar=0.263613
X6275   63   251  memristor PARAMS: InitStateVar=0.162958
X6375   64   251  memristor PARAMS: InitStateVar=0.227124
X6475   65   251  memristor PARAMS: InitStateVar=0.355177
X6575   66   251  memristor PARAMS: InitStateVar=0.186153
X6675   67   251  memristor PARAMS: InitStateVar=0.380153
X6775   68   251  memristor PARAMS: InitStateVar=0.272044
X6875   69   251  memristor PARAMS: InitStateVar=0.304943
X6975   70   251  memristor PARAMS: InitStateVar=0.195016
X7075   71   251  memristor PARAMS: InitStateVar=0.373768
X7175   72   251  memristor PARAMS: InitStateVar=0.39626
X7275   73   251  memristor PARAMS: InitStateVar=0.216116
X7375   74   251  memristor PARAMS: InitStateVar=0.307229
X7475   75   251  memristor PARAMS: InitStateVar=0.322111
X7575   76   251  memristor PARAMS: InitStateVar=0.343462
X7675   77   251  memristor PARAMS: InitStateVar=0.333317
X7775   78   251  memristor PARAMS: InitStateVar=0.497652
X7875   79   251  memristor PARAMS: InitStateVar=0.10397
X7975   80   251  memristor PARAMS: InitStateVar=0.518082
X8075   81   251  memristor PARAMS: InitStateVar=0.173905
X8175   82   251  memristor PARAMS: InitStateVar=0.284895
X8275   83   251  memristor PARAMS: InitStateVar=0.161221
X8375   84   251  memristor PARAMS: InitStateVar=0.243526
X8475   85   251  memristor PARAMS: InitStateVar=0.475336
X8575   86   251  memristor PARAMS: InitStateVar=0.409353
X8675   87   251  memristor PARAMS: InitStateVar=0.0893607
X8775   88   251  memristor PARAMS: InitStateVar=0.411374
X8875   89   251  memristor PARAMS: InitStateVar=0.206593
X8975   90   251  memristor PARAMS: InitStateVar=0.235633
X9075   91   251  memristor PARAMS: InitStateVar=0.538786
X9175   92   251  memristor PARAMS: InitStateVar=0.28603
X9275   93   251  memristor PARAMS: InitStateVar=0.299385
X9375   94   251  memristor PARAMS: InitStateVar=0.448127
X9475   95   251  memristor PARAMS: InitStateVar=0.377416
X9575   96   251  memristor PARAMS: InitStateVar=0.285127
X9675   97   251  memristor PARAMS: InitStateVar=0.0906963
X9775   98   251  memristor PARAMS: InitStateVar=0.211231
X9875   99   251  memristor PARAMS: InitStateVar=0.256231
X9975   100  251  memristor PARAMS: InitStateVar=0.224038
Xo76    251  252  OutputModule PARAMS: Rval=100
*------------------- Column 77 -------------------------------------------------
X76     1    253  memristor PARAMS: InitStateVar=0.421331
X176    2    253  memristor PARAMS: InitStateVar=0.458752
X276    3    253  memristor PARAMS: InitStateVar=0.308051
X376    4    253  memristor PARAMS: InitStateVar=0.251497
X476    5    253  memristor PARAMS: InitStateVar=0.240377
X576    6    253  memristor PARAMS: InitStateVar=0.30436
X676    7    253  memristor PARAMS: InitStateVar=0.432608
X776    8    253  memristor PARAMS: InitStateVar=0.36953
X876    9    253  memristor PARAMS: InitStateVar=0.242433
X976    10   253  memristor PARAMS: InitStateVar=0.365786
X1076   11   253  memristor PARAMS: InitStateVar=0.492679
X1176   12   253  memristor PARAMS: InitStateVar=0.276956
X1276   13   253  memristor PARAMS: InitStateVar=0.352379
X1376   14   253  memristor PARAMS: InitStateVar=0.362163
X1476   15   253  memristor PARAMS: InitStateVar=0.314026
X1576   16   253  memristor PARAMS: InitStateVar=0.378699
X1676   17   253  memristor PARAMS: InitStateVar=0.181272
X1776   18   253  memristor PARAMS: InitStateVar=0.322435
X1876   19   253  memristor PARAMS: InitStateVar=0.278079
X1976   20   253  memristor PARAMS: InitStateVar=0.368781
X2076   21   253  memristor PARAMS: InitStateVar=0.352945
X2176   22   253  memristor PARAMS: InitStateVar=0.253687
X2276   23   253  memristor PARAMS: InitStateVar=0.140806
X2376   24   253  memristor PARAMS: InitStateVar=0.319494
X2476   25   253  memristor PARAMS: InitStateVar=0.355986
X2576   26   253  memristor PARAMS: InitStateVar=0.186901
X2676   27   253  memristor PARAMS: InitStateVar=0.0693435
X2776   28   253  memristor PARAMS: InitStateVar=0.461929
X2876   29   253  memristor PARAMS: InitStateVar=0.180521
X2976   30   253  memristor PARAMS: InitStateVar=0.40623
X3076   31   253  memristor PARAMS: InitStateVar=0.221786
X3176   32   253  memristor PARAMS: InitStateVar=0.468621
X3276   33   253  memristor PARAMS: InitStateVar=0.135417
X3376   34   253  memristor PARAMS: InitStateVar=0.150805
X3476   35   253  memristor PARAMS: InitStateVar=0.481722
X3576   36   253  memristor PARAMS: InitStateVar=0.149453
X3676   37   253  memristor PARAMS: InitStateVar=0.269974
X3776   38   253  memristor PARAMS: InitStateVar=0.229978
X3876   39   253  memristor PARAMS: InitStateVar=0.343084
X3976   40   253  memristor PARAMS: InitStateVar=0.386224
X4076   41   253  memristor PARAMS: InitStateVar=0.304593
X4176   42   253  memristor PARAMS: InitStateVar=0.264189
X4276   43   253  memristor PARAMS: InitStateVar=0.302267
X4376   44   253  memristor PARAMS: InitStateVar=0.455383
X4476   45   253  memristor PARAMS: InitStateVar=0.220416
X4576   46   253  memristor PARAMS: InitStateVar=0.285712
X4676   47   253  memristor PARAMS: InitStateVar=0.18209
X4776   48   253  memristor PARAMS: InitStateVar=0.182945
X4876   49   253  memristor PARAMS: InitStateVar=0.257047
X4976   50   253  memristor PARAMS: InitStateVar=0.296896
X5076   51   253  memristor PARAMS: InitStateVar=0.231032
X5176   52   253  memristor PARAMS: InitStateVar=0.170074
X5276   53   253  memristor PARAMS: InitStateVar=0.393853
X5376   54   253  memristor PARAMS: InitStateVar=0.223722
X5476   55   253  memristor PARAMS: InitStateVar=0.453999
X5576   56   253  memristor PARAMS: InitStateVar=0.201535
X5676   57   253  memristor PARAMS: InitStateVar=0.197943
X5776   58   253  memristor PARAMS: InitStateVar=0.258636
X5876   59   253  memristor PARAMS: InitStateVar=0.36392
X5976   60   253  memristor PARAMS: InitStateVar=0.222369
X6076   61   253  memristor PARAMS: InitStateVar=0.0138246
X6176   62   253  memristor PARAMS: InitStateVar=0.319408
X6276   63   253  memristor PARAMS: InitStateVar=0.405801
X6376   64   253  memristor PARAMS: InitStateVar=0.256209
X6476   65   253  memristor PARAMS: InitStateVar=0.22106
X6576   66   253  memristor PARAMS: InitStateVar=0.18703
X6676   67   253  memristor PARAMS: InitStateVar=0.316442
X6776   68   253  memristor PARAMS: InitStateVar=0.522529
X6876   69   253  memristor PARAMS: InitStateVar=0.348301
X6976   70   253  memristor PARAMS: InitStateVar=0.0686077
X7076   71   253  memristor PARAMS: InitStateVar=0.312142
X7176   72   253  memristor PARAMS: InitStateVar=0.153183
X7276   73   253  memristor PARAMS: InitStateVar=0.329121
X7376   74   253  memristor PARAMS: InitStateVar=0.13693
X7476   75   253  memristor PARAMS: InitStateVar=0.229092
X7576   76   253  memristor PARAMS: InitStateVar=0.318806
X7676   77   253  memristor PARAMS: InitStateVar=0.179748
X7776   78   253  memristor PARAMS: InitStateVar=0.278791
X7876   79   253  memristor PARAMS: InitStateVar=0.352876
X7976   80   253  memristor PARAMS: InitStateVar=0.331274
X8076   81   253  memristor PARAMS: InitStateVar=0.432469
X8176   82   253  memristor PARAMS: InitStateVar=0.338452
X8276   83   253  memristor PARAMS: InitStateVar=0.0882337
X8376   84   253  memristor PARAMS: InitStateVar=0.218212
X8476   85   253  memristor PARAMS: InitStateVar=0.299553
X8576   86   253  memristor PARAMS: InitStateVar=0.283289
X8676   87   253  memristor PARAMS: InitStateVar=0.276396
X8776   88   253  memristor PARAMS: InitStateVar=0.473365
X8876   89   253  memristor PARAMS: InitStateVar=0.235647
X8976   90   253  memristor PARAMS: InitStateVar=0.162033
X9076   91   253  memristor PARAMS: InitStateVar=0.334179
X9176   92   253  memristor PARAMS: InitStateVar=0.146233
X9276   93   253  memristor PARAMS: InitStateVar=0.321994
X9376   94   253  memristor PARAMS: InitStateVar=0.193974
X9476   95   253  memristor PARAMS: InitStateVar=0.130811
X9576   96   253  memristor PARAMS: InitStateVar=0.516688
X9676   97   253  memristor PARAMS: InitStateVar=0.339468
X9776   98   253  memristor PARAMS: InitStateVar=0.222026
X9876   99   253  memristor PARAMS: InitStateVar=0.257892
X9976   100  253  memristor PARAMS: InitStateVar=0.396776
Xo77    253  254  OutputModule PARAMS: Rval=100
*------------------- Column 78 -------------------------------------------------
X77     1    255  memristor PARAMS: InitStateVar=0.398488
X177    2    255  memristor PARAMS: InitStateVar=0.292656
X277    3    255  memristor PARAMS: InitStateVar=0.311579
X377    4    255  memristor PARAMS: InitStateVar=0.326482
X477    5    255  memristor PARAMS: InitStateVar=0.227162
X577    6    255  memristor PARAMS: InitStateVar=0.36198
X677    7    255  memristor PARAMS: InitStateVar=0.429556
X777    8    255  memristor PARAMS: InitStateVar=0.374156
X877    9    255  memristor PARAMS: InitStateVar=0.367763
X977    10   255  memristor PARAMS: InitStateVar=0.356397
X1077   11   255  memristor PARAMS: InitStateVar=0.164005
X1177   12   255  memristor PARAMS: InitStateVar=0.474673
X1277   13   255  memristor PARAMS: InitStateVar=0.307292
X1377   14   255  memristor PARAMS: InitStateVar=0.329739
X1477   15   255  memristor PARAMS: InitStateVar=0.367254
X1577   16   255  memristor PARAMS: InitStateVar=0.18258
X1677   17   255  memristor PARAMS: InitStateVar=0.376687
X1777   18   255  memristor PARAMS: InitStateVar=0.419508
X1877   19   255  memristor PARAMS: InitStateVar=0.368137
X1977   20   255  memristor PARAMS: InitStateVar=0.44492
X2077   21   255  memristor PARAMS: InitStateVar=0.293832
X2177   22   255  memristor PARAMS: InitStateVar=0.351135
X2277   23   255  memristor PARAMS: InitStateVar=0.369518
X2377   24   255  memristor PARAMS: InitStateVar=0.253588
X2477   25   255  memristor PARAMS: InitStateVar=0.300235
X2577   26   255  memristor PARAMS: InitStateVar=0.37503
X2677   27   255  memristor PARAMS: InitStateVar=0.157579
X2777   28   255  memristor PARAMS: InitStateVar=0.279886
X2877   29   255  memristor PARAMS: InitStateVar=0.367378
X2977   30   255  memristor PARAMS: InitStateVar=0.375258
X3077   31   255  memristor PARAMS: InitStateVar=0.202962
X3177   32   255  memristor PARAMS: InitStateVar=0.268611
X3277   33   255  memristor PARAMS: InitStateVar=0.281854
X3377   34   255  memristor PARAMS: InitStateVar=0.213867
X3477   35   255  memristor PARAMS: InitStateVar=0.471739
X3577   36   255  memristor PARAMS: InitStateVar=0.22464
X3677   37   255  memristor PARAMS: InitStateVar=0.142066
X3777   38   255  memristor PARAMS: InitStateVar=0.119206
X3877   39   255  memristor PARAMS: InitStateVar=0.312204
X3977   40   255  memristor PARAMS: InitStateVar=0.264648
X4077   41   255  memristor PARAMS: InitStateVar=0.31856
X4177   42   255  memristor PARAMS: InitStateVar=0.189561
X4277   43   255  memristor PARAMS: InitStateVar=0.376132
X4377   44   255  memristor PARAMS: InitStateVar=0.597643
X4477   45   255  memristor PARAMS: InitStateVar=0.372372
X4577   46   255  memristor PARAMS: InitStateVar=0.18535
X4677   47   255  memristor PARAMS: InitStateVar=0.428296
X4777   48   255  memristor PARAMS: InitStateVar=0.273855
X4877   49   255  memristor PARAMS: InitStateVar=0.226453
X4977   50   255  memristor PARAMS: InitStateVar=0.409288
X5077   51   255  memristor PARAMS: InitStateVar=0.286409
X5177   52   255  memristor PARAMS: InitStateVar=0.206579
X5277   53   255  memristor PARAMS: InitStateVar=0.386911
X5377   54   255  memristor PARAMS: InitStateVar=0.35453
X5477   55   255  memristor PARAMS: InitStateVar=0.29298
X5577   56   255  memristor PARAMS: InitStateVar=0.172893
X5677   57   255  memristor PARAMS: InitStateVar=0.210165
X5777   58   255  memristor PARAMS: InitStateVar=0.266744
X5877   59   255  memristor PARAMS: InitStateVar=0.320304
X5977   60   255  memristor PARAMS: InitStateVar=0.330534
X6077   61   255  memristor PARAMS: InitStateVar=0.0997784
X6177   62   255  memristor PARAMS: InitStateVar=0.302025
X6277   63   255  memristor PARAMS: InitStateVar=0.348454
X6377   64   255  memristor PARAMS: InitStateVar=0.239144
X6477   65   255  memristor PARAMS: InitStateVar=0.344831
X6577   66   255  memristor PARAMS: InitStateVar=0.150453
X6677   67   255  memristor PARAMS: InitStateVar=0.210932
X6777   68   255  memristor PARAMS: InitStateVar=0.47255
X6877   69   255  memristor PARAMS: InitStateVar=0.131156
X6977   70   255  memristor PARAMS: InitStateVar=0.319952
X7077   71   255  memristor PARAMS: InitStateVar=0.218381
X7177   72   255  memristor PARAMS: InitStateVar=0.188486
X7277   73   255  memristor PARAMS: InitStateVar=0.370117
X7377   74   255  memristor PARAMS: InitStateVar=0.00608069
X7477   75   255  memristor PARAMS: InitStateVar=0.251928
X7577   76   255  memristor PARAMS: InitStateVar=0.204364
X7677   77   255  memristor PARAMS: InitStateVar=0.29793
X7777   78   255  memristor PARAMS: InitStateVar=0.398738
X7877   79   255  memristor PARAMS: InitStateVar=0.299018
X7977   80   255  memristor PARAMS: InitStateVar=0.158253
X8077   81   255  memristor PARAMS: InitStateVar=0.261341
X8177   82   255  memristor PARAMS: InitStateVar=0.241441
X8277   83   255  memristor PARAMS: InitStateVar=0.276776
X8377   84   255  memristor PARAMS: InitStateVar=0.364599
X8477   85   255  memristor PARAMS: InitStateVar=0.26049
X8577   86   255  memristor PARAMS: InitStateVar=0.231788
X8677   87   255  memristor PARAMS: InitStateVar=0.289506
X8777   88   255  memristor PARAMS: InitStateVar=0.356872
X8877   89   255  memristor PARAMS: InitStateVar=0.292715
X8977   90   255  memristor PARAMS: InitStateVar=0.237746
X9077   91   255  memristor PARAMS: InitStateVar=-0.0481622
X9177   92   255  memristor PARAMS: InitStateVar=0.262592
X9277   93   255  memristor PARAMS: InitStateVar=0.430266
X9377   94   255  memristor PARAMS: InitStateVar=0.0843557
X9477   95   255  memristor PARAMS: InitStateVar=0.332012
X9577   96   255  memristor PARAMS: InitStateVar=0.252628
X9677   97   255  memristor PARAMS: InitStateVar=0.416453
X9777   98   255  memristor PARAMS: InitStateVar=0.155478
X9877   99   255  memristor PARAMS: InitStateVar=0.114831
X9977   100  255  memristor PARAMS: InitStateVar=0.26935
Xo78    255  256  OutputModule PARAMS: Rval=100
*------------------- Column 79 -------------------------------------------------
X78     1    257  memristor PARAMS: InitStateVar=0.297391
X178    2    257  memristor PARAMS: InitStateVar=0.283271
X278    3    257  memristor PARAMS: InitStateVar=0.249996
X378    4    257  memristor PARAMS: InitStateVar=0.17625
X478    5    257  memristor PARAMS: InitStateVar=0.345085
X578    6    257  memristor PARAMS: InitStateVar=0.438277
X678    7    257  memristor PARAMS: InitStateVar=0.31974
X778    8    257  memristor PARAMS: InitStateVar=0.462377
X878    9    257  memristor PARAMS: InitStateVar=0.357476
X978    10   257  memristor PARAMS: InitStateVar=0.154732
X1078   11   257  memristor PARAMS: InitStateVar=0.374556
X1178   12   257  memristor PARAMS: InitStateVar=0.28828
X1278   13   257  memristor PARAMS: InitStateVar=0.369588
X1378   14   257  memristor PARAMS: InitStateVar=0.471914
X1478   15   257  memristor PARAMS: InitStateVar=0.237559
X1578   16   257  memristor PARAMS: InitStateVar=0.401941
X1678   17   257  memristor PARAMS: InitStateVar=0.21235
X1778   18   257  memristor PARAMS: InitStateVar=0.292242
X1878   19   257  memristor PARAMS: InitStateVar=0.184745
X1978   20   257  memristor PARAMS: InitStateVar=0.402959
X2078   21   257  memristor PARAMS: InitStateVar=0.0416019
X2178   22   257  memristor PARAMS: InitStateVar=0.329504
X2278   23   257  memristor PARAMS: InitStateVar=0.268217
X2378   24   257  memristor PARAMS: InitStateVar=0.244381
X2478   25   257  memristor PARAMS: InitStateVar=0.226009
X2578   26   257  memristor PARAMS: InitStateVar=0.504832
X2678   27   257  memristor PARAMS: InitStateVar=0.371764
X2778   28   257  memristor PARAMS: InitStateVar=0.411064
X2878   29   257  memristor PARAMS: InitStateVar=0.191064
X2978   30   257  memristor PARAMS: InitStateVar=0.276044
X3078   31   257  memristor PARAMS: InitStateVar=0.398508
X3178   32   257  memristor PARAMS: InitStateVar=0.344695
X3278   33   257  memristor PARAMS: InitStateVar=0.228654
X3378   34   257  memristor PARAMS: InitStateVar=0.23389
X3478   35   257  memristor PARAMS: InitStateVar=0.228489
X3578   36   257  memristor PARAMS: InitStateVar=0.26092
X3678   37   257  memristor PARAMS: InitStateVar=0.420945
X3778   38   257  memristor PARAMS: InitStateVar=0.30836
X3878   39   257  memristor PARAMS: InitStateVar=0.498407
X3978   40   257  memristor PARAMS: InitStateVar=0.342468
X4078   41   257  memristor PARAMS: InitStateVar=0.248346
X4178   42   257  memristor PARAMS: InitStateVar=0.304886
X4278   43   257  memristor PARAMS: InitStateVar=0.411178
X4378   44   257  memristor PARAMS: InitStateVar=0.144128
X4478   45   257  memristor PARAMS: InitStateVar=0.198677
X4578   46   257  memristor PARAMS: InitStateVar=0.154816
X4678   47   257  memristor PARAMS: InitStateVar=0.277559
X4778   48   257  memristor PARAMS: InitStateVar=0.245816
X4878   49   257  memristor PARAMS: InitStateVar=0.285077
X4978   50   257  memristor PARAMS: InitStateVar=0.394397
X5078   51   257  memristor PARAMS: InitStateVar=0.4438
X5178   52   257  memristor PARAMS: InitStateVar=0.457782
X5278   53   257  memristor PARAMS: InitStateVar=0.3738
X5378   54   257  memristor PARAMS: InitStateVar=0.242225
X5478   55   257  memristor PARAMS: InitStateVar=0.30134
X5578   56   257  memristor PARAMS: InitStateVar=0.313155
X5678   57   257  memristor PARAMS: InitStateVar=0.271322
X5778   58   257  memristor PARAMS: InitStateVar=0.410959
X5878   59   257  memristor PARAMS: InitStateVar=0.428267
X5978   60   257  memristor PARAMS: InitStateVar=0.313674
X6078   61   257  memristor PARAMS: InitStateVar=0.347649
X6178   62   257  memristor PARAMS: InitStateVar=0.190176
X6278   63   257  memristor PARAMS: InitStateVar=0.364106
X6378   64   257  memristor PARAMS: InitStateVar=0.387771
X6478   65   257  memristor PARAMS: InitStateVar=0.238157
X6578   66   257  memristor PARAMS: InitStateVar=0.361657
X6678   67   257  memristor PARAMS: InitStateVar=0.235505
X6778   68   257  memristor PARAMS: InitStateVar=0.323389
X6878   69   257  memristor PARAMS: InitStateVar=0.206239
X6978   70   257  memristor PARAMS: InitStateVar=0.187986
X7078   71   257  memristor PARAMS: InitStateVar=0.314027
X7178   72   257  memristor PARAMS: InitStateVar=0.507145
X7278   73   257  memristor PARAMS: InitStateVar=0.175183
X7378   74   257  memristor PARAMS: InitStateVar=0.211328
X7478   75   257  memristor PARAMS: InitStateVar=0.324067
X7578   76   257  memristor PARAMS: InitStateVar=0.389621
X7678   77   257  memristor PARAMS: InitStateVar=0.223197
X7778   78   257  memristor PARAMS: InitStateVar=0.156583
X7878   79   257  memristor PARAMS: InitStateVar=0.26049
X7978   80   257  memristor PARAMS: InitStateVar=0.145323
X8078   81   257  memristor PARAMS: InitStateVar=0.251081
X8178   82   257  memristor PARAMS: InitStateVar=0.305652
X8278   83   257  memristor PARAMS: InitStateVar=0.20098
X8378   84   257  memristor PARAMS: InitStateVar=0.346741
X8478   85   257  memristor PARAMS: InitStateVar=0.378709
X8578   86   257  memristor PARAMS: InitStateVar=0.238866
X8678   87   257  memristor PARAMS: InitStateVar=0.259154
X8778   88   257  memristor PARAMS: InitStateVar=0.141711
X8878   89   257  memristor PARAMS: InitStateVar=0.148865
X8978   90   257  memristor PARAMS: InitStateVar=0.25565
X9078   91   257  memristor PARAMS: InitStateVar=0.282689
X9178   92   257  memristor PARAMS: InitStateVar=0.160514
X9278   93   257  memristor PARAMS: InitStateVar=0.343934
X9378   94   257  memristor PARAMS: InitStateVar=0.322378
X9478   95   257  memristor PARAMS: InitStateVar=0.367095
X9578   96   257  memristor PARAMS: InitStateVar=0.404007
X9678   97   257  memristor PARAMS: InitStateVar=0.475311
X9778   98   257  memristor PARAMS: InitStateVar=0.327309
X9878   99   257  memristor PARAMS: InitStateVar=0.320738
X9978   100  257  memristor PARAMS: InitStateVar=0.114385
Xo79    257  258  OutputModule PARAMS: Rval=100
*------------------- Column 80 -------------------------------------------------
X79     1    259  memristor PARAMS: InitStateVar=0.369906
X179    2    259  memristor PARAMS: InitStateVar=0.177557
X279    3    259  memristor PARAMS: InitStateVar=0.35169
X379    4    259  memristor PARAMS: InitStateVar=0.339259
X479    5    259  memristor PARAMS: InitStateVar=0.335385
X579    6    259  memristor PARAMS: InitStateVar=0.127666
X679    7    259  memristor PARAMS: InitStateVar=0.270138
X779    8    259  memristor PARAMS: InitStateVar=0.311826
X879    9    259  memristor PARAMS: InitStateVar=0.227601
X979    10   259  memristor PARAMS: InitStateVar=0.289206
X1079   11   259  memristor PARAMS: InitStateVar=0.205584
X1179   12   259  memristor PARAMS: InitStateVar=0.223557
X1279   13   259  memristor PARAMS: InitStateVar=0.370212
X1379   14   259  memristor PARAMS: InitStateVar=0.32605
X1479   15   259  memristor PARAMS: InitStateVar=0.151044
X1579   16   259  memristor PARAMS: InitStateVar=0.507396
X1679   17   259  memristor PARAMS: InitStateVar=0.307501
X1779   18   259  memristor PARAMS: InitStateVar=0.326232
X1879   19   259  memristor PARAMS: InitStateVar=0.0990598
X1979   20   259  memristor PARAMS: InitStateVar=0.206052
X2079   21   259  memristor PARAMS: InitStateVar=0.337463
X2179   22   259  memristor PARAMS: InitStateVar=0.267808
X2279   23   259  memristor PARAMS: InitStateVar=0.180476
X2379   24   259  memristor PARAMS: InitStateVar=0.380098
X2479   25   259  memristor PARAMS: InitStateVar=0.354012
X2579   26   259  memristor PARAMS: InitStateVar=0.347538
X2679   27   259  memristor PARAMS: InitStateVar=0.190187
X2779   28   259  memristor PARAMS: InitStateVar=0.263304
X2879   29   259  memristor PARAMS: InitStateVar=0.337781
X2979   30   259  memristor PARAMS: InitStateVar=0.164732
X3079   31   259  memristor PARAMS: InitStateVar=0.243723
X3179   32   259  memristor PARAMS: InitStateVar=0.257814
X3279   33   259  memristor PARAMS: InitStateVar=0.361103
X3379   34   259  memristor PARAMS: InitStateVar=0.395326
X3479   35   259  memristor PARAMS: InitStateVar=0.295578
X3579   36   259  memristor PARAMS: InitStateVar=0.332988
X3679   37   259  memristor PARAMS: InitStateVar=0.333557
X3779   38   259  memristor PARAMS: InitStateVar=0.335177
X3879   39   259  memristor PARAMS: InitStateVar=0.545484
X3979   40   259  memristor PARAMS: InitStateVar=0.190188
X4079   41   259  memristor PARAMS: InitStateVar=0.423228
X4179   42   259  memristor PARAMS: InitStateVar=0.205586
X4279   43   259  memristor PARAMS: InitStateVar=0.412256
X4379   44   259  memristor PARAMS: InitStateVar=0.38312
X4479   45   259  memristor PARAMS: InitStateVar=0.332435
X4579   46   259  memristor PARAMS: InitStateVar=0.376008
X4679   47   259  memristor PARAMS: InitStateVar=0.306444
X4779   48   259  memristor PARAMS: InitStateVar=0.384345
X4879   49   259  memristor PARAMS: InitStateVar=0.148309
X4979   50   259  memristor PARAMS: InitStateVar=0.237231
X5079   51   259  memristor PARAMS: InitStateVar=0.270348
X5179   52   259  memristor PARAMS: InitStateVar=0.309571
X5279   53   259  memristor PARAMS: InitStateVar=0.469189
X5379   54   259  memristor PARAMS: InitStateVar=0.285229
X5479   55   259  memristor PARAMS: InitStateVar=0.159643
X5579   56   259  memristor PARAMS: InitStateVar=0.0959458
X5679   57   259  memristor PARAMS: InitStateVar=0.250595
X5779   58   259  memristor PARAMS: InitStateVar=0.209897
X5879   59   259  memristor PARAMS: InitStateVar=0.394061
X5979   60   259  memristor PARAMS: InitStateVar=0.162481
X6079   61   259  memristor PARAMS: InitStateVar=0.147474
X6179   62   259  memristor PARAMS: InitStateVar=0.293521
X6279   63   259  memristor PARAMS: InitStateVar=0.424233
X6379   64   259  memristor PARAMS: InitStateVar=0.157589
X6479   65   259  memristor PARAMS: InitStateVar=0.216542
X6579   66   259  memristor PARAMS: InitStateVar=0.494998
X6679   67   259  memristor PARAMS: InitStateVar=0.368151
X6779   68   259  memristor PARAMS: InitStateVar=0.598137
X6879   69   259  memristor PARAMS: InitStateVar=0.288396
X6979   70   259  memristor PARAMS: InitStateVar=0.31206
X7079   71   259  memristor PARAMS: InitStateVar=0.127303
X7179   72   259  memristor PARAMS: InitStateVar=0.299334
X7279   73   259  memristor PARAMS: InitStateVar=0.328122
X7379   74   259  memristor PARAMS: InitStateVar=0.448973
X7479   75   259  memristor PARAMS: InitStateVar=0.321137
X7579   76   259  memristor PARAMS: InitStateVar=0.410079
X7679   77   259  memristor PARAMS: InitStateVar=0.326846
X7779   78   259  memristor PARAMS: InitStateVar=0.212376
X7879   79   259  memristor PARAMS: InitStateVar=0.265287
X7979   80   259  memristor PARAMS: InitStateVar=0.294865
X8079   81   259  memristor PARAMS: InitStateVar=0.277437
X8179   82   259  memristor PARAMS: InitStateVar=0.26078
X8279   83   259  memristor PARAMS: InitStateVar=0.123802
X8379   84   259  memristor PARAMS: InitStateVar=0.390627
X8479   85   259  memristor PARAMS: InitStateVar=0.175167
X8579   86   259  memristor PARAMS: InitStateVar=0.221022
X8679   87   259  memristor PARAMS: InitStateVar=0.426115
X8779   88   259  memristor PARAMS: InitStateVar=0.296042
X8879   89   259  memristor PARAMS: InitStateVar=0.250653
X8979   90   259  memristor PARAMS: InitStateVar=0.219511
X9079   91   259  memristor PARAMS: InitStateVar=0.153256
X9179   92   259  memristor PARAMS: InitStateVar=0.222973
X9279   93   259  memristor PARAMS: InitStateVar=0.271085
X9379   94   259  memristor PARAMS: InitStateVar=0.212779
X9479   95   259  memristor PARAMS: InitStateVar=0.27134
X9579   96   259  memristor PARAMS: InitStateVar=0.392791
X9679   97   259  memristor PARAMS: InitStateVar=0.331838
X9779   98   259  memristor PARAMS: InitStateVar=0.380319
X9879   99   259  memristor PARAMS: InitStateVar=0.189523
X9979   100  259  memristor PARAMS: InitStateVar=0.324269
Xo80    259  260  OutputModule PARAMS: Rval=100
*------------------- Column 81 -------------------------------------------------
X80     1    261  memristor PARAMS: InitStateVar=0.270788
X180    2    261  memristor PARAMS: InitStateVar=0.206452
X280    3    261  memristor PARAMS: InitStateVar=0.406424
X380    4    261  memristor PARAMS: InitStateVar=0.472393
X480    5    261  memristor PARAMS: InitStateVar=0.227074
X580    6    261  memristor PARAMS: InitStateVar=0.353698
X680    7    261  memristor PARAMS: InitStateVar=0.396919
X780    8    261  memristor PARAMS: InitStateVar=0.52797
X880    9    261  memristor PARAMS: InitStateVar=0.434771
X980    10   261  memristor PARAMS: InitStateVar=0.34737
X1080   11   261  memristor PARAMS: InitStateVar=0.355611
X1180   12   261  memristor PARAMS: InitStateVar=0.231055
X1280   13   261  memristor PARAMS: InitStateVar=0.284748
X1380   14   261  memristor PARAMS: InitStateVar=0.350479
X1480   15   261  memristor PARAMS: InitStateVar=0.158121
X1580   16   261  memristor PARAMS: InitStateVar=0.37806
X1680   17   261  memristor PARAMS: InitStateVar=0.204963
X1780   18   261  memristor PARAMS: InitStateVar=0.167958
X1880   19   261  memristor PARAMS: InitStateVar=0.540121
X1980   20   261  memristor PARAMS: InitStateVar=0.362594
X2080   21   261  memristor PARAMS: InitStateVar=0.331504
X2180   22   261  memristor PARAMS: InitStateVar=0.217549
X2280   23   261  memristor PARAMS: InitStateVar=0.418118
X2380   24   261  memristor PARAMS: InitStateVar=0.0933949
X2480   25   261  memristor PARAMS: InitStateVar=0.256646
X2580   26   261  memristor PARAMS: InitStateVar=0.140333
X2680   27   261  memristor PARAMS: InitStateVar=0.278888
X2780   28   261  memristor PARAMS: InitStateVar=0.406659
X2880   29   261  memristor PARAMS: InitStateVar=0.299744
X2980   30   261  memristor PARAMS: InitStateVar=0.128242
X3080   31   261  memristor PARAMS: InitStateVar=0.18643
X3180   32   261  memristor PARAMS: InitStateVar=0.336439
X3280   33   261  memristor PARAMS: InitStateVar=0.183502
X3380   34   261  memristor PARAMS: InitStateVar=0.448452
X3480   35   261  memristor PARAMS: InitStateVar=0.237315
X3580   36   261  memristor PARAMS: InitStateVar=0.380897
X3680   37   261  memristor PARAMS: InitStateVar=0.320466
X3780   38   261  memristor PARAMS: InitStateVar=0.388748
X3880   39   261  memristor PARAMS: InitStateVar=0.35988
X3980   40   261  memristor PARAMS: InitStateVar=0.41317
X4080   41   261  memristor PARAMS: InitStateVar=0.273163
X4180   42   261  memristor PARAMS: InitStateVar=0.368243
X4280   43   261  memristor PARAMS: InitStateVar=0.210824
X4380   44   261  memristor PARAMS: InitStateVar=0.256145
X4480   45   261  memristor PARAMS: InitStateVar=0.333528
X4580   46   261  memristor PARAMS: InitStateVar=0.277672
X4680   47   261  memristor PARAMS: InitStateVar=0.205039
X4780   48   261  memristor PARAMS: InitStateVar=0.254583
X4880   49   261  memristor PARAMS: InitStateVar=0.212248
X4980   50   261  memristor PARAMS: InitStateVar=0.179505
X5080   51   261  memristor PARAMS: InitStateVar=0.267074
X5180   52   261  memristor PARAMS: InitStateVar=0.273626
X5280   53   261  memristor PARAMS: InitStateVar=0.495718
X5380   54   261  memristor PARAMS: InitStateVar=0.174547
X5480   55   261  memristor PARAMS: InitStateVar=0.31414
X5580   56   261  memristor PARAMS: InitStateVar=0.255766
X5680   57   261  memristor PARAMS: InitStateVar=0.283804
X5780   58   261  memristor PARAMS: InitStateVar=0.285696
X5880   59   261  memristor PARAMS: InitStateVar=0.247337
X5980   60   261  memristor PARAMS: InitStateVar=0.450913
X6080   61   261  memristor PARAMS: InitStateVar=0.430966
X6180   62   261  memristor PARAMS: InitStateVar=0.387471
X6280   63   261  memristor PARAMS: InitStateVar=0.416732
X6380   64   261  memristor PARAMS: InitStateVar=0.238825
X6480   65   261  memristor PARAMS: InitStateVar=0.0690773
X6580   66   261  memristor PARAMS: InitStateVar=0.36595
X6680   67   261  memristor PARAMS: InitStateVar=0.393774
X6780   68   261  memristor PARAMS: InitStateVar=0.307058
X6880   69   261  memristor PARAMS: InitStateVar=0.425972
X6980   70   261  memristor PARAMS: InitStateVar=0.136962
X7080   71   261  memristor PARAMS: InitStateVar=0.234159
X7180   72   261  memristor PARAMS: InitStateVar=0.13063
X7280   73   261  memristor PARAMS: InitStateVar=0.336118
X7380   74   261  memristor PARAMS: InitStateVar=0.435019
X7480   75   261  memristor PARAMS: InitStateVar=0.24638
X7580   76   261  memristor PARAMS: InitStateVar=0.161883
X7680   77   261  memristor PARAMS: InitStateVar=0.302194
X7780   78   261  memristor PARAMS: InitStateVar=0.395722
X7880   79   261  memristor PARAMS: InitStateVar=0.360009
X7980   80   261  memristor PARAMS: InitStateVar=0.259143
X8080   81   261  memristor PARAMS: InitStateVar=0.379262
X8180   82   261  memristor PARAMS: InitStateVar=0.493584
X8280   83   261  memristor PARAMS: InitStateVar=0.47903
X8380   84   261  memristor PARAMS: InitStateVar=0.442331
X8480   85   261  memristor PARAMS: InitStateVar=0.312218
X8580   86   261  memristor PARAMS: InitStateVar=0.340723
X8680   87   261  memristor PARAMS: InitStateVar=0.255925
X8780   88   261  memristor PARAMS: InitStateVar=0.340408
X8880   89   261  memristor PARAMS: InitStateVar=0.25896
X8980   90   261  memristor PARAMS: InitStateVar=0.276804
X9080   91   261  memristor PARAMS: InitStateVar=0.151741
X9180   92   261  memristor PARAMS: InitStateVar=0.4204
X9280   93   261  memristor PARAMS: InitStateVar=0.374141
X9380   94   261  memristor PARAMS: InitStateVar=0.475558
X9480   95   261  memristor PARAMS: InitStateVar=0.195912
X9580   96   261  memristor PARAMS: InitStateVar=0.408752
X9680   97   261  memristor PARAMS: InitStateVar=0.327424
X9780   98   261  memristor PARAMS: InitStateVar=0.252245
X9880   99   261  memristor PARAMS: InitStateVar=0.424046
X9980   100  261  memristor PARAMS: InitStateVar=0.226556
Xo81    261  262  OutputModule PARAMS: Rval=100
*------------------- Column 82 -------------------------------------------------
X81     1    263  memristor PARAMS: InitStateVar=0.366911
X181    2    263  memristor PARAMS: InitStateVar=0.394346
X281    3    263  memristor PARAMS: InitStateVar=0.273888
X381    4    263  memristor PARAMS: InitStateVar=0.370349
X481    5    263  memristor PARAMS: InitStateVar=0.271026
X581    6    263  memristor PARAMS: InitStateVar=0.164479
X681    7    263  memristor PARAMS: InitStateVar=0.222082
X781    8    263  memristor PARAMS: InitStateVar=0.360199
X881    9    263  memristor PARAMS: InitStateVar=0.432175
X981    10   263  memristor PARAMS: InitStateVar=0.242723
X1081   11   263  memristor PARAMS: InitStateVar=0.190629
X1181   12   263  memristor PARAMS: InitStateVar=0.112634
X1281   13   263  memristor PARAMS: InitStateVar=0.168154
X1381   14   263  memristor PARAMS: InitStateVar=0.357048
X1481   15   263  memristor PARAMS: InitStateVar=0.161738
X1581   16   263  memristor PARAMS: InitStateVar=0.520087
X1681   17   263  memristor PARAMS: InitStateVar=0.208039
X1781   18   263  memristor PARAMS: InitStateVar=0.279768
X1881   19   263  memristor PARAMS: InitStateVar=0.194968
X1981   20   263  memristor PARAMS: InitStateVar=0.431734
X2081   21   263  memristor PARAMS: InitStateVar=0.423643
X2181   22   263  memristor PARAMS: InitStateVar=0.384637
X2281   23   263  memristor PARAMS: InitStateVar=0.526697
X2381   24   263  memristor PARAMS: InitStateVar=0.382644
X2481   25   263  memristor PARAMS: InitStateVar=0.206318
X2581   26   263  memristor PARAMS: InitStateVar=0.197751
X2681   27   263  memristor PARAMS: InitStateVar=0.263508
X2781   28   263  memristor PARAMS: InitStateVar=0.3304
X2881   29   263  memristor PARAMS: InitStateVar=0.209442
X2981   30   263  memristor PARAMS: InitStateVar=0.270345
X3081   31   263  memristor PARAMS: InitStateVar=0.237371
X3181   32   263  memristor PARAMS: InitStateVar=0.140324
X3281   33   263  memristor PARAMS: InitStateVar=0.289668
X3381   34   263  memristor PARAMS: InitStateVar=0.136498
X3481   35   263  memristor PARAMS: InitStateVar=0.214882
X3581   36   263  memristor PARAMS: InitStateVar=0.327142
X3681   37   263  memristor PARAMS: InitStateVar=0.220175
X3781   38   263  memristor PARAMS: InitStateVar=0.443891
X3881   39   263  memristor PARAMS: InitStateVar=0.308048
X3981   40   263  memristor PARAMS: InitStateVar=0.418277
X4081   41   263  memristor PARAMS: InitStateVar=0.278599
X4181   42   263  memristor PARAMS: InitStateVar=0.351033
X4281   43   263  memristor PARAMS: InitStateVar=0.277996
X4381   44   263  memristor PARAMS: InitStateVar=0.414122
X4481   45   263  memristor PARAMS: InitStateVar=0.366558
X4581   46   263  memristor PARAMS: InitStateVar=0.412184
X4681   47   263  memristor PARAMS: InitStateVar=0.348361
X4781   48   263  memristor PARAMS: InitStateVar=0.446267
X4881   49   263  memristor PARAMS: InitStateVar=0.341336
X4981   50   263  memristor PARAMS: InitStateVar=0.444873
X5081   51   263  memristor PARAMS: InitStateVar=0.319581
X5181   52   263  memristor PARAMS: InitStateVar=0.417695
X5281   53   263  memristor PARAMS: InitStateVar=0.318217
X5381   54   263  memristor PARAMS: InitStateVar=0.413077
X5481   55   263  memristor PARAMS: InitStateVar=0.218341
X5581   56   263  memristor PARAMS: InitStateVar=0.192118
X5681   57   263  memristor PARAMS: InitStateVar=0.182867
X5781   58   263  memristor PARAMS: InitStateVar=0.386765
X5881   59   263  memristor PARAMS: InitStateVar=0.26648
X5981   60   263  memristor PARAMS: InitStateVar=0.313939
X6081   61   263  memristor PARAMS: InitStateVar=0.353205
X6181   62   263  memristor PARAMS: InitStateVar=0.464143
X6281   63   263  memristor PARAMS: InitStateVar=0.35249
X6381   64   263  memristor PARAMS: InitStateVar=0.263499
X6481   65   263  memristor PARAMS: InitStateVar=0.234615
X6581   66   263  memristor PARAMS: InitStateVar=0.352208
X6681   67   263  memristor PARAMS: InitStateVar=0.467186
X6781   68   263  memristor PARAMS: InitStateVar=0.33744
X6881   69   263  memristor PARAMS: InitStateVar=0.343907
X6981   70   263  memristor PARAMS: InitStateVar=0.336433
X7081   71   263  memristor PARAMS: InitStateVar=0.433543
X7181   72   263  memristor PARAMS: InitStateVar=0.256276
X7281   73   263  memristor PARAMS: InitStateVar=0.371592
X7381   74   263  memristor PARAMS: InitStateVar=0.26757
X7481   75   263  memristor PARAMS: InitStateVar=0.29337
X7581   76   263  memristor PARAMS: InitStateVar=0.307806
X7681   77   263  memristor PARAMS: InitStateVar=0.208699
X7781   78   263  memristor PARAMS: InitStateVar=0.401058
X7881   79   263  memristor PARAMS: InitStateVar=0.149546
X7981   80   263  memristor PARAMS: InitStateVar=0.223501
X8081   81   263  memristor PARAMS: InitStateVar=0.296923
X8181   82   263  memristor PARAMS: InitStateVar=0.196859
X8281   83   263  memristor PARAMS: InitStateVar=0.130708
X8381   84   263  memristor PARAMS: InitStateVar=0.186534
X8481   85   263  memristor PARAMS: InitStateVar=0.328362
X8581   86   263  memristor PARAMS: InitStateVar=0.19155
X8681   87   263  memristor PARAMS: InitStateVar=0.454258
X8781   88   263  memristor PARAMS: InitStateVar=0.329629
X8881   89   263  memristor PARAMS: InitStateVar=0.207109
X8981   90   263  memristor PARAMS: InitStateVar=0.29615
X9081   91   263  memristor PARAMS: InitStateVar=0.208465
X9181   92   263  memristor PARAMS: InitStateVar=0.301576
X9281   93   263  memristor PARAMS: InitStateVar=0.295731
X9381   94   263  memristor PARAMS: InitStateVar=0.607683
X9481   95   263  memristor PARAMS: InitStateVar=0.333942
X9581   96   263  memristor PARAMS: InitStateVar=0.0777236
X9681   97   263  memristor PARAMS: InitStateVar=0.452252
X9781   98   263  memristor PARAMS: InitStateVar=0.364479
X9881   99   263  memristor PARAMS: InitStateVar=0.298964
X9981   100  263  memristor PARAMS: InitStateVar=0.32981
Xo82    263  264  OutputModule PARAMS: Rval=100
*------------------- Column 83 -------------------------------------------------
X82     1    265  memristor PARAMS: InitStateVar=0.339808
X182    2    265  memristor PARAMS: InitStateVar=0.382962
X282    3    265  memristor PARAMS: InitStateVar=0.344412
X382    4    265  memristor PARAMS: InitStateVar=0.445867
X482    5    265  memristor PARAMS: InitStateVar=0.21103
X582    6    265  memristor PARAMS: InitStateVar=0.0704835
X682    7    265  memristor PARAMS: InitStateVar=0.301103
X782    8    265  memristor PARAMS: InitStateVar=0.347659
X882    9    265  memristor PARAMS: InitStateVar=0.271329
X982    10   265  memristor PARAMS: InitStateVar=0.170702
X1082   11   265  memristor PARAMS: InitStateVar=0.246351
X1182   12   265  memristor PARAMS: InitStateVar=0.367432
X1282   13   265  memristor PARAMS: InitStateVar=0.238136
X1382   14   265  memristor PARAMS: InitStateVar=0.206709
X1482   15   265  memristor PARAMS: InitStateVar=0.238577
X1582   16   265  memristor PARAMS: InitStateVar=0.450946
X1682   17   265  memristor PARAMS: InitStateVar=0.378878
X1782   18   265  memristor PARAMS: InitStateVar=0.283807
X1882   19   265  memristor PARAMS: InitStateVar=0.189252
X1982   20   265  memristor PARAMS: InitStateVar=0.335151
X2082   21   265  memristor PARAMS: InitStateVar=0.155678
X2182   22   265  memristor PARAMS: InitStateVar=0.355273
X2282   23   265  memristor PARAMS: InitStateVar=0.312449
X2382   24   265  memristor PARAMS: InitStateVar=0.182348
X2482   25   265  memristor PARAMS: InitStateVar=0.133016
X2582   26   265  memristor PARAMS: InitStateVar=0.283974
X2682   27   265  memristor PARAMS: InitStateVar=0.399393
X2782   28   265  memristor PARAMS: InitStateVar=0.318609
X2882   29   265  memristor PARAMS: InitStateVar=0.196987
X2982   30   265  memristor PARAMS: InitStateVar=0.132392
X3082   31   265  memristor PARAMS: InitStateVar=0.321395
X3182   32   265  memristor PARAMS: InitStateVar=0.180493
X3282   33   265  memristor PARAMS: InitStateVar=0.394006
X3382   34   265  memristor PARAMS: InitStateVar=0.332847
X3482   35   265  memristor PARAMS: InitStateVar=0.121783
X3582   36   265  memristor PARAMS: InitStateVar=0.380138
X3682   37   265  memristor PARAMS: InitStateVar=0.197403
X3782   38   265  memristor PARAMS: InitStateVar=0.337476
X3882   39   265  memristor PARAMS: InitStateVar=0.313383
X3982   40   265  memristor PARAMS: InitStateVar=0.265214
X4082   41   265  memristor PARAMS: InitStateVar=0.264322
X4182   42   265  memristor PARAMS: InitStateVar=0.246657
X4282   43   265  memristor PARAMS: InitStateVar=0.294455
X4382   44   265  memristor PARAMS: InitStateVar=0.269557
X4482   45   265  memristor PARAMS: InitStateVar=0.161657
X4582   46   265  memristor PARAMS: InitStateVar=0.164341
X4682   47   265  memristor PARAMS: InitStateVar=0.221033
X4782   48   265  memristor PARAMS: InitStateVar=0.321937
X4882   49   265  memristor PARAMS: InitStateVar=0.397286
X4982   50   265  memristor PARAMS: InitStateVar=0.325526
X5082   51   265  memristor PARAMS: InitStateVar=0.302626
X5182   52   265  memristor PARAMS: InitStateVar=0.395091
X5282   53   265  memristor PARAMS: InitStateVar=0.113572
X5382   54   265  memristor PARAMS: InitStateVar=0.267711
X5482   55   265  memristor PARAMS: InitStateVar=0.273152
X5582   56   265  memristor PARAMS: InitStateVar=0.354154
X5682   57   265  memristor PARAMS: InitStateVar=0.312091
X5782   58   265  memristor PARAMS: InitStateVar=0.204595
X5882   59   265  memristor PARAMS: InitStateVar=0.301196
X5982   60   265  memristor PARAMS: InitStateVar=0.19826
X6082   61   265  memristor PARAMS: InitStateVar=0.393723
X6182   62   265  memristor PARAMS: InitStateVar=0.232116
X6282   63   265  memristor PARAMS: InitStateVar=0.216499
X6382   64   265  memristor PARAMS: InitStateVar=0.387972
X6482   65   265  memristor PARAMS: InitStateVar=0.29789
X6582   66   265  memristor PARAMS: InitStateVar=0.393612
X6682   67   265  memristor PARAMS: InitStateVar=0.0682048
X6782   68   265  memristor PARAMS: InitStateVar=0.265342
X6882   69   265  memristor PARAMS: InitStateVar=0.00543871
X6982   70   265  memristor PARAMS: InitStateVar=0.425442
X7082   71   265  memristor PARAMS: InitStateVar=0.286205
X7182   72   265  memristor PARAMS: InitStateVar=0.344056
X7282   73   265  memristor PARAMS: InitStateVar=0.177841
X7382   74   265  memristor PARAMS: InitStateVar=0.555535
X7482   75   265  memristor PARAMS: InitStateVar=0.40559
X7582   76   265  memristor PARAMS: InitStateVar=0.177934
X7682   77   265  memristor PARAMS: InitStateVar=0.254558
X7782   78   265  memristor PARAMS: InitStateVar=0.409398
X7882   79   265  memristor PARAMS: InitStateVar=0.267589
X7982   80   265  memristor PARAMS: InitStateVar=0.210431
X8082   81   265  memristor PARAMS: InitStateVar=0.383367
X8182   82   265  memristor PARAMS: InitStateVar=0.246741
X8282   83   265  memristor PARAMS: InitStateVar=0.226754
X8382   84   265  memristor PARAMS: InitStateVar=0.175424
X8482   85   265  memristor PARAMS: InitStateVar=0.366417
X8582   86   265  memristor PARAMS: InitStateVar=0.26544
X8682   87   265  memristor PARAMS: InitStateVar=0.305041
X8782   88   265  memristor PARAMS: InitStateVar=0.412526
X8882   89   265  memristor PARAMS: InitStateVar=0.433474
X8982   90   265  memristor PARAMS: InitStateVar=0.434717
X9082   91   265  memristor PARAMS: InitStateVar=0.251488
X9182   92   265  memristor PARAMS: InitStateVar=0.445092
X9282   93   265  memristor PARAMS: InitStateVar=0.358846
X9382   94   265  memristor PARAMS: InitStateVar=0.430298
X9482   95   265  memristor PARAMS: InitStateVar=0.359546
X9582   96   265  memristor PARAMS: InitStateVar=0.286858
X9682   97   265  memristor PARAMS: InitStateVar=0.320817
X9782   98   265  memristor PARAMS: InitStateVar=0.298194
X9882   99   265  memristor PARAMS: InitStateVar=0.530215
X9982   100  265  memristor PARAMS: InitStateVar=0.328089
Xo83    265  266  OutputModule PARAMS: Rval=100
*------------------- Column 84 -------------------------------------------------
X83     1    267  memristor PARAMS: InitStateVar=0.133661
X183    2    267  memristor PARAMS: InitStateVar=0.18278
X283    3    267  memristor PARAMS: InitStateVar=0.298156
X383    4    267  memristor PARAMS: InitStateVar=0.326495
X483    5    267  memristor PARAMS: InitStateVar=0.46149
X583    6    267  memristor PARAMS: InitStateVar=0.289658
X683    7    267  memristor PARAMS: InitStateVar=0.39619
X783    8    267  memristor PARAMS: InitStateVar=0.302546
X883    9    267  memristor PARAMS: InitStateVar=0.323814
X983    10   267  memristor PARAMS: InitStateVar=0.312757
X1083   11   267  memristor PARAMS: InitStateVar=0.29161
X1183   12   267  memristor PARAMS: InitStateVar=0.314603
X1283   13   267  memristor PARAMS: InitStateVar=0.198483
X1383   14   267  memristor PARAMS: InitStateVar=0.314384
X1483   15   267  memristor PARAMS: InitStateVar=0.44851
X1583   16   267  memristor PARAMS: InitStateVar=0.314043
X1683   17   267  memristor PARAMS: InitStateVar=0.332226
X1783   18   267  memristor PARAMS: InitStateVar=0.265335
X1883   19   267  memristor PARAMS: InitStateVar=0.102347
X1983   20   267  memristor PARAMS: InitStateVar=0.435841
X2083   21   267  memristor PARAMS: InitStateVar=0.422737
X2183   22   267  memristor PARAMS: InitStateVar=0.328002
X2283   23   267  memristor PARAMS: InitStateVar=0.226563
X2383   24   267  memristor PARAMS: InitStateVar=0.32929
X2483   25   267  memristor PARAMS: InitStateVar=0.317026
X2583   26   267  memristor PARAMS: InitStateVar=0.0998689
X2683   27   267  memristor PARAMS: InitStateVar=0.170158
X2783   28   267  memristor PARAMS: InitStateVar=0.301438
X2883   29   267  memristor PARAMS: InitStateVar=0.463412
X2983   30   267  memristor PARAMS: InitStateVar=0.193054
X3083   31   267  memristor PARAMS: InitStateVar=0.158692
X3183   32   267  memristor PARAMS: InitStateVar=0.302422
X3283   33   267  memristor PARAMS: InitStateVar=0.1667
X3383   34   267  memristor PARAMS: InitStateVar=0.204891
X3483   35   267  memristor PARAMS: InitStateVar=0.318798
X3583   36   267  memristor PARAMS: InitStateVar=0.389879
X3683   37   267  memristor PARAMS: InitStateVar=0.356411
X3783   38   267  memristor PARAMS: InitStateVar=0.385043
X3883   39   267  memristor PARAMS: InitStateVar=0.361992
X3983   40   267  memristor PARAMS: InitStateVar=0.194538
X4083   41   267  memristor PARAMS: InitStateVar=0.184255
X4183   42   267  memristor PARAMS: InitStateVar=0.310021
X4283   43   267  memristor PARAMS: InitStateVar=0.330237
X4383   44   267  memristor PARAMS: InitStateVar=0.428027
X4483   45   267  memristor PARAMS: InitStateVar=0.378154
X4583   46   267  memristor PARAMS: InitStateVar=0.461136
X4683   47   267  memristor PARAMS: InitStateVar=0.197402
X4783   48   267  memristor PARAMS: InitStateVar=0.286293
X4883   49   267  memristor PARAMS: InitStateVar=0.262861
X4983   50   267  memristor PARAMS: InitStateVar=0.358903
X5083   51   267  memristor PARAMS: InitStateVar=0.456504
X5183   52   267  memristor PARAMS: InitStateVar=0.412528
X5283   53   267  memristor PARAMS: InitStateVar=0.22337
X5383   54   267  memristor PARAMS: InitStateVar=0.326172
X5483   55   267  memristor PARAMS: InitStateVar=0.30956
X5583   56   267  memristor PARAMS: InitStateVar=0.434958
X5683   57   267  memristor PARAMS: InitStateVar=0.388125
X5783   58   267  memristor PARAMS: InitStateVar=0.352408
X5883   59   267  memristor PARAMS: InitStateVar=0.256644
X5983   60   267  memristor PARAMS: InitStateVar=0.26393
X6083   61   267  memristor PARAMS: InitStateVar=0.358763
X6183   62   267  memristor PARAMS: InitStateVar=0.131497
X6283   63   267  memristor PARAMS: InitStateVar=0.225481
X6383   64   267  memristor PARAMS: InitStateVar=0.351308
X6483   65   267  memristor PARAMS: InitStateVar=0.256617
X6583   66   267  memristor PARAMS: InitStateVar=0.469854
X6683   67   267  memristor PARAMS: InitStateVar=0.346172
X6783   68   267  memristor PARAMS: InitStateVar=0.363003
X6883   69   267  memristor PARAMS: InitStateVar=0.42751
X6983   70   267  memristor PARAMS: InitStateVar=0.255954
X7083   71   267  memristor PARAMS: InitStateVar=0.172795
X7183   72   267  memristor PARAMS: InitStateVar=0.295991
X7283   73   267  memristor PARAMS: InitStateVar=0.391043
X7383   74   267  memristor PARAMS: InitStateVar=0.389373
X7483   75   267  memristor PARAMS: InitStateVar=0.289293
X7583   76   267  memristor PARAMS: InitStateVar=0.331072
X7683   77   267  memristor PARAMS: InitStateVar=0.329127
X7783   78   267  memristor PARAMS: InitStateVar=0.244255
X7883   79   267  memristor PARAMS: InitStateVar=0.125017
X7983   80   267  memristor PARAMS: InitStateVar=0.308112
X8083   81   267  memristor PARAMS: InitStateVar=0.381129
X8183   82   267  memristor PARAMS: InitStateVar=0.15413
X8283   83   267  memristor PARAMS: InitStateVar=0.382026
X8383   84   267  memristor PARAMS: InitStateVar=0.217082
X8483   85   267  memristor PARAMS: InitStateVar=0.309031
X8583   86   267  memristor PARAMS: InitStateVar=0.128879
X8683   87   267  memristor PARAMS: InitStateVar=0.282093
X8783   88   267  memristor PARAMS: InitStateVar=0.355961
X8883   89   267  memristor PARAMS: InitStateVar=0.273163
X8983   90   267  memristor PARAMS: InitStateVar=0.22858
X9083   91   267  memristor PARAMS: InitStateVar=0.437435
X9183   92   267  memristor PARAMS: InitStateVar=0.230215
X9283   93   267  memristor PARAMS: InitStateVar=0.234254
X9383   94   267  memristor PARAMS: InitStateVar=0.364742
X9483   95   267  memristor PARAMS: InitStateVar=0.30841
X9583   96   267  memristor PARAMS: InitStateVar=0.295254
X9683   97   267  memristor PARAMS: InitStateVar=0.439885
X9783   98   267  memristor PARAMS: InitStateVar=0.376248
X9883   99   267  memristor PARAMS: InitStateVar=0.468707
X9983   100  267  memristor PARAMS: InitStateVar=0.265413
Xo84    267  268  OutputModule PARAMS: Rval=100
*------------------- Column 85 -------------------------------------------------
X84     1    269  memristor PARAMS: InitStateVar=0.238457
X184    2    269  memristor PARAMS: InitStateVar=0.275769
X284    3    269  memristor PARAMS: InitStateVar=0.107711
X384    4    269  memristor PARAMS: InitStateVar=0.325245
X484    5    269  memristor PARAMS: InitStateVar=0.272018
X584    6    269  memristor PARAMS: InitStateVar=0.141703
X684    7    269  memristor PARAMS: InitStateVar=0.192296
X784    8    269  memristor PARAMS: InitStateVar=0.196636
X884    9    269  memristor PARAMS: InitStateVar=0.346537
X984    10   269  memristor PARAMS: InitStateVar=0.285022
X1084   11   269  memristor PARAMS: InitStateVar=0.444934
X1184   12   269  memristor PARAMS: InitStateVar=0.244118
X1284   13   269  memristor PARAMS: InitStateVar=0.193682
X1384   14   269  memristor PARAMS: InitStateVar=0.27876
X1484   15   269  memristor PARAMS: InitStateVar=0.378008
X1584   16   269  memristor PARAMS: InitStateVar=0.483123
X1684   17   269  memristor PARAMS: InitStateVar=0.210169
X1784   18   269  memristor PARAMS: InitStateVar=0.338072
X1884   19   269  memristor PARAMS: InitStateVar=0.386129
X1984   20   269  memristor PARAMS: InitStateVar=0.321068
X2084   21   269  memristor PARAMS: InitStateVar=0.479471
X2184   22   269  memristor PARAMS: InitStateVar=0.372576
X2284   23   269  memristor PARAMS: InitStateVar=0.336761
X2384   24   269  memristor PARAMS: InitStateVar=0.300809
X2484   25   269  memristor PARAMS: InitStateVar=0.158586
X2584   26   269  memristor PARAMS: InitStateVar=0.351027
X2684   27   269  memristor PARAMS: InitStateVar=0.143175
X2784   28   269  memristor PARAMS: InitStateVar=0.240464
X2884   29   269  memristor PARAMS: InitStateVar=0.110449
X2984   30   269  memristor PARAMS: InitStateVar=0.34864
X3084   31   269  memristor PARAMS: InitStateVar=0.262818
X3184   32   269  memristor PARAMS: InitStateVar=0.260098
X3284   33   269  memristor PARAMS: InitStateVar=0.116294
X3384   34   269  memristor PARAMS: InitStateVar=0.470316
X3484   35   269  memristor PARAMS: InitStateVar=0.258337
X3584   36   269  memristor PARAMS: InitStateVar=0.298009
X3684   37   269  memristor PARAMS: InitStateVar=0.39517
X3784   38   269  memristor PARAMS: InitStateVar=0.308461
X3884   39   269  memristor PARAMS: InitStateVar=0.318668
X3984   40   269  memristor PARAMS: InitStateVar=0.361687
X4084   41   269  memristor PARAMS: InitStateVar=0.381215
X4184   42   269  memristor PARAMS: InitStateVar=0.474586
X4284   43   269  memristor PARAMS: InitStateVar=0.460713
X4384   44   269  memristor PARAMS: InitStateVar=0.428926
X4484   45   269  memristor PARAMS: InitStateVar=0.285031
X4584   46   269  memristor PARAMS: InitStateVar=0.245927
X4684   47   269  memristor PARAMS: InitStateVar=0.088036
X4784   48   269  memristor PARAMS: InitStateVar=0.521373
X4884   49   269  memristor PARAMS: InitStateVar=0.343666
X4984   50   269  memristor PARAMS: InitStateVar=0.279905
X5084   51   269  memristor PARAMS: InitStateVar=0.278719
X5184   52   269  memristor PARAMS: InitStateVar=0.189037
X5284   53   269  memristor PARAMS: InitStateVar=0.158856
X5384   54   269  memristor PARAMS: InitStateVar=0.339328
X5484   55   269  memristor PARAMS: InitStateVar=0.290044
X5584   56   269  memristor PARAMS: InitStateVar=0.222244
X5684   57   269  memristor PARAMS: InitStateVar=0.449658
X5784   58   269  memristor PARAMS: InitStateVar=0.183981
X5884   59   269  memristor PARAMS: InitStateVar=0.416324
X5984   60   269  memristor PARAMS: InitStateVar=0.336256
X6084   61   269  memristor PARAMS: InitStateVar=0.380819
X6184   62   269  memristor PARAMS: InitStateVar=0.198148
X6284   63   269  memristor PARAMS: InitStateVar=0.362066
X6384   64   269  memristor PARAMS: InitStateVar=0.257202
X6484   65   269  memristor PARAMS: InitStateVar=0.480535
X6584   66   269  memristor PARAMS: InitStateVar=0.218574
X6684   67   269  memristor PARAMS: InitStateVar=0.281318
X6784   68   269  memristor PARAMS: InitStateVar=0.319149
X6884   69   269  memristor PARAMS: InitStateVar=0.323959
X6984   70   269  memristor PARAMS: InitStateVar=0.216395
X7084   71   269  memristor PARAMS: InitStateVar=0.297971
X7184   72   269  memristor PARAMS: InitStateVar=0.552818
X7284   73   269  memristor PARAMS: InitStateVar=0.247654
X7384   74   269  memristor PARAMS: InitStateVar=0.184523
X7484   75   269  memristor PARAMS: InitStateVar=0.187059
X7584   76   269  memristor PARAMS: InitStateVar=0.392614
X7684   77   269  memristor PARAMS: InitStateVar=0.484984
X7784   78   269  memristor PARAMS: InitStateVar=0.361909
X7884   79   269  memristor PARAMS: InitStateVar=0.145978
X7984   80   269  memristor PARAMS: InitStateVar=0.415261
X8084   81   269  memristor PARAMS: InitStateVar=0.152879
X8184   82   269  memristor PARAMS: InitStateVar=0.321912
X8284   83   269  memristor PARAMS: InitStateVar=0.352028
X8384   84   269  memristor PARAMS: InitStateVar=0.213279
X8484   85   269  memristor PARAMS: InitStateVar=0.310337
X8584   86   269  memristor PARAMS: InitStateVar=0.350417
X8684   87   269  memristor PARAMS: InitStateVar=0.413234
X8784   88   269  memristor PARAMS: InitStateVar=0.179736
X8884   89   269  memristor PARAMS: InitStateVar=0.331803
X8984   90   269  memristor PARAMS: InitStateVar=0.359996
X9084   91   269  memristor PARAMS: InitStateVar=0.399766
X9184   92   269  memristor PARAMS: InitStateVar=0.381265
X9284   93   269  memristor PARAMS: InitStateVar=0.288184
X9384   94   269  memristor PARAMS: InitStateVar=0.276184
X9484   95   269  memristor PARAMS: InitStateVar=0.308253
X9584   96   269  memristor PARAMS: InitStateVar=0.0716478
X9684   97   269  memristor PARAMS: InitStateVar=0.173897
X9784   98   269  memristor PARAMS: InitStateVar=0.26487
X9884   99   269  memristor PARAMS: InitStateVar=0.343538
X9984   100  269  memristor PARAMS: InitStateVar=0.338154
Xo85    269  270  OutputModule PARAMS: Rval=100
*------------------- Column 86 -------------------------------------------------
X85     1    271  memristor PARAMS: InitStateVar=0.349727
X185    2    271  memristor PARAMS: InitStateVar=0.405084
X285    3    271  memristor PARAMS: InitStateVar=0.33545
X385    4    271  memristor PARAMS: InitStateVar=0.115871
X485    5    271  memristor PARAMS: InitStateVar=0.38734
X585    6    271  memristor PARAMS: InitStateVar=0.221178
X685    7    271  memristor PARAMS: InitStateVar=0.280228
X785    8    271  memristor PARAMS: InitStateVar=0.492474
X885    9    271  memristor PARAMS: InitStateVar=0.314059
X985    10   271  memristor PARAMS: InitStateVar=0.259365
X1085   11   271  memristor PARAMS: InitStateVar=0.402882
X1185   12   271  memristor PARAMS: InitStateVar=0.360753
X1285   13   271  memristor PARAMS: InitStateVar=0.304605
X1385   14   271  memristor PARAMS: InitStateVar=0.38561
X1485   15   271  memristor PARAMS: InitStateVar=0.337701
X1585   16   271  memristor PARAMS: InitStateVar=0.358361
X1685   17   271  memristor PARAMS: InitStateVar=0.272139
X1785   18   271  memristor PARAMS: InitStateVar=0.244885
X1885   19   271  memristor PARAMS: InitStateVar=0.310277
X1985   20   271  memristor PARAMS: InitStateVar=0.249183
X2085   21   271  memristor PARAMS: InitStateVar=0.386899
X2185   22   271  memristor PARAMS: InitStateVar=0.147158
X2285   23   271  memristor PARAMS: InitStateVar=0.257406
X2385   24   271  memristor PARAMS: InitStateVar=0.211309
X2485   25   271  memristor PARAMS: InitStateVar=0.335554
X2585   26   271  memristor PARAMS: InitStateVar=0.198292
X2685   27   271  memristor PARAMS: InitStateVar=0.213632
X2785   28   271  memristor PARAMS: InitStateVar=0.357733
X2885   29   271  memristor PARAMS: InitStateVar=0.2985
X2985   30   271  memristor PARAMS: InitStateVar=0.343019
X3085   31   271  memristor PARAMS: InitStateVar=0.130708
X3185   32   271  memristor PARAMS: InitStateVar=0.385696
X3285   33   271  memristor PARAMS: InitStateVar=0.465474
X3385   34   271  memristor PARAMS: InitStateVar=0.217112
X3485   35   271  memristor PARAMS: InitStateVar=0.271643
X3585   36   271  memristor PARAMS: InitStateVar=0.457549
X3685   37   271  memristor PARAMS: InitStateVar=0.337471
X3785   38   271  memristor PARAMS: InitStateVar=0.302408
X3885   39   271  memristor PARAMS: InitStateVar=0.171978
X3985   40   271  memristor PARAMS: InitStateVar=0.330986
X4085   41   271  memristor PARAMS: InitStateVar=0.212797
X4185   42   271  memristor PARAMS: InitStateVar=0.327612
X4285   43   271  memristor PARAMS: InitStateVar=0.395617
X4385   44   271  memristor PARAMS: InitStateVar=0.203696
X4485   45   271  memristor PARAMS: InitStateVar=0.386032
X4585   46   271  memristor PARAMS: InitStateVar=0.201624
X4685   47   271  memristor PARAMS: InitStateVar=0.292507
X4785   48   271  memristor PARAMS: InitStateVar=0.166031
X4885   49   271  memristor PARAMS: InitStateVar=0.492727
X4985   50   271  memristor PARAMS: InitStateVar=0.245566
X5085   51   271  memristor PARAMS: InitStateVar=0.246243
X5185   52   271  memristor PARAMS: InitStateVar=0.332552
X5285   53   271  memristor PARAMS: InitStateVar=0.350536
X5385   54   271  memristor PARAMS: InitStateVar=0.335826
X5485   55   271  memristor PARAMS: InitStateVar=0.326397
X5585   56   271  memristor PARAMS: InitStateVar=0.213726
X5685   57   271  memristor PARAMS: InitStateVar=0.465094
X5785   58   271  memristor PARAMS: InitStateVar=0.398908
X5885   59   271  memristor PARAMS: InitStateVar=0.195217
X5985   60   271  memristor PARAMS: InitStateVar=0.441848
X6085   61   271  memristor PARAMS: InitStateVar=0.287395
X6185   62   271  memristor PARAMS: InitStateVar=0.266391
X6285   63   271  memristor PARAMS: InitStateVar=0.346966
X6385   64   271  memristor PARAMS: InitStateVar=0.380972
X6485   65   271  memristor PARAMS: InitStateVar=0.282903
X6585   66   271  memristor PARAMS: InitStateVar=0.466212
X6685   67   271  memristor PARAMS: InitStateVar=0.224642
X6785   68   271  memristor PARAMS: InitStateVar=0.288863
X6885   69   271  memristor PARAMS: InitStateVar=0.194042
X6985   70   271  memristor PARAMS: InitStateVar=0.252581
X7085   71   271  memristor PARAMS: InitStateVar=0.223037
X7185   72   271  memristor PARAMS: InitStateVar=0.315616
X7285   73   271  memristor PARAMS: InitStateVar=0.377625
X7385   74   271  memristor PARAMS: InitStateVar=0.290052
X7485   75   271  memristor PARAMS: InitStateVar=0.332376
X7585   76   271  memristor PARAMS: InitStateVar=0.276734
X7685   77   271  memristor PARAMS: InitStateVar=0.316706
X7785   78   271  memristor PARAMS: InitStateVar=0.186482
X7885   79   271  memristor PARAMS: InitStateVar=0.21061
X7985   80   271  memristor PARAMS: InitStateVar=0.268135
X8085   81   271  memristor PARAMS: InitStateVar=0.153865
X8185   82   271  memristor PARAMS: InitStateVar=0.284681
X8285   83   271  memristor PARAMS: InitStateVar=0.228893
X8385   84   271  memristor PARAMS: InitStateVar=0.265147
X8485   85   271  memristor PARAMS: InitStateVar=0.375856
X8585   86   271  memristor PARAMS: InitStateVar=0.288151
X8685   87   271  memristor PARAMS: InitStateVar=0.264427
X8785   88   271  memristor PARAMS: InitStateVar=0.326832
X8885   89   271  memristor PARAMS: InitStateVar=0.0927074
X8985   90   271  memristor PARAMS: InitStateVar=0.33345
X9085   91   271  memristor PARAMS: InitStateVar=0.34145
X9185   92   271  memristor PARAMS: InitStateVar=0.405433
X9285   93   271  memristor PARAMS: InitStateVar=0.348091
X9385   94   271  memristor PARAMS: InitStateVar=0.17179
X9485   95   271  memristor PARAMS: InitStateVar=0.205996
X9585   96   271  memristor PARAMS: InitStateVar=0.204546
X9685   97   271  memristor PARAMS: InitStateVar=0.339154
X9785   98   271  memristor PARAMS: InitStateVar=0.330297
X9885   99   271  memristor PARAMS: InitStateVar=0.380762
X9985   100  271  memristor PARAMS: InitStateVar=0.0498945
Xo86    271  272  OutputModule PARAMS: Rval=100
*------------------- Column 87 -------------------------------------------------
X86     1    273  memristor PARAMS: InitStateVar=0.249645
X186    2    273  memristor PARAMS: InitStateVar=0.329775
X286    3    273  memristor PARAMS: InitStateVar=0.317071
X386    4    273  memristor PARAMS: InitStateVar=0.361913
X486    5    273  memristor PARAMS: InitStateVar=0.317618
X586    6    273  memristor PARAMS: InitStateVar=0.172054
X686    7    273  memristor PARAMS: InitStateVar=0.26699
X786    8    273  memristor PARAMS: InitStateVar=0.245023
X886    9    273  memristor PARAMS: InitStateVar=0.301189
X986    10   273  memristor PARAMS: InitStateVar=0.403033
X1086   11   273  memristor PARAMS: InitStateVar=0.284602
X1186   12   273  memristor PARAMS: InitStateVar=0.234956
X1286   13   273  memristor PARAMS: InitStateVar=0.337832
X1386   14   273  memristor PARAMS: InitStateVar=0.374229
X1486   15   273  memristor PARAMS: InitStateVar=0.230504
X1586   16   273  memristor PARAMS: InitStateVar=0.375775
X1686   17   273  memristor PARAMS: InitStateVar=0.34545
X1786   18   273  memristor PARAMS: InitStateVar=0.457324
X1886   19   273  memristor PARAMS: InitStateVar=0.303475
X1986   20   273  memristor PARAMS: InitStateVar=0.204724
X2086   21   273  memristor PARAMS: InitStateVar=0.443082
X2186   22   273  memristor PARAMS: InitStateVar=0.268617
X2286   23   273  memristor PARAMS: InitStateVar=0.3833
X2386   24   273  memristor PARAMS: InitStateVar=0.315528
X2486   25   273  memristor PARAMS: InitStateVar=0.419827
X2586   26   273  memristor PARAMS: InitStateVar=0.267303
X2686   27   273  memristor PARAMS: InitStateVar=0.339548
X2786   28   273  memristor PARAMS: InitStateVar=0.474565
X2886   29   273  memristor PARAMS: InitStateVar=0.221504
X2986   30   273  memristor PARAMS: InitStateVar=0.4861
X3086   31   273  memristor PARAMS: InitStateVar=0.162463
X3186   32   273  memristor PARAMS: InitStateVar=0.35478
X3286   33   273  memristor PARAMS: InitStateVar=0.248812
X3386   34   273  memristor PARAMS: InitStateVar=0.289331
X3486   35   273  memristor PARAMS: InitStateVar=0.391128
X3586   36   273  memristor PARAMS: InitStateVar=0.180387
X3686   37   273  memristor PARAMS: InitStateVar=0.42656
X3786   38   273  memristor PARAMS: InitStateVar=0.344256
X3886   39   273  memristor PARAMS: InitStateVar=0.179148
X3986   40   273  memristor PARAMS: InitStateVar=0.223067
X4086   41   273  memristor PARAMS: InitStateVar=0.25374
X4186   42   273  memristor PARAMS: InitStateVar=0.390529
X4286   43   273  memristor PARAMS: InitStateVar=0.356649
X4386   44   273  memristor PARAMS: InitStateVar=0.358048
X4486   45   273  memristor PARAMS: InitStateVar=0.263869
X4586   46   273  memristor PARAMS: InitStateVar=0.387947
X4686   47   273  memristor PARAMS: InitStateVar=0.26679
X4786   48   273  memristor PARAMS: InitStateVar=0.194332
X4886   49   273  memristor PARAMS: InitStateVar=0.293409
X4986   50   273  memristor PARAMS: InitStateVar=0.43829
X5086   51   273  memristor PARAMS: InitStateVar=0.158846
X5186   52   273  memristor PARAMS: InitStateVar=0.256092
X5286   53   273  memristor PARAMS: InitStateVar=0.255228
X5386   54   273  memristor PARAMS: InitStateVar=0.320867
X5486   55   273  memristor PARAMS: InitStateVar=0.179405
X5586   56   273  memristor PARAMS: InitStateVar=0.190715
X5686   57   273  memristor PARAMS: InitStateVar=0.306307
X5786   58   273  memristor PARAMS: InitStateVar=0.324684
X5886   59   273  memristor PARAMS: InitStateVar=0.250104
X5986   60   273  memristor PARAMS: InitStateVar=0.309619
X6086   61   273  memristor PARAMS: InitStateVar=0.328574
X6186   62   273  memristor PARAMS: InitStateVar=0.456033
X6286   63   273  memristor PARAMS: InitStateVar=0.398177
X6386   64   273  memristor PARAMS: InitStateVar=0.252053
X6486   65   273  memristor PARAMS: InitStateVar=0.263055
X6586   66   273  memristor PARAMS: InitStateVar=0.396079
X6686   67   273  memristor PARAMS: InitStateVar=0.471054
X6786   68   273  memristor PARAMS: InitStateVar=0.366324
X6886   69   273  memristor PARAMS: InitStateVar=0.335544
X6986   70   273  memristor PARAMS: InitStateVar=0.226038
X7086   71   273  memristor PARAMS: InitStateVar=0.417557
X7186   72   273  memristor PARAMS: InitStateVar=0.543287
X7286   73   273  memristor PARAMS: InitStateVar=0.232509
X7386   74   273  memristor PARAMS: InitStateVar=0.253785
X7486   75   273  memristor PARAMS: InitStateVar=0.133932
X7586   76   273  memristor PARAMS: InitStateVar=0.168714
X7686   77   273  memristor PARAMS: InitStateVar=0.338352
X7786   78   273  memristor PARAMS: InitStateVar=0.340917
X7886   79   273  memristor PARAMS: InitStateVar=0.333151
X7986   80   273  memristor PARAMS: InitStateVar=0.17146
X8086   81   273  memristor PARAMS: InitStateVar=0.30964
X8186   82   273  memristor PARAMS: InitStateVar=0.177051
X8286   83   273  memristor PARAMS: InitStateVar=0.491752
X8386   84   273  memristor PARAMS: InitStateVar=0.227384
X8486   85   273  memristor PARAMS: InitStateVar=0.140802
X8586   86   273  memristor PARAMS: InitStateVar=0.438801
X8686   87   273  memristor PARAMS: InitStateVar=0.370991
X8786   88   273  memristor PARAMS: InitStateVar=0.295522
X8886   89   273  memristor PARAMS: InitStateVar=0.18761
X8986   90   273  memristor PARAMS: InitStateVar=0.373441
X9086   91   273  memristor PARAMS: InitStateVar=0.445913
X9186   92   273  memristor PARAMS: InitStateVar=0.227774
X9286   93   273  memristor PARAMS: InitStateVar=0.414333
X9386   94   273  memristor PARAMS: InitStateVar=0.207497
X9486   95   273  memristor PARAMS: InitStateVar=0.37888
X9586   96   273  memristor PARAMS: InitStateVar=0.428715
X9686   97   273  memristor PARAMS: InitStateVar=0.250214
X9786   98   273  memristor PARAMS: InitStateVar=0.154092
X9886   99   273  memristor PARAMS: InitStateVar=0.164194
X9986   100  273  memristor PARAMS: InitStateVar=0.260392
Xo87    273  274  OutputModule PARAMS: Rval=100
*------------------- Column 88 -------------------------------------------------
X87     1    275  memristor PARAMS: InitStateVar=0.276671
X187    2    275  memristor PARAMS: InitStateVar=0.234932
X287    3    275  memristor PARAMS: InitStateVar=0.264932
X387    4    275  memristor PARAMS: InitStateVar=0.38129
X487    5    275  memristor PARAMS: InitStateVar=0.404196
X587    6    275  memristor PARAMS: InitStateVar=0.416237
X687    7    275  memristor PARAMS: InitStateVar=0.372659
X787    8    275  memristor PARAMS: InitStateVar=0.314346
X887    9    275  memristor PARAMS: InitStateVar=0.435833
X987    10   275  memristor PARAMS: InitStateVar=0.166878
X1087   11   275  memristor PARAMS: InitStateVar=0.143405
X1187   12   275  memristor PARAMS: InitStateVar=0.240917
X1287   13   275  memristor PARAMS: InitStateVar=0.197201
X1387   14   275  memristor PARAMS: InitStateVar=0.560948
X1487   15   275  memristor PARAMS: InitStateVar=0.335923
X1587   16   275  memristor PARAMS: InitStateVar=0.463183
X1687   17   275  memristor PARAMS: InitStateVar=0.230799
X1787   18   275  memristor PARAMS: InitStateVar=0.148303
X1887   19   275  memristor PARAMS: InitStateVar=0.404565
X1987   20   275  memristor PARAMS: InitStateVar=0.339659
X2087   21   275  memristor PARAMS: InitStateVar=0.363642
X2187   22   275  memristor PARAMS: InitStateVar=0.327246
X2287   23   275  memristor PARAMS: InitStateVar=0.300212
X2387   24   275  memristor PARAMS: InitStateVar=0.382933
X2487   25   275  memristor PARAMS: InitStateVar=0.504248
X2587   26   275  memristor PARAMS: InitStateVar=0.28798
X2687   27   275  memristor PARAMS: InitStateVar=0.385317
X2787   28   275  memristor PARAMS: InitStateVar=0.463097
X2887   29   275  memristor PARAMS: InitStateVar=0.394327
X2987   30   275  memristor PARAMS: InitStateVar=0.110365
X3087   31   275  memristor PARAMS: InitStateVar=0.198855
X3187   32   275  memristor PARAMS: InitStateVar=0.386114
X3287   33   275  memristor PARAMS: InitStateVar=0.16619
X3387   34   275  memristor PARAMS: InitStateVar=0.318872
X3487   35   275  memristor PARAMS: InitStateVar=0.220833
X3587   36   275  memristor PARAMS: InitStateVar=0.254688
X3687   37   275  memristor PARAMS: InitStateVar=0.241743
X3787   38   275  memristor PARAMS: InitStateVar=0.30723
X3887   39   275  memristor PARAMS: InitStateVar=0.235311
X3987   40   275  memristor PARAMS: InitStateVar=0.2887
X4087   41   275  memristor PARAMS: InitStateVar=0.573436
X4187   42   275  memristor PARAMS: InitStateVar=0.300382
X4287   43   275  memristor PARAMS: InitStateVar=0.544276
X4387   44   275  memristor PARAMS: InitStateVar=0.365216
X4487   45   275  memristor PARAMS: InitStateVar=0.257244
X4587   46   275  memristor PARAMS: InitStateVar=0.446112
X4687   47   275  memristor PARAMS: InitStateVar=0.400804
X4787   48   275  memristor PARAMS: InitStateVar=0.305509
X4887   49   275  memristor PARAMS: InitStateVar=0.229409
X4987   50   275  memristor PARAMS: InitStateVar=0.258297
X5087   51   275  memristor PARAMS: InitStateVar=0.471267
X5187   52   275  memristor PARAMS: InitStateVar=0.258588
X5287   53   275  memristor PARAMS: InitStateVar=0.361986
X5387   54   275  memristor PARAMS: InitStateVar=0.282096
X5487   55   275  memristor PARAMS: InitStateVar=0.40321
X5587   56   275  memristor PARAMS: InitStateVar=0.299323
X5687   57   275  memristor PARAMS: InitStateVar=0.418604
X5787   58   275  memristor PARAMS: InitStateVar=0.128998
X5887   59   275  memristor PARAMS: InitStateVar=0.269541
X5987   60   275  memristor PARAMS: InitStateVar=0.486614
X6087   61   275  memristor PARAMS: InitStateVar=0.24562
X6187   62   275  memristor PARAMS: InitStateVar=0.447149
X6287   63   275  memristor PARAMS: InitStateVar=0.219619
X6387   64   275  memristor PARAMS: InitStateVar=0.224274
X6487   65   275  memristor PARAMS: InitStateVar=0.259406
X6587   66   275  memristor PARAMS: InitStateVar=0.497461
X6687   67   275  memristor PARAMS: InitStateVar=0.211396
X6787   68   275  memristor PARAMS: InitStateVar=0.337427
X6887   69   275  memristor PARAMS: InitStateVar=0.137914
X6987   70   275  memristor PARAMS: InitStateVar=0.303306
X7087   71   275  memristor PARAMS: InitStateVar=0.481023
X7187   72   275  memristor PARAMS: InitStateVar=0.428487
X7287   73   275  memristor PARAMS: InitStateVar=0.423649
X7387   74   275  memristor PARAMS: InitStateVar=0.270223
X7487   75   275  memristor PARAMS: InitStateVar=0.109139
X7587   76   275  memristor PARAMS: InitStateVar=0.109304
X7687   77   275  memristor PARAMS: InitStateVar=0.174961
X7787   78   275  memristor PARAMS: InitStateVar=0.30573
X7887   79   275  memristor PARAMS: InitStateVar=0.427558
X7987   80   275  memristor PARAMS: InitStateVar=0.140252
X8087   81   275  memristor PARAMS: InitStateVar=0.302832
X8187   82   275  memristor PARAMS: InitStateVar=0.140757
X8287   83   275  memristor PARAMS: InitStateVar=0.332394
X8387   84   275  memristor PARAMS: InitStateVar=0.378443
X8487   85   275  memristor PARAMS: InitStateVar=0.415451
X8587   86   275  memristor PARAMS: InitStateVar=0.381729
X8687   87   275  memristor PARAMS: InitStateVar=0.276121
X8787   88   275  memristor PARAMS: InitStateVar=0.27222
X8887   89   275  memristor PARAMS: InitStateVar=0.15995
X8987   90   275  memristor PARAMS: InitStateVar=0.189193
X9087   91   275  memristor PARAMS: InitStateVar=0.186364
X9187   92   275  memristor PARAMS: InitStateVar=0.142267
X9287   93   275  memristor PARAMS: InitStateVar=0.286987
X9387   94   275  memristor PARAMS: InitStateVar=0.33795
X9487   95   275  memristor PARAMS: InitStateVar=0.321447
X9587   96   275  memristor PARAMS: InitStateVar=0.332219
X9687   97   275  memristor PARAMS: InitStateVar=0.197434
X9787   98   275  memristor PARAMS: InitStateVar=0.304458
X9887   99   275  memristor PARAMS: InitStateVar=0.280062
X9987   100  275  memristor PARAMS: InitStateVar=0.302694
Xo88    275  276  OutputModule PARAMS: Rval=100
*------------------- Column 89 -------------------------------------------------
X88     1    277  memristor PARAMS: InitStateVar=0.539738
X188    2    277  memristor PARAMS: InitStateVar=0.343209
X288    3    277  memristor PARAMS: InitStateVar=0.243406
X388    4    277  memristor PARAMS: InitStateVar=0.232434
X488    5    277  memristor PARAMS: InitStateVar=0.386453
X588    6    277  memristor PARAMS: InitStateVar=0.252342
X688    7    277  memristor PARAMS: InitStateVar=0.242092
X788    8    277  memristor PARAMS: InitStateVar=0.4341
X888    9    277  memristor PARAMS: InitStateVar=0.207765
X988    10   277  memristor PARAMS: InitStateVar=0.312685
X1088   11   277  memristor PARAMS: InitStateVar=0.403314
X1188   12   277  memristor PARAMS: InitStateVar=0.221928
X1288   13   277  memristor PARAMS: InitStateVar=0.325022
X1388   14   277  memristor PARAMS: InitStateVar=0.250695
X1488   15   277  memristor PARAMS: InitStateVar=0.452442
X1588   16   277  memristor PARAMS: InitStateVar=0.148278
X1688   17   277  memristor PARAMS: InitStateVar=0.127269
X1788   18   277  memristor PARAMS: InitStateVar=0.327793
X1888   19   277  memristor PARAMS: InitStateVar=0.286438
X1988   20   277  memristor PARAMS: InitStateVar=0.278557
X2088   21   277  memristor PARAMS: InitStateVar=0.266619
X2188   22   277  memristor PARAMS: InitStateVar=0.221242
X2288   23   277  memristor PARAMS: InitStateVar=0.295383
X2388   24   277  memristor PARAMS: InitStateVar=0.360159
X2488   25   277  memristor PARAMS: InitStateVar=0.207859
X2588   26   277  memristor PARAMS: InitStateVar=0.310124
X2688   27   277  memristor PARAMS: InitStateVar=0.234845
X2788   28   277  memristor PARAMS: InitStateVar=0.420655
X2888   29   277  memristor PARAMS: InitStateVar=0.240131
X2988   30   277  memristor PARAMS: InitStateVar=0.134307
X3088   31   277  memristor PARAMS: InitStateVar=0.324441
X3188   32   277  memristor PARAMS: InitStateVar=0.384712
X3288   33   277  memristor PARAMS: InitStateVar=0.366482
X3388   34   277  memristor PARAMS: InitStateVar=0.19898
X3488   35   277  memristor PARAMS: InitStateVar=0.341657
X3588   36   277  memristor PARAMS: InitStateVar=0.322866
X3688   37   277  memristor PARAMS: InitStateVar=0.335021
X3788   38   277  memristor PARAMS: InitStateVar=0.120723
X3888   39   277  memristor PARAMS: InitStateVar=0.394276
X3988   40   277  memristor PARAMS: InitStateVar=0.447011
X4088   41   277  memristor PARAMS: InitStateVar=0.370904
X4188   42   277  memristor PARAMS: InitStateVar=0.209019
X4288   43   277  memristor PARAMS: InitStateVar=0.328641
X4388   44   277  memristor PARAMS: InitStateVar=0.45078
X4488   45   277  memristor PARAMS: InitStateVar=0.189126
X4588   46   277  memristor PARAMS: InitStateVar=0.293121
X4688   47   277  memristor PARAMS: InitStateVar=0.318394
X4788   48   277  memristor PARAMS: InitStateVar=0.519479
X4888   49   277  memristor PARAMS: InitStateVar=0.249646
X4988   50   277  memristor PARAMS: InitStateVar=0.330896
X5088   51   277  memristor PARAMS: InitStateVar=0.592489
X5188   52   277  memristor PARAMS: InitStateVar=0.48606
X5288   53   277  memristor PARAMS: InitStateVar=0.187432
X5388   54   277  memristor PARAMS: InitStateVar=0.340972
X5488   55   277  memristor PARAMS: InitStateVar=0.412158
X5588   56   277  memristor PARAMS: InitStateVar=0.17969
X5688   57   277  memristor PARAMS: InitStateVar=0.19788
X5788   58   277  memristor PARAMS: InitStateVar=0.437284
X5888   59   277  memristor PARAMS: InitStateVar=0.341695
X5988   60   277  memristor PARAMS: InitStateVar=0.372536
X6088   61   277  memristor PARAMS: InitStateVar=0.21681
X6188   62   277  memristor PARAMS: InitStateVar=0.372802
X6288   63   277  memristor PARAMS: InitStateVar=0.198696
X6388   64   277  memristor PARAMS: InitStateVar=0.36548
X6488   65   277  memristor PARAMS: InitStateVar=0.0949091
X6588   66   277  memristor PARAMS: InitStateVar=0.199038
X6688   67   277  memristor PARAMS: InitStateVar=0.308404
X6788   68   277  memristor PARAMS: InitStateVar=0.384945
X6888   69   277  memristor PARAMS: InitStateVar=0.350962
X6988   70   277  memristor PARAMS: InitStateVar=0.313855
X7088   71   277  memristor PARAMS: InitStateVar=0.404952
X7188   72   277  memristor PARAMS: InitStateVar=0.263542
X7288   73   277  memristor PARAMS: InitStateVar=0.203341
X7388   74   277  memristor PARAMS: InitStateVar=0.552669
X7488   75   277  memristor PARAMS: InitStateVar=0.31648
X7588   76   277  memristor PARAMS: InitStateVar=0.219516
X7688   77   277  memristor PARAMS: InitStateVar=0.352382
X7788   78   277  memristor PARAMS: InitStateVar=0.291719
X7888   79   277  memristor PARAMS: InitStateVar=0.307677
X7988   80   277  memristor PARAMS: InitStateVar=0.369027
X8088   81   277  memristor PARAMS: InitStateVar=0.419877
X8188   82   277  memristor PARAMS: InitStateVar=0.316823
X8288   83   277  memristor PARAMS: InitStateVar=0.293471
X8388   84   277  memristor PARAMS: InitStateVar=0.421303
X8488   85   277  memristor PARAMS: InitStateVar=0.088619
X8588   86   277  memristor PARAMS: InitStateVar=0.399072
X8688   87   277  memristor PARAMS: InitStateVar=0.412932
X8788   88   277  memristor PARAMS: InitStateVar=0.135188
X8888   89   277  memristor PARAMS: InitStateVar=0.310637
X8988   90   277  memristor PARAMS: InitStateVar=0.460367
X9088   91   277  memristor PARAMS: InitStateVar=0.397624
X9188   92   277  memristor PARAMS: InitStateVar=0.391056
X9288   93   277  memristor PARAMS: InitStateVar=0.229892
X9388   94   277  memristor PARAMS: InitStateVar=0.204223
X9488   95   277  memristor PARAMS: InitStateVar=0.243384
X9588   96   277  memristor PARAMS: InitStateVar=0.391386
X9688   97   277  memristor PARAMS: InitStateVar=0.387761
X9788   98   277  memristor PARAMS: InitStateVar=0.241855
X9888   99   277  memristor PARAMS: InitStateVar=0.255555
X9988   100  277  memristor PARAMS: InitStateVar=0.337433
Xo89    277  278  OutputModule PARAMS: Rval=100
*------------------- Column 90 -------------------------------------------------
X89     1    279  memristor PARAMS: InitStateVar=0.119093
X189    2    279  memristor PARAMS: InitStateVar=0.339053
X289    3    279  memristor PARAMS: InitStateVar=0.292345
X389    4    279  memristor PARAMS: InitStateVar=0.311801
X489    5    279  memristor PARAMS: InitStateVar=0.229082
X589    6    279  memristor PARAMS: InitStateVar=0.198568
X689    7    279  memristor PARAMS: InitStateVar=0.301293
X789    8    279  memristor PARAMS: InitStateVar=0.31789
X889    9    279  memristor PARAMS: InitStateVar=0.2512
X989    10   279  memristor PARAMS: InitStateVar=0.352514
X1089   11   279  memristor PARAMS: InitStateVar=0.221181
X1189   12   279  memristor PARAMS: InitStateVar=0.389547
X1289   13   279  memristor PARAMS: InitStateVar=0.220538
X1389   14   279  memristor PARAMS: InitStateVar=0.350416
X1489   15   279  memristor PARAMS: InitStateVar=0.360458
X1589   16   279  memristor PARAMS: InitStateVar=0.190824
X1689   17   279  memristor PARAMS: InitStateVar=0.43635
X1789   18   279  memristor PARAMS: InitStateVar=0.32764
X1889   19   279  memristor PARAMS: InitStateVar=0.231072
X1989   20   279  memristor PARAMS: InitStateVar=0.304401
X2089   21   279  memristor PARAMS: InitStateVar=0.204685
X2189   22   279  memristor PARAMS: InitStateVar=0.294467
X2289   23   279  memristor PARAMS: InitStateVar=0.194148
X2389   24   279  memristor PARAMS: InitStateVar=0.37525
X2489   25   279  memristor PARAMS: InitStateVar=0.254286
X2589   26   279  memristor PARAMS: InitStateVar=0.39997
X2689   27   279  memristor PARAMS: InitStateVar=0.469551
X2789   28   279  memristor PARAMS: InitStateVar=0.350349
X2889   29   279  memristor PARAMS: InitStateVar=0.232869
X2989   30   279  memristor PARAMS: InitStateVar=0.287655
X3089   31   279  memristor PARAMS: InitStateVar=0.267091
X3189   32   279  memristor PARAMS: InitStateVar=0.405008
X3289   33   279  memristor PARAMS: InitStateVar=0.156054
X3389   34   279  memristor PARAMS: InitStateVar=0.358301
X3489   35   279  memristor PARAMS: InitStateVar=0.217704
X3589   36   279  memristor PARAMS: InitStateVar=0.339953
X3689   37   279  memristor PARAMS: InitStateVar=0.246397
X3789   38   279  memristor PARAMS: InitStateVar=0.175083
X3889   39   279  memristor PARAMS: InitStateVar=0.236317
X3989   40   279  memristor PARAMS: InitStateVar=0.30863
X4089   41   279  memristor PARAMS: InitStateVar=0.318008
X4189   42   279  memristor PARAMS: InitStateVar=0.32934
X4289   43   279  memristor PARAMS: InitStateVar=0.263587
X4389   44   279  memristor PARAMS: InitStateVar=0.237351
X4489   45   279  memristor PARAMS: InitStateVar=0.283234
X4589   46   279  memristor PARAMS: InitStateVar=0.143342
X4689   47   279  memristor PARAMS: InitStateVar=0.258516
X4789   48   279  memristor PARAMS: InitStateVar=0.216657
X4889   49   279  memristor PARAMS: InitStateVar=0.334511
X4989   50   279  memristor PARAMS: InitStateVar=0.300653
X5089   51   279  memristor PARAMS: InitStateVar=0.360738
X5189   52   279  memristor PARAMS: InitStateVar=0.292831
X5289   53   279  memristor PARAMS: InitStateVar=0.272609
X5389   54   279  memristor PARAMS: InitStateVar=0.406414
X5489   55   279  memristor PARAMS: InitStateVar=0.283046
X5589   56   279  memristor PARAMS: InitStateVar=0.330002
X5689   57   279  memristor PARAMS: InitStateVar=0.491797
X5789   58   279  memristor PARAMS: InitStateVar=0.391302
X5889   59   279  memristor PARAMS: InitStateVar=0.464628
X5989   60   279  memristor PARAMS: InitStateVar=0.371639
X6089   61   279  memristor PARAMS: InitStateVar=0.404202
X6189   62   279  memristor PARAMS: InitStateVar=0.2533
X6289   63   279  memristor PARAMS: InitStateVar=0.192415
X6389   64   279  memristor PARAMS: InitStateVar=0.282134
X6489   65   279  memristor PARAMS: InitStateVar=0.311758
X6589   66   279  memristor PARAMS: InitStateVar=0.348632
X6689   67   279  memristor PARAMS: InitStateVar=0.252291
X6789   68   279  memristor PARAMS: InitStateVar=0.376693
X6889   69   279  memristor PARAMS: InitStateVar=0.286558
X6989   70   279  memristor PARAMS: InitStateVar=0.349043
X7089   71   279  memristor PARAMS: InitStateVar=0.0494341
X7189   72   279  memristor PARAMS: InitStateVar=0.294438
X7289   73   279  memristor PARAMS: InitStateVar=0.372629
X7389   74   279  memristor PARAMS: InitStateVar=0.337475
X7489   75   279  memristor PARAMS: InitStateVar=0.174738
X7589   76   279  memristor PARAMS: InitStateVar=0.163823
X7689   77   279  memristor PARAMS: InitStateVar=0.283904
X7789   78   279  memristor PARAMS: InitStateVar=0.384389
X7889   79   279  memristor PARAMS: InitStateVar=0.26534
X7989   80   279  memristor PARAMS: InitStateVar=0.253656
X8089   81   279  memristor PARAMS: InitStateVar=0.129224
X8189   82   279  memristor PARAMS: InitStateVar=0.370406
X8289   83   279  memristor PARAMS: InitStateVar=0.362356
X8389   84   279  memristor PARAMS: InitStateVar=0.462119
X8489   85   279  memristor PARAMS: InitStateVar=0.443625
X8589   86   279  memristor PARAMS: InitStateVar=0.275377
X8689   87   279  memristor PARAMS: InitStateVar=0.409715
X8789   88   279  memristor PARAMS: InitStateVar=0.131125
X8889   89   279  memristor PARAMS: InitStateVar=0.506371
X8989   90   279  memristor PARAMS: InitStateVar=0.305156
X9089   91   279  memristor PARAMS: InitStateVar=0.33839
X9189   92   279  memristor PARAMS: InitStateVar=0.356703
X9289   93   279  memristor PARAMS: InitStateVar=0.389063
X9389   94   279  memristor PARAMS: InitStateVar=0.190868
X9489   95   279  memristor PARAMS: InitStateVar=0.0772428
X9589   96   279  memristor PARAMS: InitStateVar=0.364597
X9689   97   279  memristor PARAMS: InitStateVar=0.327601
X9789   98   279  memristor PARAMS: InitStateVar=0.253348
X9889   99   279  memristor PARAMS: InitStateVar=0.366136
X9989   100  279  memristor PARAMS: InitStateVar=0.381084
Xo90    279  280  OutputModule PARAMS: Rval=100
*------------------- Column 91 -------------------------------------------------
X90     1    281  memristor PARAMS: InitStateVar=0.310275
X190    2    281  memristor PARAMS: InitStateVar=0.301982
X290    3    281  memristor PARAMS: InitStateVar=0.193731
X390    4    281  memristor PARAMS: InitStateVar=0.294857
X490    5    281  memristor PARAMS: InitStateVar=0.216398
X590    6    281  memristor PARAMS: InitStateVar=0.310353
X690    7    281  memristor PARAMS: InitStateVar=0.4245
X790    8    281  memristor PARAMS: InitStateVar=0.366826
X890    9    281  memristor PARAMS: InitStateVar=0.319274
X990    10   281  memristor PARAMS: InitStateVar=0.177304
X1090   11   281  memristor PARAMS: InitStateVar=0.388096
X1190   12   281  memristor PARAMS: InitStateVar=0.406748
X1290   13   281  memristor PARAMS: InitStateVar=0.448893
X1390   14   281  memristor PARAMS: InitStateVar=0.198234
X1490   15   281  memristor PARAMS: InitStateVar=0.245705
X1590   16   281  memristor PARAMS: InitStateVar=0.417052
X1690   17   281  memristor PARAMS: InitStateVar=0.218348
X1790   18   281  memristor PARAMS: InitStateVar=0.247924
X1890   19   281  memristor PARAMS: InitStateVar=0.276937
X1990   20   281  memristor PARAMS: InitStateVar=0.279765
X2090   21   281  memristor PARAMS: InitStateVar=0.308347
X2190   22   281  memristor PARAMS: InitStateVar=0.20235
X2290   23   281  memristor PARAMS: InitStateVar=0.207606
X2390   24   281  memristor PARAMS: InitStateVar=0.25952
X2490   25   281  memristor PARAMS: InitStateVar=0.440864
X2590   26   281  memristor PARAMS: InitStateVar=0.40412
X2690   27   281  memristor PARAMS: InitStateVar=0.352744
X2790   28   281  memristor PARAMS: InitStateVar=0.253111
X2890   29   281  memristor PARAMS: InitStateVar=0.351341
X2990   30   281  memristor PARAMS: InitStateVar=0.317293
X3090   31   281  memristor PARAMS: InitStateVar=0.094466
X3190   32   281  memristor PARAMS: InitStateVar=0.264097
X3290   33   281  memristor PARAMS: InitStateVar=0.374563
X3390   34   281  memristor PARAMS: InitStateVar=0.368808
X3490   35   281  memristor PARAMS: InitStateVar=0.460274
X3590   36   281  memristor PARAMS: InitStateVar=0.14168
X3690   37   281  memristor PARAMS: InitStateVar=0.428091
X3790   38   281  memristor PARAMS: InitStateVar=0.283369
X3890   39   281  memristor PARAMS: InitStateVar=0.251657
X3990   40   281  memristor PARAMS: InitStateVar=0.271057
X4090   41   281  memristor PARAMS: InitStateVar=0.316791
X4190   42   281  memristor PARAMS: InitStateVar=0.309026
X4290   43   281  memristor PARAMS: InitStateVar=0.1971
X4390   44   281  memristor PARAMS: InitStateVar=0.272338
X4490   45   281  memristor PARAMS: InitStateVar=0.351103
X4590   46   281  memristor PARAMS: InitStateVar=0.311438
X4690   47   281  memristor PARAMS: InitStateVar=0.203964
X4790   48   281  memristor PARAMS: InitStateVar=0.165555
X4890   49   281  memristor PARAMS: InitStateVar=0.238529
X4990   50   281  memristor PARAMS: InitStateVar=0.238389
X5090   51   281  memristor PARAMS: InitStateVar=0.243929
X5190   52   281  memristor PARAMS: InitStateVar=0.0813089
X5290   53   281  memristor PARAMS: InitStateVar=0.317293
X5390   54   281  memristor PARAMS: InitStateVar=0.302657
X5490   55   281  memristor PARAMS: InitStateVar=0.258924
X5590   56   281  memristor PARAMS: InitStateVar=0.39013
X5690   57   281  memristor PARAMS: InitStateVar=0.301313
X5790   58   281  memristor PARAMS: InitStateVar=0.334503
X5890   59   281  memristor PARAMS: InitStateVar=0.389764
X5990   60   281  memristor PARAMS: InitStateVar=0.212618
X6090   61   281  memristor PARAMS: InitStateVar=0.207244
X6190   62   281  memristor PARAMS: InitStateVar=0.309368
X6290   63   281  memristor PARAMS: InitStateVar=0.106749
X6390   64   281  memristor PARAMS: InitStateVar=0.0989719
X6490   65   281  memristor PARAMS: InitStateVar=0.384577
X6590   66   281  memristor PARAMS: InitStateVar=0.116458
X6690   67   281  memristor PARAMS: InitStateVar=0.144542
X6790   68   281  memristor PARAMS: InitStateVar=0.123165
X6890   69   281  memristor PARAMS: InitStateVar=0.264141
X6990   70   281  memristor PARAMS: InitStateVar=0.359865
X7090   71   281  memristor PARAMS: InitStateVar=0.213045
X7190   72   281  memristor PARAMS: InitStateVar=0.380834
X7290   73   281  memristor PARAMS: InitStateVar=0.335177
X7390   74   281  memristor PARAMS: InitStateVar=0.330955
X7490   75   281  memristor PARAMS: InitStateVar=0.445469
X7590   76   281  memristor PARAMS: InitStateVar=0.26555
X7690   77   281  memristor PARAMS: InitStateVar=0.256768
X7790   78   281  memristor PARAMS: InitStateVar=0.147388
X7890   79   281  memristor PARAMS: InitStateVar=0.347187
X7990   80   281  memristor PARAMS: InitStateVar=0.223216
X8090   81   281  memristor PARAMS: InitStateVar=0.338155
X8190   82   281  memristor PARAMS: InitStateVar=0.342846
X8290   83   281  memristor PARAMS: InitStateVar=0.386523
X8390   84   281  memristor PARAMS: InitStateVar=0.325983
X8490   85   281  memristor PARAMS: InitStateVar=0.396487
X8590   86   281  memristor PARAMS: InitStateVar=0.320721
X8690   87   281  memristor PARAMS: InitStateVar=0.323714
X8790   88   281  memristor PARAMS: InitStateVar=0.295048
X8890   89   281  memristor PARAMS: InitStateVar=0.307632
X8990   90   281  memristor PARAMS: InitStateVar=0.215908
X9090   91   281  memristor PARAMS: InitStateVar=0.248974
X9190   92   281  memristor PARAMS: InitStateVar=0.192631
X9290   93   281  memristor PARAMS: InitStateVar=0.177095
X9390   94   281  memristor PARAMS: InitStateVar=0.244754
X9490   95   281  memristor PARAMS: InitStateVar=0.263912
X9590   96   281  memristor PARAMS: InitStateVar=0.111328
X9690   97   281  memristor PARAMS: InitStateVar=0.450161
X9790   98   281  memristor PARAMS: InitStateVar=0.184213
X9890   99   281  memristor PARAMS: InitStateVar=0.260435
X9990   100  281  memristor PARAMS: InitStateVar=0.36855
Xo91    281  282  OutputModule PARAMS: Rval=100
*------------------- Column 92 -------------------------------------------------
X91     1    283  memristor PARAMS: InitStateVar=0.476766
X191    2    283  memristor PARAMS: InitStateVar=0.373945
X291    3    283  memristor PARAMS: InitStateVar=0.167831
X391    4    283  memristor PARAMS: InitStateVar=0.307083
X491    5    283  memristor PARAMS: InitStateVar=0.247434
X591    6    283  memristor PARAMS: InitStateVar=0.268171
X691    7    283  memristor PARAMS: InitStateVar=0.255774
X791    8    283  memristor PARAMS: InitStateVar=0.265197
X891    9    283  memristor PARAMS: InitStateVar=0.267135
X991    10   283  memristor PARAMS: InitStateVar=0.164853
X1091   11   283  memristor PARAMS: InitStateVar=0.331251
X1191   12   283  memristor PARAMS: InitStateVar=0.0772246
X1291   13   283  memristor PARAMS: InitStateVar=0.101164
X1391   14   283  memristor PARAMS: InitStateVar=0.28639
X1491   15   283  memristor PARAMS: InitStateVar=0.276317
X1591   16   283  memristor PARAMS: InitStateVar=0.341926
X1691   17   283  memristor PARAMS: InitStateVar=0.26749
X1791   18   283  memristor PARAMS: InitStateVar=0.433534
X1891   19   283  memristor PARAMS: InitStateVar=0.240009
X1991   20   283  memristor PARAMS: InitStateVar=0.329309
X2091   21   283  memristor PARAMS: InitStateVar=0.33431
X2191   22   283  memristor PARAMS: InitStateVar=0.364856
X2291   23   283  memristor PARAMS: InitStateVar=0.440928
X2391   24   283  memristor PARAMS: InitStateVar=0.303782
X2491   25   283  memristor PARAMS: InitStateVar=0.449864
X2591   26   283  memristor PARAMS: InitStateVar=0.410695
X2691   27   283  memristor PARAMS: InitStateVar=0.275929
X2791   28   283  memristor PARAMS: InitStateVar=0.392714
X2891   29   283  memristor PARAMS: InitStateVar=0.320003
X2991   30   283  memristor PARAMS: InitStateVar=0.354052
X3091   31   283  memristor PARAMS: InitStateVar=0.42276
X3191   32   283  memristor PARAMS: InitStateVar=0.324931
X3291   33   283  memristor PARAMS: InitStateVar=0.116335
X3391   34   283  memristor PARAMS: InitStateVar=0.498307
X3491   35   283  memristor PARAMS: InitStateVar=0.342044
X3591   36   283  memristor PARAMS: InitStateVar=0.364925
X3691   37   283  memristor PARAMS: InitStateVar=0.313077
X3791   38   283  memristor PARAMS: InitStateVar=0.485375
X3891   39   283  memristor PARAMS: InitStateVar=0.279192
X3991   40   283  memristor PARAMS: InitStateVar=0.278036
X4091   41   283  memristor PARAMS: InitStateVar=0.263828
X4191   42   283  memristor PARAMS: InitStateVar=0.248826
X4291   43   283  memristor PARAMS: InitStateVar=0.367581
X4391   44   283  memristor PARAMS: InitStateVar=0.468249
X4491   45   283  memristor PARAMS: InitStateVar=0.274015
X4591   46   283  memristor PARAMS: InitStateVar=0.360704
X4691   47   283  memristor PARAMS: InitStateVar=0.239371
X4791   48   283  memristor PARAMS: InitStateVar=0.296603
X4891   49   283  memristor PARAMS: InitStateVar=0.380624
X4991   50   283  memristor PARAMS: InitStateVar=0.193495
X5091   51   283  memristor PARAMS: InitStateVar=0.297259
X5191   52   283  memristor PARAMS: InitStateVar=0.36936
X5291   53   283  memristor PARAMS: InitStateVar=0.242777
X5391   54   283  memristor PARAMS: InitStateVar=0.299685
X5491   55   283  memristor PARAMS: InitStateVar=0.51285
X5591   56   283  memristor PARAMS: InitStateVar=0.430476
X5691   57   283  memristor PARAMS: InitStateVar=0.174816
X5791   58   283  memristor PARAMS: InitStateVar=0.447147
X5891   59   283  memristor PARAMS: InitStateVar=0.215916
X5991   60   283  memristor PARAMS: InitStateVar=0.279029
X6091   61   283  memristor PARAMS: InitStateVar=0.238969
X6191   62   283  memristor PARAMS: InitStateVar=0.17677
X6291   63   283  memristor PARAMS: InitStateVar=0.25405
X6391   64   283  memristor PARAMS: InitStateVar=0.25177
X6491   65   283  memristor PARAMS: InitStateVar=0.460162
X6591   66   283  memristor PARAMS: InitStateVar=0.412221
X6691   67   283  memristor PARAMS: InitStateVar=0.356387
X6791   68   283  memristor PARAMS: InitStateVar=0.575975
X6891   69   283  memristor PARAMS: InitStateVar=0.464028
X6991   70   283  memristor PARAMS: InitStateVar=0.19372
X7091   71   283  memristor PARAMS: InitStateVar=0.348509
X7191   72   283  memristor PARAMS: InitStateVar=0.292563
X7291   73   283  memristor PARAMS: InitStateVar=0.335114
X7391   74   283  memristor PARAMS: InitStateVar=0.407509
X7491   75   283  memristor PARAMS: InitStateVar=0.247963
X7591   76   283  memristor PARAMS: InitStateVar=0.288525
X7691   77   283  memristor PARAMS: InitStateVar=0.186212
X7791   78   283  memristor PARAMS: InitStateVar=0.270651
X7891   79   283  memristor PARAMS: InitStateVar=0.330477
X7991   80   283  memristor PARAMS: InitStateVar=0.459651
X8091   81   283  memristor PARAMS: InitStateVar=0.322598
X8191   82   283  memristor PARAMS: InitStateVar=0.426425
X8291   83   283  memristor PARAMS: InitStateVar=0.117272
X8391   84   283  memristor PARAMS: InitStateVar=0.482795
X8491   85   283  memristor PARAMS: InitStateVar=0.245617
X8591   86   283  memristor PARAMS: InitStateVar=0.0339643
X8691   87   283  memristor PARAMS: InitStateVar=0.192161
X8791   88   283  memristor PARAMS: InitStateVar=0.143971
X8891   89   283  memristor PARAMS: InitStateVar=0.180979
X8991   90   283  memristor PARAMS: InitStateVar=0.380858
X9091   91   283  memristor PARAMS: InitStateVar=0.399663
X9191   92   283  memristor PARAMS: InitStateVar=0.110028
X9291   93   283  memristor PARAMS: InitStateVar=0.444592
X9391   94   283  memristor PARAMS: InitStateVar=0.10798
X9491   95   283  memristor PARAMS: InitStateVar=0.379921
X9591   96   283  memristor PARAMS: InitStateVar=0.275619
X9691   97   283  memristor PARAMS: InitStateVar=0.349536
X9791   98   283  memristor PARAMS: InitStateVar=0.119818
X9891   99   283  memristor PARAMS: InitStateVar=0.212317
X9991   100  283  memristor PARAMS: InitStateVar=0.325914
Xo92    283  284  OutputModule PARAMS: Rval=100
*------------------- Column 93 -------------------------------------------------
X92     1    285  memristor PARAMS: InitStateVar=0.342515
X192    2    285  memristor PARAMS: InitStateVar=0.365986
X292    3    285  memristor PARAMS: InitStateVar=0.269753
X392    4    285  memristor PARAMS: InitStateVar=0.32449
X492    5    285  memristor PARAMS: InitStateVar=0.249474
X592    6    285  memristor PARAMS: InitStateVar=0.319844
X692    7    285  memristor PARAMS: InitStateVar=0.401122
X792    8    285  memristor PARAMS: InitStateVar=0.389402
X892    9    285  memristor PARAMS: InitStateVar=0.207441
X992    10   285  memristor PARAMS: InitStateVar=0.306032
X1092   11   285  memristor PARAMS: InitStateVar=0.173305
X1192   12   285  memristor PARAMS: InitStateVar=0.395953
X1292   13   285  memristor PARAMS: InitStateVar=0.216446
X1392   14   285  memristor PARAMS: InitStateVar=0.224374
X1492   15   285  memristor PARAMS: InitStateVar=0.374141
X1592   16   285  memristor PARAMS: InitStateVar=0.356176
X1692   17   285  memristor PARAMS: InitStateVar=0.5393
X1792   18   285  memristor PARAMS: InitStateVar=0.199858
X1892   19   285  memristor PARAMS: InitStateVar=0.356048
X1992   20   285  memristor PARAMS: InitStateVar=0.263938
X2092   21   285  memristor PARAMS: InitStateVar=0.273973
X2192   22   285  memristor PARAMS: InitStateVar=0.445365
X2292   23   285  memristor PARAMS: InitStateVar=0.247159
X2392   24   285  memristor PARAMS: InitStateVar=0.463557
X2492   25   285  memristor PARAMS: InitStateVar=0.308567
X2592   26   285  memristor PARAMS: InitStateVar=0.347537
X2692   27   285  memristor PARAMS: InitStateVar=0.205106
X2792   28   285  memristor PARAMS: InitStateVar=0.212519
X2892   29   285  memristor PARAMS: InitStateVar=0.214027
X2992   30   285  memristor PARAMS: InitStateVar=0.27373
X3092   31   285  memristor PARAMS: InitStateVar=0.349569
X3192   32   285  memristor PARAMS: InitStateVar=0.367159
X3292   33   285  memristor PARAMS: InitStateVar=0.160335
X3392   34   285  memristor PARAMS: InitStateVar=0.393069
X3492   35   285  memristor PARAMS: InitStateVar=0.245706
X3592   36   285  memristor PARAMS: InitStateVar=0.292302
X3692   37   285  memristor PARAMS: InitStateVar=0.272776
X3792   38   285  memristor PARAMS: InitStateVar=0.302046
X3892   39   285  memristor PARAMS: InitStateVar=0.0367353
X3992   40   285  memristor PARAMS: InitStateVar=0.366915
X4092   41   285  memristor PARAMS: InitStateVar=0.043975
X4192   42   285  memristor PARAMS: InitStateVar=0.499523
X4292   43   285  memristor PARAMS: InitStateVar=0.343723
X4392   44   285  memristor PARAMS: InitStateVar=0.399593
X4492   45   285  memristor PARAMS: InitStateVar=0.450008
X4592   46   285  memristor PARAMS: InitStateVar=0.257097
X4692   47   285  memristor PARAMS: InitStateVar=0.192874
X4792   48   285  memristor PARAMS: InitStateVar=0.500993
X4892   49   285  memristor PARAMS: InitStateVar=0.285723
X4992   50   285  memristor PARAMS: InitStateVar=0.244
X5092   51   285  memristor PARAMS: InitStateVar=0.279812
X5192   52   285  memristor PARAMS: InitStateVar=0.174168
X5292   53   285  memristor PARAMS: InitStateVar=0.157614
X5392   54   285  memristor PARAMS: InitStateVar=0.494819
X5492   55   285  memristor PARAMS: InitStateVar=0.328838
X5592   56   285  memristor PARAMS: InitStateVar=0.358667
X5692   57   285  memristor PARAMS: InitStateVar=0.380365
X5792   58   285  memristor PARAMS: InitStateVar=0.23949
X5892   59   285  memristor PARAMS: InitStateVar=0.346939
X5992   60   285  memristor PARAMS: InitStateVar=0.239607
X6092   61   285  memristor PARAMS: InitStateVar=0.357949
X6192   62   285  memristor PARAMS: InitStateVar=0.274615
X6292   63   285  memristor PARAMS: InitStateVar=0.246003
X6392   64   285  memristor PARAMS: InitStateVar=0.345513
X6492   65   285  memristor PARAMS: InitStateVar=0.324729
X6592   66   285  memristor PARAMS: InitStateVar=0.268232
X6692   67   285  memristor PARAMS: InitStateVar=0.3954
X6792   68   285  memristor PARAMS: InitStateVar=0.20417
X6892   69   285  memristor PARAMS: InitStateVar=0.333168
X6992   70   285  memristor PARAMS: InitStateVar=0.260355
X7092   71   285  memristor PARAMS: InitStateVar=0.259653
X7192   72   285  memristor PARAMS: InitStateVar=-0.0430842
X7292   73   285  memristor PARAMS: InitStateVar=0.299862
X7392   74   285  memristor PARAMS: InitStateVar=0.326248
X7492   75   285  memristor PARAMS: InitStateVar=0.38576
X7592   76   285  memristor PARAMS: InitStateVar=0.461437
X7692   77   285  memristor PARAMS: InitStateVar=0.170827
X7792   78   285  memristor PARAMS: InitStateVar=0.234792
X7892   79   285  memristor PARAMS: InitStateVar=0.200526
X7992   80   285  memristor PARAMS: InitStateVar=0.323159
X8092   81   285  memristor PARAMS: InitStateVar=0.372482
X8192   82   285  memristor PARAMS: InitStateVar=0.379524
X8292   83   285  memristor PARAMS: InitStateVar=0.233859
X8392   84   285  memristor PARAMS: InitStateVar=0.150041
X8492   85   285  memristor PARAMS: InitStateVar=0.220293
X8592   86   285  memristor PARAMS: InitStateVar=0.361127
X8692   87   285  memristor PARAMS: InitStateVar=0.372865
X8792   88   285  memristor PARAMS: InitStateVar=0.257867
X8892   89   285  memristor PARAMS: InitStateVar=0.268638
X8992   90   285  memristor PARAMS: InitStateVar=0.286019
X9092   91   285  memristor PARAMS: InitStateVar=0.2584
X9192   92   285  memristor PARAMS: InitStateVar=0.152324
X9292   93   285  memristor PARAMS: InitStateVar=0.366397
X9392   94   285  memristor PARAMS: InitStateVar=0.299193
X9492   95   285  memristor PARAMS: InitStateVar=0.202926
X9592   96   285  memristor PARAMS: InitStateVar=0.310438
X9692   97   285  memristor PARAMS: InitStateVar=0.226637
X9792   98   285  memristor PARAMS: InitStateVar=0.419779
X9892   99   285  memristor PARAMS: InitStateVar=0.268123
X9992   100  285  memristor PARAMS: InitStateVar=0.150868
Xo93    285  286  OutputModule PARAMS: Rval=100
*------------------- Column 94 -------------------------------------------------
X93     1    287  memristor PARAMS: InitStateVar=0.444484
X193    2    287  memristor PARAMS: InitStateVar=0.414592
X293    3    287  memristor PARAMS: InitStateVar=0.228136
X393    4    287  memristor PARAMS: InitStateVar=0.371664
X493    5    287  memristor PARAMS: InitStateVar=0.506095
X593    6    287  memristor PARAMS: InitStateVar=0.153136
X693    7    287  memristor PARAMS: InitStateVar=0.506041
X793    8    287  memristor PARAMS: InitStateVar=0.165036
X893    9    287  memristor PARAMS: InitStateVar=0.28101
X993    10   287  memristor PARAMS: InitStateVar=0.196605
X1093   11   287  memristor PARAMS: InitStateVar=0.32391
X1193   12   287  memristor PARAMS: InitStateVar=0.465671
X1293   13   287  memristor PARAMS: InitStateVar=0.312609
X1393   14   287  memristor PARAMS: InitStateVar=0.35479
X1493   15   287  memristor PARAMS: InitStateVar=0.29162
X1593   16   287  memristor PARAMS: InitStateVar=0.404384
X1693   17   287  memristor PARAMS: InitStateVar=0.227137
X1793   18   287  memristor PARAMS: InitStateVar=0.292827
X1893   19   287  memristor PARAMS: InitStateVar=0.370358
X1993   20   287  memristor PARAMS: InitStateVar=0.296739
X2093   21   287  memristor PARAMS: InitStateVar=0.392951
X2193   22   287  memristor PARAMS: InitStateVar=0.2027
X2293   23   287  memristor PARAMS: InitStateVar=0.280533
X2393   24   287  memristor PARAMS: InitStateVar=0.145564
X2493   25   287  memristor PARAMS: InitStateVar=0.384389
X2593   26   287  memristor PARAMS: InitStateVar=0.291309
X2693   27   287  memristor PARAMS: InitStateVar=0.188644
X2793   28   287  memristor PARAMS: InitStateVar=0.322228
X2893   29   287  memristor PARAMS: InitStateVar=0.40855
X2993   30   287  memristor PARAMS: InitStateVar=0.22711
X3093   31   287  memristor PARAMS: InitStateVar=0.138534
X3193   32   287  memristor PARAMS: InitStateVar=0.267225
X3293   33   287  memristor PARAMS: InitStateVar=0.183079
X3393   34   287  memristor PARAMS: InitStateVar=0.307778
X3493   35   287  memristor PARAMS: InitStateVar=0.244566
X3593   36   287  memristor PARAMS: InitStateVar=0.198776
X3693   37   287  memristor PARAMS: InitStateVar=0.152136
X3793   38   287  memristor PARAMS: InitStateVar=0.381002
X3893   39   287  memristor PARAMS: InitStateVar=0.243464
X3993   40   287  memristor PARAMS: InitStateVar=0.333342
X4093   41   287  memristor PARAMS: InitStateVar=0.532835
X4193   42   287  memristor PARAMS: InitStateVar=0.361825
X4293   43   287  memristor PARAMS: InitStateVar=0.422815
X4393   44   287  memristor PARAMS: InitStateVar=0.231323
X4493   45   287  memristor PARAMS: InitStateVar=0.184239
X4593   46   287  memristor PARAMS: InitStateVar=0.378322
X4693   47   287  memristor PARAMS: InitStateVar=0.216118
X4793   48   287  memristor PARAMS: InitStateVar=0.155992
X4893   49   287  memristor PARAMS: InitStateVar=0.216676
X4993   50   287  memristor PARAMS: InitStateVar=0.466384
X5093   51   287  memristor PARAMS: InitStateVar=0.122168
X5193   52   287  memristor PARAMS: InitStateVar=0.255442
X5293   53   287  memristor PARAMS: InitStateVar=0.249957
X5393   54   287  memristor PARAMS: InitStateVar=0.453014
X5493   55   287  memristor PARAMS: InitStateVar=0.549403
X5593   56   287  memristor PARAMS: InitStateVar=0.165999
X5693   57   287  memristor PARAMS: InitStateVar=0.145717
X5793   58   287  memristor PARAMS: InitStateVar=0.118832
X5893   59   287  memristor PARAMS: InitStateVar=0.0371962
X5993   60   287  memristor PARAMS: InitStateVar=0.333998
X6093   61   287  memristor PARAMS: InitStateVar=0.339958
X6193   62   287  memristor PARAMS: InitStateVar=0.311543
X6293   63   287  memristor PARAMS: InitStateVar=0.285537
X6393   64   287  memristor PARAMS: InitStateVar=0.295843
X6493   65   287  memristor PARAMS: InitStateVar=0.326758
X6593   66   287  memristor PARAMS: InitStateVar=0.314886
X6693   67   287  memristor PARAMS: InitStateVar=0.289453
X6793   68   287  memristor PARAMS: InitStateVar=0.198514
X6893   69   287  memristor PARAMS: InitStateVar=0.191637
X6993   70   287  memristor PARAMS: InitStateVar=0.263464
X7093   71   287  memristor PARAMS: InitStateVar=0.170718
X7193   72   287  memristor PARAMS: InitStateVar=0.223834
X7293   73   287  memristor PARAMS: InitStateVar=0.351508
X7393   74   287  memristor PARAMS: InitStateVar=0.28316
X7493   75   287  memristor PARAMS: InitStateVar=0.212054
X7593   76   287  memristor PARAMS: InitStateVar=0.183109
X7693   77   287  memristor PARAMS: InitStateVar=0.258198
X7793   78   287  memristor PARAMS: InitStateVar=0.204381
X7893   79   287  memristor PARAMS: InitStateVar=0.177811
X7993   80   287  memristor PARAMS: InitStateVar=0.286723
X8093   81   287  memristor PARAMS: InitStateVar=0.066433
X8193   82   287  memristor PARAMS: InitStateVar=0.299207
X8293   83   287  memristor PARAMS: InitStateVar=0.243655
X8393   84   287  memristor PARAMS: InitStateVar=0.217992
X8493   85   287  memristor PARAMS: InitStateVar=0.326928
X8593   86   287  memristor PARAMS: InitStateVar=0.350995
X8693   87   287  memristor PARAMS: InitStateVar=0.216918
X8793   88   287  memristor PARAMS: InitStateVar=0.171328
X8893   89   287  memristor PARAMS: InitStateVar=0.316364
X8993   90   287  memristor PARAMS: InitStateVar=0.391437
X9093   91   287  memristor PARAMS: InitStateVar=0.25542
X9193   92   287  memristor PARAMS: InitStateVar=0.308384
X9293   93   287  memristor PARAMS: InitStateVar=0.326797
X9393   94   287  memristor PARAMS: InitStateVar=0.225383
X9493   95   287  memristor PARAMS: InitStateVar=0.446516
X9593   96   287  memristor PARAMS: InitStateVar=0.311768
X9693   97   287  memristor PARAMS: InitStateVar=0.259992
X9793   98   287  memristor PARAMS: InitStateVar=0.298575
X9893   99   287  memristor PARAMS: InitStateVar=0.0769821
X9993   100  287  memristor PARAMS: InitStateVar=0.350246
Xo94    287  288  OutputModule PARAMS: Rval=100
*------------------- Column 95 -------------------------------------------------
X94     1    289  memristor PARAMS: InitStateVar=0.472732
X194    2    289  memristor PARAMS: InitStateVar=0.276169
X294    3    289  memristor PARAMS: InitStateVar=0.227597
X394    4    289  memristor PARAMS: InitStateVar=0.297423
X494    5    289  memristor PARAMS: InitStateVar=0.279217
X594    6    289  memristor PARAMS: InitStateVar=0.218134
X694    7    289  memristor PARAMS: InitStateVar=0.410325
X794    8    289  memristor PARAMS: InitStateVar=0.253791
X894    9    289  memristor PARAMS: InitStateVar=0.440654
X994    10   289  memristor PARAMS: InitStateVar=0.242462
X1094   11   289  memristor PARAMS: InitStateVar=0.215034
X1194   12   289  memristor PARAMS: InitStateVar=0.26775
X1294   13   289  memristor PARAMS: InitStateVar=0.247132
X1394   14   289  memristor PARAMS: InitStateVar=0.174826
X1494   15   289  memristor PARAMS: InitStateVar=0.239072
X1594   16   289  memristor PARAMS: InitStateVar=0.4304
X1694   17   289  memristor PARAMS: InitStateVar=0.269272
X1794   18   289  memristor PARAMS: InitStateVar=0.16563
X1894   19   289  memristor PARAMS: InitStateVar=0.227771
X1994   20   289  memristor PARAMS: InitStateVar=0.37796
X2094   21   289  memristor PARAMS: InitStateVar=0.308935
X2194   22   289  memristor PARAMS: InitStateVar=0.204399
X2294   23   289  memristor PARAMS: InitStateVar=0.344171
X2394   24   289  memristor PARAMS: InitStateVar=0.450714
X2494   25   289  memristor PARAMS: InitStateVar=0.273589
X2594   26   289  memristor PARAMS: InitStateVar=0.334686
X2694   27   289  memristor PARAMS: InitStateVar=0.139576
X2794   28   289  memristor PARAMS: InitStateVar=0.378716
X2894   29   289  memristor PARAMS: InitStateVar=0.335661
X2994   30   289  memristor PARAMS: InitStateVar=0.310221
X3094   31   289  memristor PARAMS: InitStateVar=0.318474
X3194   32   289  memristor PARAMS: InitStateVar=0.246994
X3294   33   289  memristor PARAMS: InitStateVar=0.177315
X3394   34   289  memristor PARAMS: InitStateVar=0.193093
X3494   35   289  memristor PARAMS: InitStateVar=0.269678
X3594   36   289  memristor PARAMS: InitStateVar=0.19017
X3694   37   289  memristor PARAMS: InitStateVar=0.41344
X3794   38   289  memristor PARAMS: InitStateVar=0.205713
X3894   39   289  memristor PARAMS: InitStateVar=0.381765
X3994   40   289  memristor PARAMS: InitStateVar=0.138172
X4094   41   289  memristor PARAMS: InitStateVar=0.148996
X4194   42   289  memristor PARAMS: InitStateVar=0.292741
X4294   43   289  memristor PARAMS: InitStateVar=0.379068
X4394   44   289  memristor PARAMS: InitStateVar=0.141108
X4494   45   289  memristor PARAMS: InitStateVar=0.281304
X4594   46   289  memristor PARAMS: InitStateVar=0.208733
X4694   47   289  memristor PARAMS: InitStateVar=0.233011
X4794   48   289  memristor PARAMS: InitStateVar=0.27971
X4894   49   289  memristor PARAMS: InitStateVar=0.302666
X4994   50   289  memristor PARAMS: InitStateVar=0.374739
X5094   51   289  memristor PARAMS: InitStateVar=0.300246
X5194   52   289  memristor PARAMS: InitStateVar=0.32119
X5294   53   289  memristor PARAMS: InitStateVar=0.434164
X5394   54   289  memristor PARAMS: InitStateVar=0.405059
X5494   55   289  memristor PARAMS: InitStateVar=0.200969
X5594   56   289  memristor PARAMS: InitStateVar=0.273764
X5694   57   289  memristor PARAMS: InitStateVar=0.30444
X5794   58   289  memristor PARAMS: InitStateVar=0.488301
X5894   59   289  memristor PARAMS: InitStateVar=0.284548
X5994   60   289  memristor PARAMS: InitStateVar=0.403265
X6094   61   289  memristor PARAMS: InitStateVar=0.496168
X6194   62   289  memristor PARAMS: InitStateVar=0.188128
X6294   63   289  memristor PARAMS: InitStateVar=0.423454
X6394   64   289  memristor PARAMS: InitStateVar=0.109613
X6494   65   289  memristor PARAMS: InitStateVar=0.170274
X6594   66   289  memristor PARAMS: InitStateVar=0.323422
X6694   67   289  memristor PARAMS: InitStateVar=0.249827
X6794   68   289  memristor PARAMS: InitStateVar=0.216353
X6894   69   289  memristor PARAMS: InitStateVar=0.400425
X6994   70   289  memristor PARAMS: InitStateVar=0.313536
X7094   71   289  memristor PARAMS: InitStateVar=0.341572
X7194   72   289  memristor PARAMS: InitStateVar=0.293839
X7294   73   289  memristor PARAMS: InitStateVar=0.354718
X7394   74   289  memristor PARAMS: InitStateVar=0.289413
X7494   75   289  memristor PARAMS: InitStateVar=0.206299
X7594   76   289  memristor PARAMS: InitStateVar=0.203996
X7694   77   289  memristor PARAMS: InitStateVar=0.225713
X7794   78   289  memristor PARAMS: InitStateVar=0.572582
X7894   79   289  memristor PARAMS: InitStateVar=0.340544
X7994   80   289  memristor PARAMS: InitStateVar=0.365734
X8094   81   289  memristor PARAMS: InitStateVar=0.237392
X8194   82   289  memristor PARAMS: InitStateVar=0.376839
X8294   83   289  memristor PARAMS: InitStateVar=0.142893
X8394   84   289  memristor PARAMS: InitStateVar=0.308094
X8494   85   289  memristor PARAMS: InitStateVar=0.447285
X8594   86   289  memristor PARAMS: InitStateVar=0.376061
X8694   87   289  memristor PARAMS: InitStateVar=0.399578
X8794   88   289  memristor PARAMS: InitStateVar=0.242368
X8894   89   289  memristor PARAMS: InitStateVar=0.382643
X8994   90   289  memristor PARAMS: InitStateVar=0.412673
X9094   91   289  memristor PARAMS: InitStateVar=0.279814
X9194   92   289  memristor PARAMS: InitStateVar=0.175139
X9294   93   289  memristor PARAMS: InitStateVar=0.181874
X9394   94   289  memristor PARAMS: InitStateVar=0.198715
X9494   95   289  memristor PARAMS: InitStateVar=0.309417
X9594   96   289  memristor PARAMS: InitStateVar=0.261492
X9694   97   289  memristor PARAMS: InitStateVar=0.395068
X9794   98   289  memristor PARAMS: InitStateVar=0.378781
X9894   99   289  memristor PARAMS: InitStateVar=0.231675
X9994   100  289  memristor PARAMS: InitStateVar=0.158271
Xo95    289  290  OutputModule PARAMS: Rval=100
*------------------- Column 96 -------------------------------------------------
X95     1    291  memristor PARAMS: InitStateVar=0.395483
X195    2    291  memristor PARAMS: InitStateVar=0.399987
X295    3    291  memristor PARAMS: InitStateVar=0.427891
X395    4    291  memristor PARAMS: InitStateVar=0.377645
X495    5    291  memristor PARAMS: InitStateVar=0.295591
X595    6    291  memristor PARAMS: InitStateVar=0.1767
X695    7    291  memristor PARAMS: InitStateVar=0.18454
X795    8    291  memristor PARAMS: InitStateVar=0.400375
X895    9    291  memristor PARAMS: InitStateVar=0.365933
X995    10   291  memristor PARAMS: InitStateVar=0.248481
X1095   11   291  memristor PARAMS: InitStateVar=0.478563
X1195   12   291  memristor PARAMS: InitStateVar=0.323903
X1295   13   291  memristor PARAMS: InitStateVar=0.265136
X1395   14   291  memristor PARAMS: InitStateVar=0.187209
X1495   15   291  memristor PARAMS: InitStateVar=0.275291
X1595   16   291  memristor PARAMS: InitStateVar=0.293493
X1695   17   291  memristor PARAMS: InitStateVar=0.238635
X1795   18   291  memristor PARAMS: InitStateVar=0.332754
X1895   19   291  memristor PARAMS: InitStateVar=0.254668
X1995   20   291  memristor PARAMS: InitStateVar=0.101732
X2095   21   291  memristor PARAMS: InitStateVar=0.106036
X2195   22   291  memristor PARAMS: InitStateVar=0.174434
X2295   23   291  memristor PARAMS: InitStateVar=0.254699
X2395   24   291  memristor PARAMS: InitStateVar=0.477278
X2495   25   291  memristor PARAMS: InitStateVar=0.161789
X2595   26   291  memristor PARAMS: InitStateVar=0.35314
X2695   27   291  memristor PARAMS: InitStateVar=0.203897
X2795   28   291  memristor PARAMS: InitStateVar=0.375255
X2895   29   291  memristor PARAMS: InitStateVar=0.0928588
X2995   30   291  memristor PARAMS: InitStateVar=0.275249
X3095   31   291  memristor PARAMS: InitStateVar=0.36706
X3195   32   291  memristor PARAMS: InitStateVar=0.300111
X3295   33   291  memristor PARAMS: InitStateVar=0.200171
X3395   34   291  memristor PARAMS: InitStateVar=0.317106
X3495   35   291  memristor PARAMS: InitStateVar=0.270192
X3595   36   291  memristor PARAMS: InitStateVar=0.326835
X3695   37   291  memristor PARAMS: InitStateVar=0.374702
X3795   38   291  memristor PARAMS: InitStateVar=0.376037
X3895   39   291  memristor PARAMS: InitStateVar=0.30874
X3995   40   291  memristor PARAMS: InitStateVar=0.299119
X4095   41   291  memristor PARAMS: InitStateVar=0.273774
X4195   42   291  memristor PARAMS: InitStateVar=0.282303
X4295   43   291  memristor PARAMS: InitStateVar=0.394079
X4395   44   291  memristor PARAMS: InitStateVar=0.469393
X4495   45   291  memristor PARAMS: InitStateVar=0.38648
X4595   46   291  memristor PARAMS: InitStateVar=0.41088
X4695   47   291  memristor PARAMS: InitStateVar=0.2825
X4795   48   291  memristor PARAMS: InitStateVar=0.388106
X4895   49   291  memristor PARAMS: InitStateVar=0.338365
X4995   50   291  memristor PARAMS: InitStateVar=0.242165
X5095   51   291  memristor PARAMS: InitStateVar=0.510851
X5195   52   291  memristor PARAMS: InitStateVar=0.327169
X5295   53   291  memristor PARAMS: InitStateVar=0.432409
X5395   54   291  memristor PARAMS: InitStateVar=0.383493
X5495   55   291  memristor PARAMS: InitStateVar=0.319062
X5595   56   291  memristor PARAMS: InitStateVar=0.259959
X5695   57   291  memristor PARAMS: InitStateVar=0.342972
X5795   58   291  memristor PARAMS: InitStateVar=0.315748
X5895   59   291  memristor PARAMS: InitStateVar=0.317114
X5995   60   291  memristor PARAMS: InitStateVar=0.375849
X6095   61   291  memristor PARAMS: InitStateVar=0.242084
X6195   62   291  memristor PARAMS: InitStateVar=0.380946
X6295   63   291  memristor PARAMS: InitStateVar=0.19673
X6395   64   291  memristor PARAMS: InitStateVar=0.394385
X6495   65   291  memristor PARAMS: InitStateVar=0.423129
X6595   66   291  memristor PARAMS: InitStateVar=0.273368
X6695   67   291  memristor PARAMS: InitStateVar=0.322523
X6795   68   291  memristor PARAMS: InitStateVar=0.283304
X6895   69   291  memristor PARAMS: InitStateVar=0.160575
X6995   70   291  memristor PARAMS: InitStateVar=0.256586
X7095   71   291  memristor PARAMS: InitStateVar=0.301097
X7195   72   291  memristor PARAMS: InitStateVar=0.275415
X7295   73   291  memristor PARAMS: InitStateVar=0.441877
X7395   74   291  memristor PARAMS: InitStateVar=0.381411
X7495   75   291  memristor PARAMS: InitStateVar=0.30394
X7595   76   291  memristor PARAMS: InitStateVar=0.438706
X7695   77   291  memristor PARAMS: InitStateVar=0.42112
X7795   78   291  memristor PARAMS: InitStateVar=0.463446
X7895   79   291  memristor PARAMS: InitStateVar=0.310265
X7995   80   291  memristor PARAMS: InitStateVar=0.424116
X8095   81   291  memristor PARAMS: InitStateVar=0.383464
X8195   82   291  memristor PARAMS: InitStateVar=0.385225
X8295   83   291  memristor PARAMS: InitStateVar=0.218953
X8395   84   291  memristor PARAMS: InitStateVar=0.342703
X8495   85   291  memristor PARAMS: InitStateVar=0.440616
X8595   86   291  memristor PARAMS: InitStateVar=0.0644343
X8695   87   291  memristor PARAMS: InitStateVar=0.215313
X8795   88   291  memristor PARAMS: InitStateVar=0.409827
X8895   89   291  memristor PARAMS: InitStateVar=0.246627
X8995   90   291  memristor PARAMS: InitStateVar=0.287116
X9095   91   291  memristor PARAMS: InitStateVar=0.133181
X9195   92   291  memristor PARAMS: InitStateVar=0.274311
X9295   93   291  memristor PARAMS: InitStateVar=0.35794
X9395   94   291  memristor PARAMS: InitStateVar=0.32467
X9495   95   291  memristor PARAMS: InitStateVar=0.193886
X9595   96   291  memristor PARAMS: InitStateVar=0.329253
X9695   97   291  memristor PARAMS: InitStateVar=0.311621
X9795   98   291  memristor PARAMS: InitStateVar=0.225716
X9895   99   291  memristor PARAMS: InitStateVar=0.243051
X9995   100  291  memristor PARAMS: InitStateVar=0.385294
Xo96    291  292  OutputModule PARAMS: Rval=100
*------------------- Column 97 -------------------------------------------------
X96     1    293  memristor PARAMS: InitStateVar=0.295683
X196    2    293  memristor PARAMS: InitStateVar=0.23549
X296    3    293  memristor PARAMS: InitStateVar=0.462002
X396    4    293  memristor PARAMS: InitStateVar=0.241422
X496    5    293  memristor PARAMS: InitStateVar=0.336808
X596    6    293  memristor PARAMS: InitStateVar=0.18452
X696    7    293  memristor PARAMS: InitStateVar=0.269042
X796    8    293  memristor PARAMS: InitStateVar=0.235889
X896    9    293  memristor PARAMS: InitStateVar=0.261779
X996    10   293  memristor PARAMS: InitStateVar=0.3316
X1096   11   293  memristor PARAMS: InitStateVar=0.200064
X1196   12   293  memristor PARAMS: InitStateVar=0.406345
X1296   13   293  memristor PARAMS: InitStateVar=0.211827
X1396   14   293  memristor PARAMS: InitStateVar=0.229368
X1496   15   293  memristor PARAMS: InitStateVar=0.496557
X1596   16   293  memristor PARAMS: InitStateVar=0.361326
X1696   17   293  memristor PARAMS: InitStateVar=0.164366
X1796   18   293  memristor PARAMS: InitStateVar=0.199273
X1896   19   293  memristor PARAMS: InitStateVar=0.437059
X1996   20   293  memristor PARAMS: InitStateVar=0.586268
X2096   21   293  memristor PARAMS: InitStateVar=0.244283
X2196   22   293  memristor PARAMS: InitStateVar=0.269266
X2296   23   293  memristor PARAMS: InitStateVar=0.504772
X2396   24   293  memristor PARAMS: InitStateVar=0.270207
X2496   25   293  memristor PARAMS: InitStateVar=0.352458
X2596   26   293  memristor PARAMS: InitStateVar=0.27577
X2696   27   293  memristor PARAMS: InitStateVar=0.28595
X2796   28   293  memristor PARAMS: InitStateVar=0.158875
X2896   29   293  memristor PARAMS: InitStateVar=0.460567
X2996   30   293  memristor PARAMS: InitStateVar=0.27488
X3096   31   293  memristor PARAMS: InitStateVar=0.336972
X3196   32   293  memristor PARAMS: InitStateVar=0.344139
X3296   33   293  memristor PARAMS: InitStateVar=0.486924
X3396   34   293  memristor PARAMS: InitStateVar=0.22472
X3496   35   293  memristor PARAMS: InitStateVar=0.41109
X3596   36   293  memristor PARAMS: InitStateVar=0.251979
X3696   37   293  memristor PARAMS: InitStateVar=0.451793
X3796   38   293  memristor PARAMS: InitStateVar=0.243684
X3896   39   293  memristor PARAMS: InitStateVar=0.340951
X3996   40   293  memristor PARAMS: InitStateVar=0.115525
X4096   41   293  memristor PARAMS: InitStateVar=0.298605
X4196   42   293  memristor PARAMS: InitStateVar=0.272502
X4296   43   293  memristor PARAMS: InitStateVar=0.277214
X4396   44   293  memristor PARAMS: InitStateVar=0.302955
X4496   45   293  memristor PARAMS: InitStateVar=0.307649
X4596   46   293  memristor PARAMS: InitStateVar=0.00895415
X4696   47   293  memristor PARAMS: InitStateVar=0.34583
X4796   48   293  memristor PARAMS: InitStateVar=0.471079
X4896   49   293  memristor PARAMS: InitStateVar=0.379391
X4996   50   293  memristor PARAMS: InitStateVar=0.187362
X5096   51   293  memristor PARAMS: InitStateVar=0.144492
X5196   52   293  memristor PARAMS: InitStateVar=0.176951
X5296   53   293  memristor PARAMS: InitStateVar=0.294322
X5396   54   293  memristor PARAMS: InitStateVar=0.297689
X5496   55   293  memristor PARAMS: InitStateVar=0.196461
X5596   56   293  memristor PARAMS: InitStateVar=0.197908
X5696   57   293  memristor PARAMS: InitStateVar=0.184354
X5796   58   293  memristor PARAMS: InitStateVar=0.266897
X5896   59   293  memristor PARAMS: InitStateVar=0.318643
X5996   60   293  memristor PARAMS: InitStateVar=0.289942
X6096   61   293  memristor PARAMS: InitStateVar=0.436317
X6196   62   293  memristor PARAMS: InitStateVar=0.131523
X6296   63   293  memristor PARAMS: InitStateVar=0.273946
X6396   64   293  memristor PARAMS: InitStateVar=0.250254
X6496   65   293  memristor PARAMS: InitStateVar=0.270589
X6596   66   293  memristor PARAMS: InitStateVar=0.352481
X6696   67   293  memristor PARAMS: InitStateVar=0.435366
X6796   68   293  memristor PARAMS: InitStateVar=0.401108
X6896   69   293  memristor PARAMS: InitStateVar=0.328793
X6996   70   293  memristor PARAMS: InitStateVar=0.307444
X7096   71   293  memristor PARAMS: InitStateVar=0.276034
X7196   72   293  memristor PARAMS: InitStateVar=0.139113
X7296   73   293  memristor PARAMS: InitStateVar=0.208295
X7396   74   293  memristor PARAMS: InitStateVar=0.430517
X7496   75   293  memristor PARAMS: InitStateVar=0.21416
X7596   76   293  memristor PARAMS: InitStateVar=0.35028
X7696   77   293  memristor PARAMS: InitStateVar=0.170339
X7796   78   293  memristor PARAMS: InitStateVar=0.265017
X7896   79   293  memristor PARAMS: InitStateVar=0.157829
X7996   80   293  memristor PARAMS: InitStateVar=0.15173
X8096   81   293  memristor PARAMS: InitStateVar=0.184819
X8196   82   293  memristor PARAMS: InitStateVar=0.211357
X8296   83   293  memristor PARAMS: InitStateVar=0.293003
X8396   84   293  memristor PARAMS: InitStateVar=0.271034
X8496   85   293  memristor PARAMS: InitStateVar=0.233018
X8596   86   293  memristor PARAMS: InitStateVar=0.343124
X8696   87   293  memristor PARAMS: InitStateVar=0.25829
X8796   88   293  memristor PARAMS: InitStateVar=0.208673
X8896   89   293  memristor PARAMS: InitStateVar=0.373009
X8996   90   293  memristor PARAMS: InitStateVar=0.346154
X9096   91   293  memristor PARAMS: InitStateVar=0.405948
X9196   92   293  memristor PARAMS: InitStateVar=0.226066
X9296   93   293  memristor PARAMS: InitStateVar=0.403737
X9396   94   293  memristor PARAMS: InitStateVar=0.336554
X9496   95   293  memristor PARAMS: InitStateVar=0.283924
X9596   96   293  memristor PARAMS: InitStateVar=0.269874
X9696   97   293  memristor PARAMS: InitStateVar=0.290693
X9796   98   293  memristor PARAMS: InitStateVar=0.422648
X9896   99   293  memristor PARAMS: InitStateVar=0.251519
X9996   100  293  memristor PARAMS: InitStateVar=0.394958
Xo97    293  294  OutputModule PARAMS: Rval=100
*------------------- Column 98 -------------------------------------------------
X97     1    295  memristor PARAMS: InitStateVar=0.214432
X197    2    295  memristor PARAMS: InitStateVar=0.149574
X297    3    295  memristor PARAMS: InitStateVar=0.277424
X397    4    295  memristor PARAMS: InitStateVar=-0.0594351
X497    5    295  memristor PARAMS: InitStateVar=0.327203
X597    6    295  memristor PARAMS: InitStateVar=0.329105
X697    7    295  memristor PARAMS: InitStateVar=0.439667
X797    8    295  memristor PARAMS: InitStateVar=0.278723
X897    9    295  memristor PARAMS: InitStateVar=0.182326
X997    10   295  memristor PARAMS: InitStateVar=0.231573
X1097   11   295  memristor PARAMS: InitStateVar=0.323345
X1197   12   295  memristor PARAMS: InitStateVar=0.298624
X1297   13   295  memristor PARAMS: InitStateVar=0.562817
X1397   14   295  memristor PARAMS: InitStateVar=0.199552
X1497   15   295  memristor PARAMS: InitStateVar=0.440508
X1597   16   295  memristor PARAMS: InitStateVar=0.327412
X1697   17   295  memristor PARAMS: InitStateVar=0.316559
X1797   18   295  memristor PARAMS: InitStateVar=0.140376
X1897   19   295  memristor PARAMS: InitStateVar=0.199126
X1997   20   295  memristor PARAMS: InitStateVar=0.281681
X2097   21   295  memristor PARAMS: InitStateVar=0.384516
X2197   22   295  memristor PARAMS: InitStateVar=0.330442
X2297   23   295  memristor PARAMS: InitStateVar=0.260809
X2397   24   295  memristor PARAMS: InitStateVar=0.225243
X2497   25   295  memristor PARAMS: InitStateVar=0.18223
X2597   26   295  memristor PARAMS: InitStateVar=0.398057
X2697   27   295  memristor PARAMS: InitStateVar=0.306767
X2797   28   295  memristor PARAMS: InitStateVar=0.382745
X2897   29   295  memristor PARAMS: InitStateVar=0.0953381
X2997   30   295  memristor PARAMS: InitStateVar=0.266539
X3097   31   295  memristor PARAMS: InitStateVar=0.176054
X3197   32   295  memristor PARAMS: InitStateVar=0.279528
X3297   33   295  memristor PARAMS: InitStateVar=0.264759
X3397   34   295  memristor PARAMS: InitStateVar=0.423829
X3497   35   295  memristor PARAMS: InitStateVar=0.316671
X3597   36   295  memristor PARAMS: InitStateVar=0.348597
X3697   37   295  memristor PARAMS: InitStateVar=0.416527
X3797   38   295  memristor PARAMS: InitStateVar=0.174491
X3897   39   295  memristor PARAMS: InitStateVar=0.400452
X3997   40   295  memristor PARAMS: InitStateVar=0.253918
X4097   41   295  memristor PARAMS: InitStateVar=0.350924
X4197   42   295  memristor PARAMS: InitStateVar=0.210969
X4297   43   295  memristor PARAMS: InitStateVar=0.330816
X4397   44   295  memristor PARAMS: InitStateVar=0.313274
X4497   45   295  memristor PARAMS: InitStateVar=0.335421
X4597   46   295  memristor PARAMS: InitStateVar=0.426544
X4697   47   295  memristor PARAMS: InitStateVar=0.0607157
X4797   48   295  memristor PARAMS: InitStateVar=0.51947
X4897   49   295  memristor PARAMS: InitStateVar=0.417398
X4997   50   295  memristor PARAMS: InitStateVar=0.231142
X5097   51   295  memristor PARAMS: InitStateVar=0.351639
X5197   52   295  memristor PARAMS: InitStateVar=0.233492
X5297   53   295  memristor PARAMS: InitStateVar=0.428772
X5397   54   295  memristor PARAMS: InitStateVar=0.35499
X5497   55   295  memristor PARAMS: InitStateVar=0.265508
X5597   56   295  memristor PARAMS: InitStateVar=0.293646
X5697   57   295  memristor PARAMS: InitStateVar=0.301494
X5797   58   295  memristor PARAMS: InitStateVar=0.236767
X5897   59   295  memristor PARAMS: InitStateVar=0.264582
X5997   60   295  memristor PARAMS: InitStateVar=0.526223
X6097   61   295  memristor PARAMS: InitStateVar=0.159282
X6197   62   295  memristor PARAMS: InitStateVar=0.477528
X6297   63   295  memristor PARAMS: InitStateVar=0.439336
X6397   64   295  memristor PARAMS: InitStateVar=0.257781
X6497   65   295  memristor PARAMS: InitStateVar=0.292978
X6597   66   295  memristor PARAMS: InitStateVar=0.372634
X6697   67   295  memristor PARAMS: InitStateVar=0.163582
X6797   68   295  memristor PARAMS: InitStateVar=0.275492
X6897   69   295  memristor PARAMS: InitStateVar=0.254151
X6997   70   295  memristor PARAMS: InitStateVar=0.336384
X7097   71   295  memristor PARAMS: InitStateVar=0.475015
X7197   72   295  memristor PARAMS: InitStateVar=0.218566
X7297   73   295  memristor PARAMS: InitStateVar=0.140044
X7397   74   295  memristor PARAMS: InitStateVar=0.211946
X7497   75   295  memristor PARAMS: InitStateVar=0.285225
X7597   76   295  memristor PARAMS: InitStateVar=0.155034
X7697   77   295  memristor PARAMS: InitStateVar=0.325633
X7797   78   295  memristor PARAMS: InitStateVar=0.261056
X7897   79   295  memristor PARAMS: InitStateVar=0.136712
X7997   80   295  memristor PARAMS: InitStateVar=0.288397
X8097   81   295  memristor PARAMS: InitStateVar=0.339077
X8197   82   295  memristor PARAMS: InitStateVar=0.321252
X8297   83   295  memristor PARAMS: InitStateVar=0.248745
X8397   84   295  memristor PARAMS: InitStateVar=0.347425
X8497   85   295  memristor PARAMS: InitStateVar=0.514107
X8597   86   295  memristor PARAMS: InitStateVar=0.435823
X8697   87   295  memristor PARAMS: InitStateVar=0.235816
X8797   88   295  memristor PARAMS: InitStateVar=0.128828
X8897   89   295  memristor PARAMS: InitStateVar=0.201967
X8997   90   295  memristor PARAMS: InitStateVar=0.300179
X9097   91   295  memristor PARAMS: InitStateVar=0.334153
X9197   92   295  memristor PARAMS: InitStateVar=0.450327
X9297   93   295  memristor PARAMS: InitStateVar=0.379555
X9397   94   295  memristor PARAMS: InitStateVar=0.359021
X9497   95   295  memristor PARAMS: InitStateVar=0.342891
X9597   96   295  memristor PARAMS: InitStateVar=0.355675
X9697   97   295  memristor PARAMS: InitStateVar=0.466853
X9797   98   295  memristor PARAMS: InitStateVar=0.212157
X9897   99   295  memristor PARAMS: InitStateVar=0.268844
X9997   100  295  memristor PARAMS: InitStateVar=0.284926
Xo98    295  296  OutputModule PARAMS: Rval=100
*------------------- Column 99 -------------------------------------------------
X98     1    297  memristor PARAMS: InitStateVar=0.406801
X198    2    297  memristor PARAMS: InitStateVar=0.356768
X298    3    297  memristor PARAMS: InitStateVar=0.341134
X398    4    297  memristor PARAMS: InitStateVar=0.37928
X498    5    297  memristor PARAMS: InitStateVar=0.194763
X598    6    297  memristor PARAMS: InitStateVar=0.399973
X698    7    297  memristor PARAMS: InitStateVar=0.235416
X798    8    297  memristor PARAMS: InitStateVar=0.273664
X898    9    297  memristor PARAMS: InitStateVar=0.309764
X998    10   297  memristor PARAMS: InitStateVar=0.197358
X1098   11   297  memristor PARAMS: InitStateVar=0.452975
X1198   12   297  memristor PARAMS: InitStateVar=0.283624
X1298   13   297  memristor PARAMS: InitStateVar=0.220399
X1398   14   297  memristor PARAMS: InitStateVar=0.390445
X1498   15   297  memristor PARAMS: InitStateVar=0.261718
X1598   16   297  memristor PARAMS: InitStateVar=0.346694
X1698   17   297  memristor PARAMS: InitStateVar=0.362461
X1798   18   297  memristor PARAMS: InitStateVar=0.296546
X1898   19   297  memristor PARAMS: InitStateVar=0.356949
X1998   20   297  memristor PARAMS: InitStateVar=0.358061
X2098   21   297  memristor PARAMS: InitStateVar=0.269042
X2198   22   297  memristor PARAMS: InitStateVar=0.363041
X2298   23   297  memristor PARAMS: InitStateVar=0.210673
X2398   24   297  memristor PARAMS: InitStateVar=0.39584
X2498   25   297  memristor PARAMS: InitStateVar=0.176974
X2598   26   297  memristor PARAMS: InitStateVar=0.342558
X2698   27   297  memristor PARAMS: InitStateVar=0.24693
X2798   28   297  memristor PARAMS: InitStateVar=0.304695
X2898   29   297  memristor PARAMS: InitStateVar=0.17217
X2998   30   297  memristor PARAMS: InitStateVar=0.211562
X3098   31   297  memristor PARAMS: InitStateVar=0.387787
X3198   32   297  memristor PARAMS: InitStateVar=0.214146
X3298   33   297  memristor PARAMS: InitStateVar=0.262557
X3398   34   297  memristor PARAMS: InitStateVar=0.25054
X3498   35   297  memristor PARAMS: InitStateVar=0.26249
X3598   36   297  memristor PARAMS: InitStateVar=0.372191
X3698   37   297  memristor PARAMS: InitStateVar=0.204087
X3798   38   297  memristor PARAMS: InitStateVar=0.370175
X3898   39   297  memristor PARAMS: InitStateVar=0.322172
X3998   40   297  memristor PARAMS: InitStateVar=0.275413
X4098   41   297  memristor PARAMS: InitStateVar=0.342083
X4198   42   297  memristor PARAMS: InitStateVar=0.377536
X4298   43   297  memristor PARAMS: InitStateVar=0.274361
X4398   44   297  memristor PARAMS: InitStateVar=0.198205
X4498   45   297  memristor PARAMS: InitStateVar=0.279701
X4598   46   297  memristor PARAMS: InitStateVar=0.367851
X4698   47   297  memristor PARAMS: InitStateVar=0.428221
X4798   48   297  memristor PARAMS: InitStateVar=0.331549
X4898   49   297  memristor PARAMS: InitStateVar=0.265712
X4998   50   297  memristor PARAMS: InitStateVar=0.304003
X5098   51   297  memristor PARAMS: InitStateVar=0.282286
X5198   52   297  memristor PARAMS: InitStateVar=0.240563
X5298   53   297  memristor PARAMS: InitStateVar=0.240951
X5398   54   297  memristor PARAMS: InitStateVar=0.303667
X5498   55   297  memristor PARAMS: InitStateVar=0.398332
X5598   56   297  memristor PARAMS: InitStateVar=0.294522
X5698   57   297  memristor PARAMS: InitStateVar=0.320923
X5798   58   297  memristor PARAMS: InitStateVar=0.320146
X5898   59   297  memristor PARAMS: InitStateVar=0.307484
X5998   60   297  memristor PARAMS: InitStateVar=0.391615
X6098   61   297  memristor PARAMS: InitStateVar=0.365471
X6198   62   297  memristor PARAMS: InitStateVar=0.291876
X6298   63   297  memristor PARAMS: InitStateVar=0.219792
X6398   64   297  memristor PARAMS: InitStateVar=0.216206
X6498   65   297  memristor PARAMS: InitStateVar=0.404939
X6598   66   297  memristor PARAMS: InitStateVar=0.335747
X6698   67   297  memristor PARAMS: InitStateVar=0.179067
X6798   68   297  memristor PARAMS: InitStateVar=0.269528
X6898   69   297  memristor PARAMS: InitStateVar=0.373286
X6998   70   297  memristor PARAMS: InitStateVar=0.426206
X7098   71   297  memristor PARAMS: InitStateVar=0.261806
X7198   72   297  memristor PARAMS: InitStateVar=0.412691
X7298   73   297  memristor PARAMS: InitStateVar=0.287647
X7398   74   297  memristor PARAMS: InitStateVar=0.201083
X7498   75   297  memristor PARAMS: InitStateVar=0.4121
X7598   76   297  memristor PARAMS: InitStateVar=0.380143
X7698   77   297  memristor PARAMS: InitStateVar=0.21776
X7798   78   297  memristor PARAMS: InitStateVar=0.298964
X7898   79   297  memristor PARAMS: InitStateVar=0.286078
X7998   80   297  memristor PARAMS: InitStateVar=0.206763
X8098   81   297  memristor PARAMS: InitStateVar=0.253356
X8198   82   297  memristor PARAMS: InitStateVar=0.311904
X8298   83   297  memristor PARAMS: InitStateVar=0.352316
X8398   84   297  memristor PARAMS: InitStateVar=0.100423
X8498   85   297  memristor PARAMS: InitStateVar=0.338781
X8598   86   297  memristor PARAMS: InitStateVar=0.309606
X8698   87   297  memristor PARAMS: InitStateVar=0.276084
X8798   88   297  memristor PARAMS: InitStateVar=0.333009
X8898   89   297  memristor PARAMS: InitStateVar=0.640761
X8998   90   297  memristor PARAMS: InitStateVar=0.408306
X9098   91   297  memristor PARAMS: InitStateVar=0.333695
X9198   92   297  memristor PARAMS: InitStateVar=0.378156
X9298   93   297  memristor PARAMS: InitStateVar=0.272769
X9398   94   297  memristor PARAMS: InitStateVar=0.431216
X9498   95   297  memristor PARAMS: InitStateVar=0.274696
X9598   96   297  memristor PARAMS: InitStateVar=0.374042
X9698   97   297  memristor PARAMS: InitStateVar=0.259975
X9798   98   297  memristor PARAMS: InitStateVar=0.347911
X9898   99   297  memristor PARAMS: InitStateVar=0.216768
X9998   100  297  memristor PARAMS: InitStateVar=0.191946
Xo99    297  298  OutputModule PARAMS: Rval=100
*------------------- Column 100 -------------------------------------------------
X99     1    299  memristor PARAMS: InitStateVar=0.392659
X199    2    299  memristor PARAMS: InitStateVar=0.340032
X299    3    299  memristor PARAMS: InitStateVar=0.255611
X399    4    299  memristor PARAMS: InitStateVar=0.180108
X499    5    299  memristor PARAMS: InitStateVar=0.497258
X599    6    299  memristor PARAMS: InitStateVar=0.368874
X699    7    299  memristor PARAMS: InitStateVar=0.266371
X799    8    299  memristor PARAMS: InitStateVar=0.264648
X899    9    299  memristor PARAMS: InitStateVar=0.411478
X999    10   299  memristor PARAMS: InitStateVar=0.39345
X1099   11   299  memristor PARAMS: InitStateVar=0.387734
X1199   12   299  memristor PARAMS: InitStateVar=0.246147
X1299   13   299  memristor PARAMS: InitStateVar=0.583822
X1399   14   299  memristor PARAMS: InitStateVar=0.316634
X1499   15   299  memristor PARAMS: InitStateVar=0.45422
X1599   16   299  memristor PARAMS: InitStateVar=0.34648
X1699   17   299  memristor PARAMS: InitStateVar=0.308045
X1799   18   299  memristor PARAMS: InitStateVar=0.228436
X1899   19   299  memristor PARAMS: InitStateVar=0.210452
X1999   20   299  memristor PARAMS: InitStateVar=0.34768
X2099   21   299  memristor PARAMS: InitStateVar=0.322923
X2199   22   299  memristor PARAMS: InitStateVar=0.282009
X2299   23   299  memristor PARAMS: InitStateVar=0.418314
X2399   24   299  memristor PARAMS: InitStateVar=0.212651
X2499   25   299  memristor PARAMS: InitStateVar=0.372566
X2599   26   299  memristor PARAMS: InitStateVar=0.205505
X2699   27   299  memristor PARAMS: InitStateVar=0.140769
X2799   28   299  memristor PARAMS: InitStateVar=0.38469
X2899   29   299  memristor PARAMS: InitStateVar=0.312729
X2999   30   299  memristor PARAMS: InitStateVar=0.186905
X3099   31   299  memristor PARAMS: InitStateVar=0.253581
X3199   32   299  memristor PARAMS: InitStateVar=0.373502
X3299   33   299  memristor PARAMS: InitStateVar=0.238597
X3399   34   299  memristor PARAMS: InitStateVar=0.279048
X3499   35   299  memristor PARAMS: InitStateVar=0.334473
X3599   36   299  memristor PARAMS: InitStateVar=0.284433
X3699   37   299  memristor PARAMS: InitStateVar=0.272708
X3799   38   299  memristor PARAMS: InitStateVar=0.271072
X3899   39   299  memristor PARAMS: InitStateVar=0.338318
X3999   40   299  memristor PARAMS: InitStateVar=0.158196
X4099   41   299  memristor PARAMS: InitStateVar=0.481737
X4199   42   299  memristor PARAMS: InitStateVar=0.187857
X4299   43   299  memristor PARAMS: InitStateVar=0.431839
X4399   44   299  memristor PARAMS: InitStateVar=0.136265
X4499   45   299  memristor PARAMS: InitStateVar=0.377827
X4599   46   299  memristor PARAMS: InitStateVar=0.246923
X4699   47   299  memristor PARAMS: InitStateVar=0.264093
X4799   48   299  memristor PARAMS: InitStateVar=0.157288
X4899   49   299  memristor PARAMS: InitStateVar=0.366086
X4999   50   299  memristor PARAMS: InitStateVar=0.406377
X5099   51   299  memristor PARAMS: InitStateVar=0.175979
X5199   52   299  memristor PARAMS: InitStateVar=0.394442
X5299   53   299  memristor PARAMS: InitStateVar=0.475658
X5399   54   299  memristor PARAMS: InitStateVar=0.169157
X5499   55   299  memristor PARAMS: InitStateVar=0.331645
X5599   56   299  memristor PARAMS: InitStateVar=0.285299
X5699   57   299  memristor PARAMS: InitStateVar=0.276206
X5799   58   299  memristor PARAMS: InitStateVar=0.361666
X5899   59   299  memristor PARAMS: InitStateVar=0.246642
X5999   60   299  memristor PARAMS: InitStateVar=0.351142
X6099   61   299  memristor PARAMS: InitStateVar=0.225193
X6199   62   299  memristor PARAMS: InitStateVar=0.387905
X6299   63   299  memristor PARAMS: InitStateVar=0.267633
X6399   64   299  memristor PARAMS: InitStateVar=0.40348
X6499   65   299  memristor PARAMS: InitStateVar=0.345569
X6599   66   299  memristor PARAMS: InitStateVar=0.245574
X6699   67   299  memristor PARAMS: InitStateVar=0.267501
X6799   68   299  memristor PARAMS: InitStateVar=0.343032
X6899   69   299  memristor PARAMS: InitStateVar=0.174872
X6999   70   299  memristor PARAMS: InitStateVar=0.448577
X7099   71   299  memristor PARAMS: InitStateVar=0.351858
X7199   72   299  memristor PARAMS: InitStateVar=0.369214
X7299   73   299  memristor PARAMS: InitStateVar=0.11886
X7399   74   299  memristor PARAMS: InitStateVar=0.283989
X7499   75   299  memristor PARAMS: InitStateVar=0.261845
X7599   76   299  memristor PARAMS: InitStateVar=0.214266
X7699   77   299  memristor PARAMS: InitStateVar=0.367833
X7799   78   299  memristor PARAMS: InitStateVar=0.265913
X7899   79   299  memristor PARAMS: InitStateVar=0.226532
X7999   80   299  memristor PARAMS: InitStateVar=0.346378
X8099   81   299  memristor PARAMS: InitStateVar=0.278289
X8199   82   299  memristor PARAMS: InitStateVar=0.272601
X8299   83   299  memristor PARAMS: InitStateVar=0.526228
X8399   84   299  memristor PARAMS: InitStateVar=0.273296
X8499   85   299  memristor PARAMS: InitStateVar=0.322558
X8599   86   299  memristor PARAMS: InitStateVar=0.161081
X8699   87   299  memristor PARAMS: InitStateVar=0.350058
X8799   88   299  memristor PARAMS: InitStateVar=0.311415
X8899   89   299  memristor PARAMS: InitStateVar=0.389335
X8999   90   299  memristor PARAMS: InitStateVar=0.3282
X9099   91   299  memristor PARAMS: InitStateVar=0.158411
X9199   92   299  memristor PARAMS: InitStateVar=0.468598
X9299   93   299  memristor PARAMS: InitStateVar=0.452551
X9399   94   299  memristor PARAMS: InitStateVar=0.274653
X9499   95   299  memristor PARAMS: InitStateVar=0.308221
X9599   96   299  memristor PARAMS: InitStateVar=0.209717
X9699   97   299  memristor PARAMS: InitStateVar=0.408226
X9799   98   299  memristor PARAMS: InitStateVar=0.296737
X9899   99   299  memristor PARAMS: InitStateVar=0.180941
X9999   100  299  memristor PARAMS: InitStateVar=0.444734
Xo100   299  300  OutputModule PARAMS: Rval=100

********************************************************************************
********************** Measurements for analysis *******************************
********************************************************************************
* Measurement Type      : AVG
* Measurement Interval  : from 0ms to 10000ms
* Measured Elements     : V(102) V(104) V(106) V(108) V(110) V(112) V(114) V(116) V(118) V(120)
*                         V(122) V(124) V(126) V(128) V(130) V(132) V(134) V(136) V(138) V(140) V(142)
*                         V(144) V(146) V(148) V(150) V(152) V(154) V(156) V(158) V(160) V(162) V(164)
*                         V(166) V(168) V(170) V(172) V(174) V(176) V(178) V(180) V(182) V(184) V(186)
*                         V(188) V(190) V(192) V(194) V(196) V(198) V(200) V(202) V(204) V(206) V(208)
*                         V(210) V(212) V(214) V(216) V(218) V(220) V(222) V(224) V(226) V(228) V(230)
*                         V(232) V(234) V(236) V(238) V(240) V(242) V(244) V(246) V(248) V(250) V(252)
*                         V(254) V(256) V(258) V(260) V(262) V(264) V(266) V(268) V(270) V(272) V(274)
*                         V(276) V(278) V(280) V(282) V(284) V(286) V(288) V(290) V(292) V(294) V(296)
*                         V(298) V(300)
********************************************************************************
.PRINT TRAN FORMAT=NOINDEX
.MEASURE TRAN V102_102_AVG  AVG     V(102) FROM=0ms TO=10000ms
.MEASURE TRAN V104_104_AVG  AVG     V(104) FROM=0ms TO=10000ms
.MEASURE TRAN V106_106_AVG  AVG     V(106) FROM=0ms TO=10000ms
.MEASURE TRAN V108_108_AVG  AVG     V(108) FROM=0ms TO=10000ms
.MEASURE TRAN V110_110_AVG  AVG     V(110) FROM=0ms TO=10000ms
.MEASURE TRAN V112_112_AVG  AVG     V(112) FROM=0ms TO=10000ms
.MEASURE TRAN V114_114_AVG  AVG     V(114) FROM=0ms TO=10000ms
.MEASURE TRAN V116_116_AVG  AVG     V(116) FROM=0ms TO=10000ms
.MEASURE TRAN V118_118_AVG  AVG     V(118) FROM=0ms TO=10000ms
.MEASURE TRAN V120_120_AVG  AVG     V(120) FROM=0ms TO=10000ms
.MEASURE TRAN V122_122_AVG  AVG     V(122) FROM=0ms TO=10000ms
.MEASURE TRAN V124_124_AVG  AVG     V(124) FROM=0ms TO=10000ms
.MEASURE TRAN V126_126_AVG  AVG     V(126) FROM=0ms TO=10000ms
.MEASURE TRAN V128_128_AVG  AVG     V(128) FROM=0ms TO=10000ms
.MEASURE TRAN V130_130_AVG  AVG     V(130) FROM=0ms TO=10000ms
.MEASURE TRAN V132_132_AVG  AVG     V(132) FROM=0ms TO=10000ms
.MEASURE TRAN V134_134_AVG  AVG     V(134) FROM=0ms TO=10000ms
.MEASURE TRAN V136_136_AVG  AVG     V(136) FROM=0ms TO=10000ms
.MEASURE TRAN V138_138_AVG  AVG     V(138) FROM=0ms TO=10000ms
.MEASURE TRAN V140_140_AVG  AVG     V(140) FROM=0ms TO=10000ms
.MEASURE TRAN V142_142_AVG  AVG     V(142) FROM=0ms TO=10000ms
.MEASURE TRAN V144_144_AVG  AVG     V(144) FROM=0ms TO=10000ms
.MEASURE TRAN V146_146_AVG  AVG     V(146) FROM=0ms TO=10000ms
.MEASURE TRAN V148_148_AVG  AVG     V(148) FROM=0ms TO=10000ms
.MEASURE TRAN V150_150_AVG  AVG     V(150) FROM=0ms TO=10000ms
.MEASURE TRAN V152_152_AVG  AVG     V(152) FROM=0ms TO=10000ms
.MEASURE TRAN V154_154_AVG  AVG     V(154) FROM=0ms TO=10000ms
.MEASURE TRAN V156_156_AVG  AVG     V(156) FROM=0ms TO=10000ms
.MEASURE TRAN V158_158_AVG  AVG     V(158) FROM=0ms TO=10000ms
.MEASURE TRAN V160_160_AVG  AVG     V(160) FROM=0ms TO=10000ms
.MEASURE TRAN V162_162_AVG  AVG     V(162) FROM=0ms TO=10000ms
.MEASURE TRAN V164_164_AVG  AVG     V(164) FROM=0ms TO=10000ms
.MEASURE TRAN V166_166_AVG  AVG     V(166) FROM=0ms TO=10000ms
.MEASURE TRAN V168_168_AVG  AVG     V(168) FROM=0ms TO=10000ms
.MEASURE TRAN V170_170_AVG  AVG     V(170) FROM=0ms TO=10000ms
.MEASURE TRAN V172_172_AVG  AVG     V(172) FROM=0ms TO=10000ms
.MEASURE TRAN V174_174_AVG  AVG     V(174) FROM=0ms TO=10000ms
.MEASURE TRAN V176_176_AVG  AVG     V(176) FROM=0ms TO=10000ms
.MEASURE TRAN V178_178_AVG  AVG     V(178) FROM=0ms TO=10000ms
.MEASURE TRAN V180_180_AVG  AVG     V(180) FROM=0ms TO=10000ms
.MEASURE TRAN V182_182_AVG  AVG     V(182) FROM=0ms TO=10000ms
.MEASURE TRAN V184_184_AVG  AVG     V(184) FROM=0ms TO=10000ms
.MEASURE TRAN V186_186_AVG  AVG     V(186) FROM=0ms TO=10000ms
.MEASURE TRAN V188_188_AVG  AVG     V(188) FROM=0ms TO=10000ms
.MEASURE TRAN V190_190_AVG  AVG     V(190) FROM=0ms TO=10000ms
.MEASURE TRAN V192_192_AVG  AVG     V(192) FROM=0ms TO=10000ms
.MEASURE TRAN V194_194_AVG  AVG     V(194) FROM=0ms TO=10000ms
.MEASURE TRAN V196_196_AVG  AVG     V(196) FROM=0ms TO=10000ms
.MEASURE TRAN V198_198_AVG  AVG     V(198) FROM=0ms TO=10000ms
.MEASURE TRAN V200_200_AVG  AVG     V(200) FROM=0ms TO=10000ms
.MEASURE TRAN V202_202_AVG  AVG     V(202) FROM=0ms TO=10000ms
.MEASURE TRAN V204_204_AVG  AVG     V(204) FROM=0ms TO=10000ms
.MEASURE TRAN V206_206_AVG  AVG     V(206) FROM=0ms TO=10000ms
.MEASURE TRAN V208_208_AVG  AVG     V(208) FROM=0ms TO=10000ms
.MEASURE TRAN V210_210_AVG  AVG     V(210) FROM=0ms TO=10000ms
.MEASURE TRAN V212_212_AVG  AVG     V(212) FROM=0ms TO=10000ms
.MEASURE TRAN V214_214_AVG  AVG     V(214) FROM=0ms TO=10000ms
.MEASURE TRAN V216_216_AVG  AVG     V(216) FROM=0ms TO=10000ms
.MEASURE TRAN V218_218_AVG  AVG     V(218) FROM=0ms TO=10000ms
.MEASURE TRAN V220_220_AVG  AVG     V(220) FROM=0ms TO=10000ms
.MEASURE TRAN V222_222_AVG  AVG     V(222) FROM=0ms TO=10000ms
.MEASURE TRAN V224_224_AVG  AVG     V(224) FROM=0ms TO=10000ms
.MEASURE TRAN V226_226_AVG  AVG     V(226) FROM=0ms TO=10000ms
.MEASURE TRAN V228_228_AVG  AVG     V(228) FROM=0ms TO=10000ms
.MEASURE TRAN V230_230_AVG  AVG     V(230) FROM=0ms TO=10000ms
.MEASURE TRAN V232_232_AVG  AVG     V(232) FROM=0ms TO=10000ms
.MEASURE TRAN V234_234_AVG  AVG     V(234) FROM=0ms TO=10000ms
.MEASURE TRAN V236_236_AVG  AVG     V(236) FROM=0ms TO=10000ms
.MEASURE TRAN V238_238_AVG  AVG     V(238) FROM=0ms TO=10000ms
.MEASURE TRAN V240_240_AVG  AVG     V(240) FROM=0ms TO=10000ms
.MEASURE TRAN V242_242_AVG  AVG     V(242) FROM=0ms TO=10000ms
.MEASURE TRAN V244_244_AVG  AVG     V(244) FROM=0ms TO=10000ms
.MEASURE TRAN V246_246_AVG  AVG     V(246) FROM=0ms TO=10000ms
.MEASURE TRAN V248_248_AVG  AVG     V(248) FROM=0ms TO=10000ms
.MEASURE TRAN V250_250_AVG  AVG     V(250) FROM=0ms TO=10000ms
.MEASURE TRAN V252_252_AVG  AVG     V(252) FROM=0ms TO=10000ms
.MEASURE TRAN V254_254_AVG  AVG     V(254) FROM=0ms TO=10000ms
.MEASURE TRAN V256_256_AVG  AVG     V(256) FROM=0ms TO=10000ms
.MEASURE TRAN V258_258_AVG  AVG     V(258) FROM=0ms TO=10000ms
.MEASURE TRAN V260_260_AVG  AVG     V(260) FROM=0ms TO=10000ms
.MEASURE TRAN V262_262_AVG  AVG     V(262) FROM=0ms TO=10000ms
.MEASURE TRAN V264_264_AVG  AVG     V(264) FROM=0ms TO=10000ms
.MEASURE TRAN V266_266_AVG  AVG     V(266) FROM=0ms TO=10000ms
.MEASURE TRAN V268_268_AVG  AVG     V(268) FROM=0ms TO=10000ms
.MEASURE TRAN V270_270_AVG  AVG     V(270) FROM=0ms TO=10000ms
.MEASURE TRAN V272_272_AVG  AVG     V(272) FROM=0ms TO=10000ms
.MEASURE TRAN V274_274_AVG  AVG     V(274) FROM=0ms TO=10000ms
.MEASURE TRAN V276_276_AVG  AVG     V(276) FROM=0ms TO=10000ms
.MEASURE TRAN V278_278_AVG  AVG     V(278) FROM=0ms TO=10000ms
.MEASURE TRAN V280_280_AVG  AVG     V(280) FROM=0ms TO=10000ms
.MEASURE TRAN V282_282_AVG  AVG     V(282) FROM=0ms TO=10000ms
.MEASURE TRAN V284_284_AVG  AVG     V(284) FROM=0ms TO=10000ms
.MEASURE TRAN V286_286_AVG  AVG     V(286) FROM=0ms TO=10000ms
.MEASURE TRAN V288_288_AVG  AVG     V(288) FROM=0ms TO=10000ms
.MEASURE TRAN V290_290_AVG  AVG     V(290) FROM=0ms TO=10000ms
.MEASURE TRAN V292_292_AVG  AVG     V(292) FROM=0ms TO=10000ms
.MEASURE TRAN V294_294_AVG  AVG     V(294) FROM=0ms TO=10000ms
.MEASURE TRAN V296_296_AVG  AVG     V(296) FROM=0ms TO=10000ms
.MEASURE TRAN V298_298_AVG  AVG     V(298) FROM=0ms TO=10000ms
.MEASURE TRAN V300_300_AVG  AVG     V(300) FROM=0ms TO=10000ms

.END
