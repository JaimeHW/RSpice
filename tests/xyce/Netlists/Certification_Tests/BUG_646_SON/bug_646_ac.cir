* This tests SON Bug 646 for .AC analyses with 3, 4 and 5 variables
* on the .PRINT AC FORMAT=PROBE line

.AC DEC 4 1e2 1e6
.PRINT AC FORMAT=PROBE FILE=bug_646_ac.cir3.csd V(1) V(2) V(3)
.PRINT AC FORMAT=PROBE FILE=bug_646_ac.cir4.csd V(1) V(2) V(3) V(4)
.PRINT AC FORMAT=PROBE FILE=bug_646_ac.cir5.csd V(1) V(2) V(3) V(4) V(5)

* Use a simple high-pass RC circuit.  Break the "R" up into 5 pieces
* so that that 5 voltages can be easily printed out.
VS  1  0  DC 0 AC 1
C1  1  1a 1u
R1  1a 2  1
R2  2  3  1
R3  3  4  1
R4  4  5  1
R5  5  0  1
