* vout_8_9_05
*-------------------------------------------------------------------------------
* Generated by ChileCAD (Version 2.1.0, Release #23 'J' (Aug 7, 2005))
* on Tue Aug 09 10:35:18 MDT 2005. Netlist type: Xyce 2.x.
* From schematic: "vout_8_9_05".
*-------------------------------------------------------------------------------

.Print TRAN  V(2)
.Tran 1 5

*** Resistors ***
R0 2 0 2k
R1 4 0 10T

*** Sources ***
V0 1 0 DC 1
V1 3 0 DC 2.7
V2 RBAD 0 0

*** Subcircuit Devices ***
X0 2 0 1 0 4 3 jfernan/OPA341_basic

*** Start Model Definitions ***

.MODEL core/Dideal D
+ IS=1e-15

RBad 1  0  1Meg

.MODEL OPA2341/Ntypemos NMOS
+ LEVEL = 3
+ UO = 600
+ VTO = 0.7
+ NFS = 0
+ TOX = 1E-007
+ NSUB = 1E+015
+ NSS = 0
+ VMAX = 1E+006
+ RS = 0
+ RD = 0
+ RSH = 0
+ XJ = 0
+ LD = 0
+ DELTA = 0
+ THETA = 0
+ ETA = 0
+ KAPPA = 0.2

.MODEL OPA2341/Ptypemos PMOS
+ LEVEL = 3
+ UO = 600
+ VTO = -0.8
+ NFS = 0
+ TOX = 1E-007
+ NSUB = 1E+015
+ NSS = 0
+ VMAX = 1E+006
+ RS = 0
+ RD = 0
+ RSH = 0
+ XJ = 0
+ LD = 0
+ DELTA = 0
+ THETA = 0
+ ETA = 0
+ KAPPA = 0.2

.MODEL core/Qpnp PNP
+ BF=25

*** End Model Definitions ***

*** Start Subcircuit Definitions ***

* OPA341_basic
*-------------------------------------------------------------------------------
* Generated by ChileCAD (Version 2.1.0, Release #23 'J' (Aug 7, 2005))
* on Tue Aug 09 10:35:17 MDT 2005. Netlist type: Xyce 2.x.
* From schematic: "OPA341_basic".
*-------------------------------------------------------------------------------

* on Tue Aug 09 10:34:46 MDT 2005. Netlist type: Xyce 2.x.
.SUBCKT jfernan/OPA341_basic Out V- +In -In SD V+

*** Resistors ***
R0 0 19 10T
R2 0 20 10T
R3 0 25 10T
R4 0 27 10T
R5 28 0 10T
R7 29 0 10T
R8 30 0 10T

*** Subcircuit Devices ***
X0 19 19 19 19 19 19 19 19 SD 1 V+ V- jfernan/IN_OUT_PAD
X1 20 20 20 20 20 20 20 20 +In 8 V+ V- jfernan/IN_OUT_PAD
X2 25 25 25 25 25 25 25 25 -In 26 V+ V- jfernan/IN_OUT_PAD
X3 2 33 4 5 32 6 1 V+ V- jfernan/ENABLE
X4 2 33 5 32 3 7 17 16 31 8 26 4 V+ V- jfernan/INPUT_STAGE
X5 3 7 17 16 31 18 2 33 V+ V- jfernan/BIAS
X6 2 33 4 5 6 16 17 31 18 10 11 12 13 14 V+ V- jfernan/OUTPUT_STAGE
X7 30 29 10 11 12 13 28 14 Out 27 V+ V- jfernan/IN_OUT_PAD

.ENDS jfernan/OPA341_basic

* IN_OUT_PAD
*-------------------------------------------------------------------------------
* Generated by ChileCAD (Version 2.1.0, Release #23 'J' (Aug 7, 2005))
* on Tue Aug 09 10:35:02 MDT 2005. Netlist type: Xyce 2.x.
* From schematic: "IN_OUT_PAD".
*-------------------------------------------------------------------------------

* on Tue Aug 09 10:34:31 MDT 2005. Netlist type: Xyce 2.x.
.SUBCKT jfernan/IN_OUT_PAD R_1 R_2 R_3 R_4 R_5 R_6 R_7 R_8 IN/OUT IN_CIR V+ V-

*** Diodes ***
D1 IN/OUT 3 core/Dideal
D2 IN/OUT V+ core/Dideal

M0 3 3 V- V- OPA2341/Ntypemos L=700n W=100u M=1
M1 IN_CIR IN_CIR V- V- OPA2341/Ntypemos L=700n W=10u M=2

*** Resistors ***
R1 IN/OUT R_1 10
R10 1 IN_CIR 35
R2 IN/OUT R_2 10
R3 IN/OUT R_3 10
R4 IN/OUT R_4 10
R5 IN/OUT R_5 10
R6 IN/OUT R_6 10
R7 IN/OUT R_7 10
R8 IN/OUT R_8 10
R9 1 IN/OUT 200

.ENDS jfernan/IN_OUT_PAD

* ENABLE
*-------------------------------------------------------------------------------
* Generated by ChileCAD (Version 2.1.0, Release #23 'J' (Aug 7, 2005))
* on Tue Aug 09 10:35:07 MDT 2005. Netlist type: Xyce 2.x.
* From schematic: "ENABLE".
*-------------------------------------------------------------------------------

* on Tue Aug 09 10:34:38 MDT 2005. Netlist type: Xyce 2.x.
.SUBCKT jfernan/ENABLE EN1 EN2 EN3 EN4 EN5 EN6 SDB_IN V+ V-

*** Capacitors ***
C1 16 EN1 10p

M0 6 SDB_IN 4 4 OPA2341/Ptypemos L=20u W=1u M=1
M1 8 SDB_IN 6 6 OPA2341/Ptypemos L=20u W=1u M=1
M10 4 SDB_IN V+ V+ OPA2341/Ptypemos L=20u W=1u M=1
M11 13 SDB_IN V- V- OPA2341/Ntypemos L=20u W=1u M=1
M12 15 9 V- V- OPA2341/Ntypemos L=1u W=1u M=1
M13 16 15 V- V- OPA2341/Ntypemos L=1u W=1u M=1
M14 14 16 V- V- OPA2341/Ntypemos L=1u W=1u M=1
M15 EN2 16 V- V- OPA2341/Ntypemos L=1u W=1u M=1
M16 EN4 16 V- V- OPA2341/Ntypemos L=1u W=1u M=1
M17 EN6 16 V- V- OPA2341/Ntypemos L=1u W=1u M=1
M2 9 SDB_IN 8 8 OPA2341/Ptypemos L=20u W=1u M=1
M3 15 9 V+ V+ OPA2341/Ptypemos L=1u W=3u M=1
M4 16 15 V+ V+ OPA2341/Ptypemos L=1u W=3u M=1
M5 14 16 V+ V+ OPA2341/Ptypemos L=1u W=3u M=1
M6 EN1 14 V+ V+ OPA2341/Ptypemos L=1u W=10u M=1
M7 EN3 14 V+ V+ OPA2341/Ptypemos L=1u W=10u M=1
M8 EN5 14 V+ V+ OPA2341/Ptypemos L=1u W=10u M=1
M9 9 SDB_IN 13 13 OPA2341/Ntypemos L=20u W=1u M=1

.ENDS jfernan/ENABLE

* INPUT_STAGE
*-------------------------------------------------------------------------------
* Generated by ChileCAD (Version 2.1.0, Release #23 'J' (Aug 7, 2005))
* on Tue Aug 09 10:35:08 MDT 2005. Netlist type: Xyce 2.x.
* From schematic: "INPUT_STAGE".
*-------------------------------------------------------------------------------

.SUBCKT jfernan/INPUT_STAGE EN1 EN2 EN4 EN5 Bias1 Bias3 Bias4 Bias5 Bias6 +IN -IN O2 V+ V-

*** Capacitors ***
C2 V- 13 10p

M0 1 EN1 V+ V+ OPA2341/Ptypemos L=1u W=10u M=50
M1 2 Bias4 1 1 OPA2341/Ptypemos L=1u W=10u M=50
M10 Bias5 Bias5 Bias5 Bias5 OPA2341/Ptypemos L=1u W=10u M=2
M11 8 8 V+ V+ OPA2341/Ptypemos L=1u W=10u M=50
M12 10 EN5 V+ V+ OPA2341/Ptypemos L=1u W=10u M=50
M13 11 Bias4 10 10 OPA2341/Ptypemos L=1u W=10u M=50
M14 14 Bias5 11 11 OPA2341/Ptypemos L=1u W=15u M=10
M15 14 Bias5 11 11 OPA2341/Ptypemos L=1u W=15u M=10
M16 O2 8 V+ V+ OPA2341/Ptypemos L=1u W=10u M=50
M17 7 +IN 4 4 OPA2341/Ntypemos L=12u W=25u M=12
M18 4 Bias6 5 5 OPA2341/Ntypemos L=2u W=9u M=50
M19 5 416 V- V- OPA2341/Ntypemos L=2u W=9u M=50
M2 416 Bias1 2 2 OPA2341/Ptypemos L=1u W=10u M=50
M20 416 416 V- V- OPA2341/Ntypemos L=2u W=9u M=50
M21 7 -IN 4 4 OPA2341/Ntypemos L=12u W=25u M=12
M22 Bias5 Bias3 3 3 OPA2341/Ntypemos L=1u W=10u M=25
M23 Bias5 Bias3 12 12 OPA2341/Ntypemos L=1u W=10u M=25
M24 3 Bias5 9 9 OPA2341/Ntypemos L=2u W=20u M=20
M25 12 Bias5 15 15 OPA2341/Ntypemos L=2u W=20u M=20
M26 8 Bias5 17 17 OPA2341/Ntypemos L=1u W=10u M=10
M27 17 17 V- V- OPA2341/Ntypemos L=1u W=9u M=20
M28 EN4 17 V- V- OPA2341/Ntypemos L=1u W=9u M=20
M29 O2 Bias5 EN4 EN4 OPA2341/Ntypemos L=1u W=10u M=10
M3 3 +IN 2 2 OPA2341/Ptypemos L=6u W=25u M=12
M30 14 EN2 V- V- OPA2341/Ntypemos L=2u W=8u M=50
M4 12 -IN 2 2 OPA2341/Ptypemos L=6u W=25u M=12
M5 7 Bias1 Bias1 Bias1 OPA2341/Ptypemos L=2u W=20u M=50
M6 7 Bias1 Bias1 Bias1 OPA2341/Ptypemos L=2u W=20u M=50
M7 Bias5 7 7 7 OPA2341/Ptypemos L=1u W=10u M=50
M8 Bias5 7 7 7 OPA2341/Ptypemos L=1u W=10u M=50
M9 Bias5 Bias5 Bias5 Bias5 OPA2341/Ptypemos L=1u W=10u M=2

*** Resistors ***
R1 Bias1 V+ 5k
R14 V- 9 5k
R15 V- 15 5k
R2 Bias1 V+ 5k
R2A 13 Bias5 5k

.ENDS jfernan/INPUT_STAGE

* BIAS
*-------------------------------------------------------------------------------
* Generated by ChileCAD (Version 2.1.0, Release #23 'J' (Aug 7, 2005))
* on Tue Aug 09 10:35:16 MDT 2005. Netlist type: Xyce 2.x.
* From schematic: "BIAS".
*-------------------------------------------------------------------------------

* on Tue Aug 09 10:34:44 MDT 2005. Netlist type: Xyce 2.x.
.SUBCKT jfernan/BIAS Bias1 Bias3 Bias4 Bias5 Bias6 Bias7 EN1 EN2 V+ V-

*** Capacitors ***
C1 17 V+ 5p
C2 V- Bias4 5p
C3 V- EN1 5p
C4 Bias6 V+ 5p

M0 2 EN1 V+ V+ OPA2341/Ptypemos L=20u W=1u M=1
M1 2 2 11 11 OPA2341/Ptypemos L=1u W=10u M=10
M10 27 27 V+ V+ OPA2341/Ptypemos L=1u W=10u M=5
M11 Bias4 27 V+ V+ OPA2341/Ptypemos L=1u W=10u M=5
M12 28 28 27 27 OPA2341/Ptypemos L=1u W=10u M=1
M13 V- 28 Bias4 Bias4 OPA2341/Ptypemos L=1u W=10u M=5
M14 32 EN1 V+ V+ OPA2341/Ptypemos L=1u W=10u M=10
M15 31 Bias4 32 32 OPA2341/Ptypemos L=1u W=10u M=10
M16 33 EN1 V+ V+ OPA2341/Ptypemos L=1u W=10u M=10
M17 Bias3 Bias4 33 33 OPA2341/Ptypemos L=1u W=10u M=10
M18 Bias1 Bias1 13 13 OPA2341/Ptypemos L=1u W=10u M=10
M19 2 2 4 4 OPA2341/Ntypemos L=5u W=25u M=10
M2 10 EN1 V+ V+ OPA2341/Ptypemos L=1u W=10u M=5
M20 14 11 6 6 OPA2341/Ntypemos L=5u W=25u M=10
M21 18 11 19 19 OPA2341/Ntypemos L=5u W=25u M=10
M22 17 17 26 26 OPA2341/Ntypemos L=5u W=25u M=2
M23 28 Bias6 29 29 OPA2341/Ntypemos L=2u W=8u M=5
M24 29 31 V- V- OPA2341/Ntypemos L=2u W=8u M=5
M25 31 31 V- V- OPA2341/Ntypemos L=2u W=8u M=10
M26 Bias6 Bias6 Bias7 Bias7 OPA2341/Ntypemos L=2u W=8u M=10
M27 Bias5 Bias6 31 31 OPA2341/Ntypemos L=2u W=8u M=10
M28 31 EN2 V- V- OPA2341/Ntypemos L=2u W=8u M=10
M3 11 Bias4 10 10 OPA2341/Ptypemos L=1u W=10u M=5
M4 14 17 11 11 OPA2341/Ptypemos L=1u W=10u M=10
M5 22 EN1 V+ V+ OPA2341/Ptypemos L=1u W=10u M=5
M6 EN1 Bias4 22 22 OPA2341/Ptypemos L=1u W=10u M=5
M7 18 17 EN1 EN1 OPA2341/Ptypemos L=1u W=10u M=10
M8 2 2 17 17 OPA2341/Ptypemos L=1u W=10u M=10
M9 17 EN1 V+ V+ OPA2341/Ptypemos L=1u W=10u M=5

*** Transistors ***
Q1 V- V- 4 core/Qpnp 1
Q2 V- V- 6 core/Qpnp 1
Q3 V- V- 20 core/Qpnp 4
Q4 V- V- 26 core/Qpnp 1

*** Resistors ***
R1 20 19 7k
R2 13 V+ 50k
R3 Bias5 Bias1 20k
R4 0 Bias7 30k
R5 Bias6 Bias3 30k

.ENDS jfernan/BIAS

* OUTPUT_STAGE
*-------------------------------------------------------------------------------
* Generated by ChileCAD (Version 2.1.0, Release #23 'J' (Aug 7, 2005))
* on Tue Aug 09 10:35:16 MDT 2005. Netlist type: Xyce 2.x.
* From schematic: "OUTPUT_STAGE".
*-------------------------------------------------------------------------------

* on Tue Aug 09 10:34:45 MDT 2005. Netlist type: Xyce 2.x.
.SUBCKT jfernan/OUTPUT_STAGE EN1 EN2 EN3 EN4 EN6 O1 BIAS4 BIAS6 BIAS7 Vout_1 Vout_2 Vout_3 Vout_4 Vout_5 V+ V-

*** Capacitors ***
C1 36 15 3p
C3 Vout_5 21 7p
C4 23 Vout_5 7p
C5 BIAS7 11 10p

M0 16 16 V+ V+ OPA2341/Ptypemos L=500n W=10u M=100
M1 EN3 EN3 16 16 OPA2341/Ptypemos L=500n W=10u M=100
M10 4 6 V+ V+ OPA2341/Ptypemos L=2u W=20u M=5
M11 7 Bias4 4 4 OPA2341/Ptypemos L=2u W=20u M=5
M12 EN4 BIAS7 7 7 OPA2341/Ptypemos L=1u W=15u M=1
M13 30 11 7 7 OPA2341/Ptypemos L=1u W=15u M=1
M14 12 6 V+ V+ OPA2341/Ptypemos L=2u W=20u M=5
M15 13 6 V+ V+ OPA2341/Ptypemos L=2u W=20u M=5
M16 BIAS7 Bias4 12 12 OPA2341/Ptypemos L=2u W=20u M=5
M17 11 Bias4 13 13 OPA2341/Ptypemos L=2u W=20u M=5
M18 6 6 V+ V+ OPA2341/Ptypemos L=2u W=20u M=5
M19 14 EN3 V+ V+ OPA2341/Ptypemos L=1u W=9u M=40
M2 V- EN6 EN3 EN3 OPA2341/Ptypemos L=1u W=10u M=20
M20 Vout_5 EN3 V+ V+ OPA2341/Ptypemos L=1u W=9u M=40
M21 Vout_4 EN3 V+ V+ OPA2341/Ptypemos L=1u W=9u M=40
M22 Vout_3 EN3 V+ V+ OPA2341/Ptypemos L=1u W=9u M=40
M23 Vout_2 EN3 V+ V+ OPA2341/Ptypemos L=1u W=9u M=40
M24 Vout_1 EN3 V+ V+ OPA2341/Ptypemos L=1u W=9u M=40
M25 EN6 BIAS6 27 27 OPA2341/Ntypemos L=2u W=8u M=1
M26 27 EN2 V- V- OPA2341/Ntypemos L=2u W=8u M=1
M27 28 EN4 29 29 OPA2341/Ntypemos L=1u W=9u M=20
M28 3 3 5 5 OPA2341/Ntypemos L=1u W=12u M=4
M29 5 5 V- V- OPA2341/Ntypemos L=1u W=10u M=40
M3 EN6 EN6 16 16 OPA2341/Ptypemos L=1u W=10u M=20
M30 31 3 EN4 EN4 OPA2341/Ntypemos L=1u W=12u M=4
M31 9 BIAS7 25 25 OPA2341/Ntypemos L=1u W=10u M=1
M32 30 30 V- V- OPA2341/Ntypemos L=1u W=9u M=2
M33 EN4 30 V- V- OPA2341/Ntypemos L=1u W=9u M=2
M34 EN3 11 25 25 OPA2341/Ntypemos L=1u W=10u M=1
M35 25 Bias6 32 32 OPA2341/Ntypemos L=2u W=9u M=5
M36 32 EN2 V- V- OPA2341/Ntypemos L=2u W=9u M=5
M37 6 Bias6 33 33 OPA2341/Ntypemos L=2u W=9u M=4
M38 33 EN2 V- V- OPA2341/Ntypemos L=2u W=9u M=4
M39 26 11 BIAS7 BIAS7 OPA2341/Ntypemos L=1u W=10u M=1
M4 10 EN3 1 1 OPA2341/Ptypemos L=1u W=10u M=50
M40 BIAS7 BIAS7 10 10 OPA2341/Ntypemos L=1u W=12u M=3
M41 BIAS7 BIAS7 34 34 OPA2341/Ntypemos L=2u W=25u M=2
M42 BIAS7 BIAS7 29 29 OPA2341/Ntypemos L=1u W=12u M=3
M43 34 34 35 35 OPA2341/Ntypemos L=1u W=12u M=3
M44 14 EN4 V- V- OPA2341/Ntypemos L=1u W=9u M=40
M45 Vout_5 24 V- V- OPA2341/Ntypemos L=1u W=9u M=40
M46 Vout_4 24 V- V- OPA2341/Ntypemos L=1u W=9u M=40
M47 Vout_3 24 V- V- OPA2341/Ntypemos L=1u W=9u M=40
M48 Vout_2 24 V- V- OPA2341/Ntypemos L=1u W=9u M=40
M49 Vout_1 24 V- V- OPA2341/Ntypemos L=1u W=9u M=40
M5 2 EN1 V+ V+ OPA2341/Ptypemos L=1u W=10u M=1
M6 3 BIAS4 2 2 OPA2341/Ptypemos L=1u W=10u M=1
M7 5 5 EN4 EN4 OPA2341/Ptypemos L=500n W=10u M=100
M8 9 9 V+ V+ OPA2341/Ptypemos L=1u W=10u M=5
M9 EN3 9 V+ V+ OPA2341/Ptypemos L=1u W=10u M=5

*** Resistors ***
R1 O1 36 2k
R3 21 EN3 2k
R4 24 23 2k
R40 26 V+ 100
R42 V- 35 8k
R52A V- 10 9k
R52B 1 V+ 9k
R56A 31 V+ 100
R68A V- 29 9k
R68B 28 V+ 100
R9 15 Vout_5 500

r24  24  0 1e18
.ENDS jfernan/OUTPUT_STAGE

*** End Subcircuit Definitions ***

.END
