*================================================================
* Analograils Simulator Batch Output : Copyright 2005-2015
** TestBench Simulator = xyce
*================================================================
* --------- Global Parameters ---------------------------------
.global_param Vg = '0.35'
.global_param dvdd = '1.8'
.global_param i_vth = '1e-06'
.global_param logic_delay = '5e-11'
.global_param m = '0'
.global_param p1 = '0'
.global_param perio = '0'
.global_param period = '1e-09'
.global_param tf = '1e-11'
.global_param tr = '1e-11'
.global_param trise = '1e-11'
*================================================================
* --------- Global Simulator Settings--------------------------
.options nonlin  abstol=1e-12 maxstep=200
.options nonlin-hb abstol=1.0e-06
*================================================================
* --------- Corner Variables ----------------------------------
.global_param kcARlogic = '0.016'
.global_param kcpar = '1'
.global_param kfringecap = '1'
.global_param kmimcap = '1'
.global_param kmoscap = '1'
.global_param kodres = '1'
.global_param kpolyres = '1'
.global_param kr0ARlogic = '7000'
.global_param kr1ARlogic = '20000'
.global_param krpar = '1'
.options device temp=27 debuglevel=-100
*.include "models.hs"
.include "xyce_netlist.sp"

.options linsol-hb type=aztecoo  prec_type=block_jacobi AZ_tol=1e-9
.include "model.cir"
*================================================================

*================================================================
* Simulation Directives -----------------------------------------
*this analysis netlist was generated by new code
.options hbint tahb=1 startupperiods=0  numfreq=5,3 intmodmax=5
.hb 2.4e+09 2.41e+09
.print hb_fd
+vm(N__123) vp(N__123)
.print hb_td v(N__123)

*================================================================
.end
