Length 1000 RC chain circuit, adjoint transient sensitivity analysis

V0 1a 0 2.0V
Vin 1 1a sin(0.0 1.0  2e10)

R1 1 2 1.000000000000e+00
C1 2 0 1.000000000000e-15
R2 2 3 1.000000000000e+00
C2 3 0 1.000000000000e-15
R3 3 4 1.000000000000e+00
C3 4 0 1.000000000000e-15
R4 4 5 1.000000000000e+00
C4 5 0 1.000000000000e-15
R5 5 6 1.000000000000e+00
C5 6 0 1.000000000000e-15
R6 6 7 1.000000000000e+00
C6 7 0 1.000000000000e-15
R7 7 8 1.000000000000e+00
C7 8 0 1.000000000000e-15
R8 8 9 1.000000000000e+00
C8 9 0 1.000000000000e-15
R9 9 10 1.000000000000e+00
C9 10 0 1.000000000000e-15
R10 10 11 1.000000000000e+00
C10 11 0 1.000000000000e-15
R11 11 12 1.000000000000e+00
C11 12 0 1.000000000000e-15
R12 12 13 1.000000000000e+00
C12 13 0 1.000000000000e-15
R13 13 14 1.000000000000e+00
C13 14 0 1.000000000000e-15
R14 14 15 1.000000000000e+00
C14 15 0 1.000000000000e-15
R15 15 16 1.000000000000e+00
C15 16 0 1.000000000000e-15
R16 16 17 1.000000000000e+00
C16 17 0 1.000000000000e-15
R17 17 18 1.000000000000e+00
C17 18 0 1.000000000000e-15
R18 18 19 1.000000000000e+00
C18 19 0 1.000000000000e-15
R19 19 20 1.000000000000e+00
C19 20 0 1.000000000000e-15
R20 20 21 1.000000000000e+00
C20 21 0 1.000000000000e-15
R21 21 22 1.000000000000e+00
C21 22 0 1.000000000000e-15
R22 22 23 1.000000000000e+00
C22 23 0 1.000000000000e-15
R23 23 24 1.000000000000e+00
C23 24 0 1.000000000000e-15
R24 24 25 1.000000000000e+00
C24 25 0 1.000000000000e-15
R25 25 26 1.000000000000e+00
C25 26 0 1.000000000000e-15
R26 26 27 1.000000000000e+00
C26 27 0 1.000000000000e-15
R27 27 28 1.000000000000e+00
C27 28 0 1.000000000000e-15
R28 28 29 1.000000000000e+00
C28 29 0 1.000000000000e-15
R29 29 30 1.000000000000e+00
C29 30 0 1.000000000000e-15
R30 30 31 1.000000000000e+00
C30 31 0 1.000000000000e-15
R31 31 32 1.000000000000e+00
C31 32 0 1.000000000000e-15
R32 32 33 1.000000000000e+00
C32 33 0 1.000000000000e-15
R33 33 34 1.000000000000e+00
C33 34 0 1.000000000000e-15
R34 34 35 1.000000000000e+00
C34 35 0 1.000000000000e-15
R35 35 36 1.000000000000e+00
C35 36 0 1.000000000000e-15
R36 36 37 1.000000000000e+00
C36 37 0 1.000000000000e-15
R37 37 38 1.000000000000e+00
C37 38 0 1.000000000000e-15
R38 38 39 1.000000000000e+00
C38 39 0 1.000000000000e-15
R39 39 40 1.000000000000e+00
C39 40 0 1.000000000000e-15
R40 40 41 1.000000000000e+00
C40 41 0 1.000000000000e-15
R41 41 42 1.000000000000e+00
C41 42 0 1.000000000000e-15
R42 42 43 1.000000000000e+00
C42 43 0 1.000000000000e-15
R43 43 44 1.000000000000e+00
C43 44 0 1.000000000000e-15
R44 44 45 1.000000000000e+00
C44 45 0 1.000000000000e-15
R45 45 46 1.000000000000e+00
C45 46 0 1.000000000000e-15
R46 46 47 1.000000000000e+00
C46 47 0 1.000000000000e-15
R47 47 48 1.000000000000e+00
C47 48 0 1.000000000000e-15
R48 48 49 1.000000000000e+00
C48 49 0 1.000000000000e-15
R49 49 50 1.000000000000e+00
C49 50 0 1.000000000000e-15
R50 50 51 1.000000000000e+00
C50 51 0 1.000000000000e-15
R51 51 52 1.000000000000e+00
C51 52 0 1.000000000000e-15
R52 52 53 1.000000000000e+00
C52 53 0 1.000000000000e-15
R53 53 54 1.000000000000e+00
C53 54 0 1.000000000000e-15
R54 54 55 1.000000000000e+00
C54 55 0 1.000000000000e-15
R55 55 56 1.000000000000e+00
C55 56 0 1.000000000000e-15
R56 56 57 1.000000000000e+00
C56 57 0 1.000000000000e-15
R57 57 58 1.000000000000e+00
C57 58 0 1.000000000000e-15
R58 58 59 1.000000000000e+00
C58 59 0 1.000000000000e-15
R59 59 60 1.000000000000e+00
C59 60 0 1.000000000000e-15
R60 60 61 1.000000000000e+00
C60 61 0 1.000000000000e-15
R61 61 62 1.000000000000e+00
C61 62 0 1.000000000000e-15
R62 62 63 1.000000000000e+00
C62 63 0 1.000000000000e-15
R63 63 64 1.000000000000e+00
C63 64 0 1.000000000000e-15
R64 64 65 1.000000000000e+00
C64 65 0 1.000000000000e-15
R65 65 66 1.000000000000e+00
C65 66 0 1.000000000000e-15
R66 66 67 1.000000000000e+00
C66 67 0 1.000000000000e-15
R67 67 68 1.000000000000e+00
C67 68 0 1.000000000000e-15
R68 68 69 1.000000000000e+00
C68 69 0 1.000000000000e-15
R69 69 70 1.000000000000e+00
C69 70 0 1.000000000000e-15
R70 70 71 1.000000000000e+00
C70 71 0 1.000000000000e-15
R71 71 72 1.000000000000e+00
C71 72 0 1.000000000000e-15
R72 72 73 1.000000000000e+00
C72 73 0 1.000000000000e-15
R73 73 74 1.000000000000e+00
C73 74 0 1.000000000000e-15
R74 74 75 1.000000000000e+00
C74 75 0 1.000000000000e-15
R75 75 76 1.000000000000e+00
C75 76 0 1.000000000000e-15
R76 76 77 1.000000000000e+00
C76 77 0 1.000000000000e-15
R77 77 78 1.000000000000e+00
C77 78 0 1.000000000000e-15
R78 78 79 1.000000000000e+00
C78 79 0 1.000000000000e-15
R79 79 80 1.000000000000e+00
C79 80 0 1.000000000000e-15
R80 80 81 1.000000000000e+00
C80 81 0 1.000000000000e-15
R81 81 82 1.000000000000e+00
C81 82 0 1.000000000000e-15
R82 82 83 1.000000000000e+00
C82 83 0 1.000000000000e-15
R83 83 84 1.000000000000e+00
C83 84 0 1.000000000000e-15
R84 84 85 1.000000000000e+00
C84 85 0 1.000000000000e-15
R85 85 86 1.000000000000e+00
C85 86 0 1.000000000000e-15
R86 86 87 1.000000000000e+00
C86 87 0 1.000000000000e-15
R87 87 88 1.000000000000e+00
C87 88 0 1.000000000000e-15
R88 88 89 1.000000000000e+00
C88 89 0 1.000000000000e-15
R89 89 90 1.000000000000e+00
C89 90 0 1.000000000000e-15
R90 90 91 1.000000000000e+00
C90 91 0 1.000000000000e-15
R91 91 92 1.000000000000e+00
C91 92 0 1.000000000000e-15
R92 92 93 1.000000000000e+00
C92 93 0 1.000000000000e-15
R93 93 94 1.000000000000e+00
C93 94 0 1.000000000000e-15
R94 94 95 1.000000000000e+00
C94 95 0 1.000000000000e-15
R95 95 96 1.000000000000e+00
C95 96 0 1.000000000000e-15
R96 96 97 1.000000000000e+00
C96 97 0 1.000000000000e-15
R97 97 98 1.000000000000e+00
C97 98 0 1.000000000000e-15
R98 98 99 1.000000000000e+00
C98 99 0 1.000000000000e-15
R99 99 100 1.000000000000e+00
C99 100 0 1.000000000000e-15
R100 100 101 1.000000000000e+00
C100 101 0 1.000000000000e-15
R101 101 102 1.000000000000e+00
C101 102 0 1.000000000000e-15
R102 102 103 1.000000000000e+00
C102 103 0 1.000000000000e-15
R103 103 104 1.000000000000e+00
C103 104 0 1.000000000000e-15
R104 104 105 1.000000000000e+00
C104 105 0 1.000000000000e-15
R105 105 106 1.000000000000e+00
C105 106 0 1.000000000000e-15
R106 106 107 1.000000000000e+00
C106 107 0 1.000000000000e-15
R107 107 108 1.000000000000e+00
C107 108 0 1.000000000000e-15
R108 108 109 1.000000000000e+00
C108 109 0 1.000000000000e-15
R109 109 110 1.000000000000e+00
C109 110 0 1.000000000000e-15
R110 110 111 1.000000000000e+00
C110 111 0 1.000000000000e-15
R111 111 112 1.000000000000e+00
C111 112 0 1.000000000000e-15
R112 112 113 1.000000000000e+00
C112 113 0 1.000000000000e-15
R113 113 114 1.000000000000e+00
C113 114 0 1.000000000000e-15
R114 114 115 1.000000000000e+00
C114 115 0 1.000000000000e-15
R115 115 116 1.000000000000e+00
C115 116 0 1.000000000000e-15
R116 116 117 1.000000000000e+00
C116 117 0 1.000000000000e-15
R117 117 118 1.000000000000e+00
C117 118 0 1.000000000000e-15
R118 118 119 1.000000000000e+00
C118 119 0 1.000000000000e-15
R119 119 120 1.000000000000e+00
C119 120 0 1.000000000000e-15
R120 120 121 1.000000000000e+00
C120 121 0 1.000000000000e-15
R121 121 122 1.000000000000e+00
C121 122 0 1.000000000000e-15
R122 122 123 1.000000000000e+00
C122 123 0 1.000000000000e-15
R123 123 124 1.000000000000e+00
C123 124 0 1.000000000000e-15
R124 124 125 1.000000000000e+00
C124 125 0 1.000000000000e-15
R125 125 126 1.000000000000e+00
C125 126 0 1.000000000000e-15
R126 126 127 1.000000000000e+00
C126 127 0 1.000000000000e-15
R127 127 128 1.000000000000e+00
C127 128 0 1.000000000000e-15
R128 128 129 1.000000000000e+00
C128 129 0 1.000000000000e-15
R129 129 130 1.000000000000e+00
C129 130 0 1.000000000000e-15
R130 130 131 1.000000000000e+00
C130 131 0 1.000000000000e-15
R131 131 132 1.000000000000e+00
C131 132 0 1.000000000000e-15
R132 132 133 1.000000000000e+00
C132 133 0 1.000000000000e-15
R133 133 134 1.000000000000e+00
C133 134 0 1.000000000000e-15
R134 134 135 1.000000000000e+00
C134 135 0 1.000000000000e-15
R135 135 136 1.000000000000e+00
C135 136 0 1.000000000000e-15
R136 136 137 1.000000000000e+00
C136 137 0 1.000000000000e-15
R137 137 138 1.000000000000e+00
C137 138 0 1.000000000000e-15
R138 138 139 1.000000000000e+00
C138 139 0 1.000000000000e-15
R139 139 140 1.000000000000e+00
C139 140 0 1.000000000000e-15
R140 140 141 1.000000000000e+00
C140 141 0 1.000000000000e-15
R141 141 142 1.000000000000e+00
C141 142 0 1.000000000000e-15
R142 142 143 1.000000000000e+00
C142 143 0 1.000000000000e-15
R143 143 144 1.000000000000e+00
C143 144 0 1.000000000000e-15
R144 144 145 1.000000000000e+00
C144 145 0 1.000000000000e-15
R145 145 146 1.000000000000e+00
C145 146 0 1.000000000000e-15
R146 146 147 1.000000000000e+00
C146 147 0 1.000000000000e-15
R147 147 148 1.000000000000e+00
C147 148 0 1.000000000000e-15
R148 148 149 1.000000000000e+00
C148 149 0 1.000000000000e-15
R149 149 150 1.000000000000e+00
C149 150 0 1.000000000000e-15
R150 150 151 1.000000000000e+00
C150 151 0 1.000000000000e-15
R151 151 152 1.000000000000e+00
C151 152 0 1.000000000000e-15
R152 152 153 1.000000000000e+00
C152 153 0 1.000000000000e-15
R153 153 154 1.000000000000e+00
C153 154 0 1.000000000000e-15
R154 154 155 1.000000000000e+00
C154 155 0 1.000000000000e-15
R155 155 156 1.000000000000e+00
C155 156 0 1.000000000000e-15
R156 156 157 1.000000000000e+00
C156 157 0 1.000000000000e-15
R157 157 158 1.000000000000e+00
C157 158 0 1.000000000000e-15
R158 158 159 1.000000000000e+00
C158 159 0 1.000000000000e-15
R159 159 160 1.000000000000e+00
C159 160 0 1.000000000000e-15
R160 160 161 1.000000000000e+00
C160 161 0 1.000000000000e-15
R161 161 162 1.000000000000e+00
C161 162 0 1.000000000000e-15
R162 162 163 1.000000000000e+00
C162 163 0 1.000000000000e-15
R163 163 164 1.000000000000e+00
C163 164 0 1.000000000000e-15
R164 164 165 1.000000000000e+00
C164 165 0 1.000000000000e-15
R165 165 166 1.000000000000e+00
C165 166 0 1.000000000000e-15
R166 166 167 1.000000000000e+00
C166 167 0 1.000000000000e-15
R167 167 168 1.000000000000e+00
C167 168 0 1.000000000000e-15
R168 168 169 1.000000000000e+00
C168 169 0 1.000000000000e-15
R169 169 170 1.000000000000e+00
C169 170 0 1.000000000000e-15
R170 170 171 1.000000000000e+00
C170 171 0 1.000000000000e-15
R171 171 172 1.000000000000e+00
C171 172 0 1.000000000000e-15
R172 172 173 1.000000000000e+00
C172 173 0 1.000000000000e-15
R173 173 174 1.000000000000e+00
C173 174 0 1.000000000000e-15
R174 174 175 1.000000000000e+00
C174 175 0 1.000000000000e-15
R175 175 176 1.000000000000e+00
C175 176 0 1.000000000000e-15
R176 176 177 1.000000000000e+00
C176 177 0 1.000000000000e-15
R177 177 178 1.000000000000e+00
C177 178 0 1.000000000000e-15
R178 178 179 1.000000000000e+00
C178 179 0 1.000000000000e-15
R179 179 180 1.000000000000e+00
C179 180 0 1.000000000000e-15
R180 180 181 1.000000000000e+00
C180 181 0 1.000000000000e-15
R181 181 182 1.000000000000e+00
C181 182 0 1.000000000000e-15
R182 182 183 1.000000000000e+00
C182 183 0 1.000000000000e-15
R183 183 184 1.000000000000e+00
C183 184 0 1.000000000000e-15
R184 184 185 1.000000000000e+00
C184 185 0 1.000000000000e-15
R185 185 186 1.000000000000e+00
C185 186 0 1.000000000000e-15
R186 186 187 1.000000000000e+00
C186 187 0 1.000000000000e-15
R187 187 188 1.000000000000e+00
C187 188 0 1.000000000000e-15
R188 188 189 1.000000000000e+00
C188 189 0 1.000000000000e-15
R189 189 190 1.000000000000e+00
C189 190 0 1.000000000000e-15
R190 190 191 1.000000000000e+00
C190 191 0 1.000000000000e-15
R191 191 192 1.000000000000e+00
C191 192 0 1.000000000000e-15
R192 192 193 1.000000000000e+00
C192 193 0 1.000000000000e-15
R193 193 194 1.000000000000e+00
C193 194 0 1.000000000000e-15
R194 194 195 1.000000000000e+00
C194 195 0 1.000000000000e-15
R195 195 196 1.000000000000e+00
C195 196 0 1.000000000000e-15
R196 196 197 1.000000000000e+00
C196 197 0 1.000000000000e-15
R197 197 198 1.000000000000e+00
C197 198 0 1.000000000000e-15
R198 198 199 1.000000000000e+00
C198 199 0 1.000000000000e-15
R199 199 200 1.000000000000e+00
C199 200 0 1.000000000000e-15
R200 200 201 1.000000000000e+00
C200 201 0 1.000000000000e-15
R201 201 202 1.000000000000e+00
C201 202 0 1.000000000000e-15
R202 202 203 1.000000000000e+00
C202 203 0 1.000000000000e-15
R203 203 204 1.000000000000e+00
C203 204 0 1.000000000000e-15
R204 204 205 1.000000000000e+00
C204 205 0 1.000000000000e-15
R205 205 206 1.000000000000e+00
C205 206 0 1.000000000000e-15
R206 206 207 1.000000000000e+00
C206 207 0 1.000000000000e-15
R207 207 208 1.000000000000e+00
C207 208 0 1.000000000000e-15
R208 208 209 1.000000000000e+00
C208 209 0 1.000000000000e-15
R209 209 210 1.000000000000e+00
C209 210 0 1.000000000000e-15
R210 210 211 1.000000000000e+00
C210 211 0 1.000000000000e-15
R211 211 212 1.000000000000e+00
C211 212 0 1.000000000000e-15
R212 212 213 1.000000000000e+00
C212 213 0 1.000000000000e-15
R213 213 214 1.000000000000e+00
C213 214 0 1.000000000000e-15
R214 214 215 1.000000000000e+00
C214 215 0 1.000000000000e-15
R215 215 216 1.000000000000e+00
C215 216 0 1.000000000000e-15
R216 216 217 1.000000000000e+00
C216 217 0 1.000000000000e-15
R217 217 218 1.000000000000e+00
C217 218 0 1.000000000000e-15
R218 218 219 1.000000000000e+00
C218 219 0 1.000000000000e-15
R219 219 220 1.000000000000e+00
C219 220 0 1.000000000000e-15
R220 220 221 1.000000000000e+00
C220 221 0 1.000000000000e-15
R221 221 222 1.000000000000e+00
C221 222 0 1.000000000000e-15
R222 222 223 1.000000000000e+00
C222 223 0 1.000000000000e-15
R223 223 224 1.000000000000e+00
C223 224 0 1.000000000000e-15
R224 224 225 1.000000000000e+00
C224 225 0 1.000000000000e-15
R225 225 226 1.000000000000e+00
C225 226 0 1.000000000000e-15
R226 226 227 1.000000000000e+00
C226 227 0 1.000000000000e-15
R227 227 228 1.000000000000e+00
C227 228 0 1.000000000000e-15
R228 228 229 1.000000000000e+00
C228 229 0 1.000000000000e-15
R229 229 230 1.000000000000e+00
C229 230 0 1.000000000000e-15
R230 230 231 1.000000000000e+00
C230 231 0 1.000000000000e-15
R231 231 232 1.000000000000e+00
C231 232 0 1.000000000000e-15
R232 232 233 1.000000000000e+00
C232 233 0 1.000000000000e-15
R233 233 234 1.000000000000e+00
C233 234 0 1.000000000000e-15
R234 234 235 1.000000000000e+00
C234 235 0 1.000000000000e-15
R235 235 236 1.000000000000e+00
C235 236 0 1.000000000000e-15
R236 236 237 1.000000000000e+00
C236 237 0 1.000000000000e-15
R237 237 238 1.000000000000e+00
C237 238 0 1.000000000000e-15
R238 238 239 1.000000000000e+00
C238 239 0 1.000000000000e-15
R239 239 240 1.000000000000e+00
C239 240 0 1.000000000000e-15
R240 240 241 1.000000000000e+00
C240 241 0 1.000000000000e-15
R241 241 242 1.000000000000e+00
C241 242 0 1.000000000000e-15
R242 242 243 1.000000000000e+00
C242 243 0 1.000000000000e-15
R243 243 244 1.000000000000e+00
C243 244 0 1.000000000000e-15
R244 244 245 1.000000000000e+00
C244 245 0 1.000000000000e-15
R245 245 246 1.000000000000e+00
C245 246 0 1.000000000000e-15
R246 246 247 1.000000000000e+00
C246 247 0 1.000000000000e-15
R247 247 248 1.000000000000e+00
C247 248 0 1.000000000000e-15
R248 248 249 1.000000000000e+00
C248 249 0 1.000000000000e-15
R249 249 250 1.000000000000e+00
C249 250 0 1.000000000000e-15
R250 250 251 1.000000000000e+00
C250 251 0 1.000000000000e-15
R251 251 252 1.000000000000e+00
C251 252 0 1.000000000000e-15
R252 252 253 1.000000000000e+00
C252 253 0 1.000000000000e-15
R253 253 254 1.000000000000e+00
C253 254 0 1.000000000000e-15
R254 254 255 1.000000000000e+00
C254 255 0 1.000000000000e-15
R255 255 256 1.000000000000e+00
C255 256 0 1.000000000000e-15
R256 256 257 1.000000000000e+00
C256 257 0 1.000000000000e-15
R257 257 258 1.000000000000e+00
C257 258 0 1.000000000000e-15
R258 258 259 1.000000000000e+00
C258 259 0 1.000000000000e-15
R259 259 260 1.000000000000e+00
C259 260 0 1.000000000000e-15
R260 260 261 1.000000000000e+00
C260 261 0 1.000000000000e-15
R261 261 262 1.000000000000e+00
C261 262 0 1.000000000000e-15
R262 262 263 1.000000000000e+00
C262 263 0 1.000000000000e-15
R263 263 264 1.000000000000e+00
C263 264 0 1.000000000000e-15
R264 264 265 1.000000000000e+00
C264 265 0 1.000000000000e-15
R265 265 266 1.000000000000e+00
C265 266 0 1.000000000000e-15
R266 266 267 1.000000000000e+00
C266 267 0 1.000000000000e-15
R267 267 268 1.000000000000e+00
C267 268 0 1.000000000000e-15
R268 268 269 1.000000000000e+00
C268 269 0 1.000000000000e-15
R269 269 270 1.000000000000e+00
C269 270 0 1.000000000000e-15
R270 270 271 1.000000000000e+00
C270 271 0 1.000000000000e-15
R271 271 272 1.000000000000e+00
C271 272 0 1.000000000000e-15
R272 272 273 1.000000000000e+00
C272 273 0 1.000000000000e-15
R273 273 274 1.000000000000e+00
C273 274 0 1.000000000000e-15
R274 274 275 1.000000000000e+00
C274 275 0 1.000000000000e-15
R275 275 276 1.000000000000e+00
C275 276 0 1.000000000000e-15
R276 276 277 1.000000000000e+00
C276 277 0 1.000000000000e-15
R277 277 278 1.000000000000e+00
C277 278 0 1.000000000000e-15
R278 278 279 1.000000000000e+00
C278 279 0 1.000000000000e-15
R279 279 280 1.000000000000e+00
C279 280 0 1.000000000000e-15
R280 280 281 1.000000000000e+00
C280 281 0 1.000000000000e-15
R281 281 282 1.000000000000e+00
C281 282 0 1.000000000000e-15
R282 282 283 1.000000000000e+00
C282 283 0 1.000000000000e-15
R283 283 284 1.000000000000e+00
C283 284 0 1.000000000000e-15
R284 284 285 1.000000000000e+00
C284 285 0 1.000000000000e-15
R285 285 286 1.000000000000e+00
C285 286 0 1.000000000000e-15
R286 286 287 1.000000000000e+00
C286 287 0 1.000000000000e-15
R287 287 288 1.000000000000e+00
C287 288 0 1.000000000000e-15
R288 288 289 1.000000000000e+00
C288 289 0 1.000000000000e-15
R289 289 290 1.000000000000e+00
C289 290 0 1.000000000000e-15
R290 290 291 1.000000000000e+00
C290 291 0 1.000000000000e-15
R291 291 292 1.000000000000e+00
C291 292 0 1.000000000000e-15
R292 292 293 1.000000000000e+00
C292 293 0 1.000000000000e-15
R293 293 294 1.000000000000e+00
C293 294 0 1.000000000000e-15
R294 294 295 1.000000000000e+00
C294 295 0 1.000000000000e-15
R295 295 296 1.000000000000e+00
C295 296 0 1.000000000000e-15
R296 296 297 1.000000000000e+00
C296 297 0 1.000000000000e-15
R297 297 298 1.000000000000e+00
C297 298 0 1.000000000000e-15
R298 298 299 1.000000000000e+00
C298 299 0 1.000000000000e-15
R299 299 300 1.000000000000e+00
C299 300 0 1.000000000000e-15
R300 300 301 1.000000000000e+00
C300 301 0 1.000000000000e-15
R301 301 302 1.000000000000e+00
C301 302 0 1.000000000000e-15
R302 302 303 1.000000000000e+00
C302 303 0 1.000000000000e-15
R303 303 304 1.000000000000e+00
C303 304 0 1.000000000000e-15
R304 304 305 1.000000000000e+00
C304 305 0 1.000000000000e-15
R305 305 306 1.000000000000e+00
C305 306 0 1.000000000000e-15
R306 306 307 1.000000000000e+00
C306 307 0 1.000000000000e-15
R307 307 308 1.000000000000e+00
C307 308 0 1.000000000000e-15
R308 308 309 1.000000000000e+00
C308 309 0 1.000000000000e-15
R309 309 310 1.000000000000e+00
C309 310 0 1.000000000000e-15
R310 310 311 1.000000000000e+00
C310 311 0 1.000000000000e-15
R311 311 312 1.000000000000e+00
C311 312 0 1.000000000000e-15
R312 312 313 1.000000000000e+00
C312 313 0 1.000000000000e-15
R313 313 314 1.000000000000e+00
C313 314 0 1.000000000000e-15
R314 314 315 1.000000000000e+00
C314 315 0 1.000000000000e-15
R315 315 316 1.000000000000e+00
C315 316 0 1.000000000000e-15
R316 316 317 1.000000000000e+00
C316 317 0 1.000000000000e-15
R317 317 318 1.000000000000e+00
C317 318 0 1.000000000000e-15
R318 318 319 1.000000000000e+00
C318 319 0 1.000000000000e-15
R319 319 320 1.000000000000e+00
C319 320 0 1.000000000000e-15
R320 320 321 1.000000000000e+00
C320 321 0 1.000000000000e-15
R321 321 322 1.000000000000e+00
C321 322 0 1.000000000000e-15
R322 322 323 1.000000000000e+00
C322 323 0 1.000000000000e-15
R323 323 324 1.000000000000e+00
C323 324 0 1.000000000000e-15
R324 324 325 1.000000000000e+00
C324 325 0 1.000000000000e-15
R325 325 326 1.000000000000e+00
C325 326 0 1.000000000000e-15
R326 326 327 1.000000000000e+00
C326 327 0 1.000000000000e-15
R327 327 328 1.000000000000e+00
C327 328 0 1.000000000000e-15
R328 328 329 1.000000000000e+00
C328 329 0 1.000000000000e-15
R329 329 330 1.000000000000e+00
C329 330 0 1.000000000000e-15
R330 330 331 1.000000000000e+00
C330 331 0 1.000000000000e-15
R331 331 332 1.000000000000e+00
C331 332 0 1.000000000000e-15
R332 332 333 1.000000000000e+00
C332 333 0 1.000000000000e-15
R333 333 334 1.000000000000e+00
C333 334 0 1.000000000000e-15
R334 334 335 1.000000000000e+00
C334 335 0 1.000000000000e-15
R335 335 336 1.000000000000e+00
C335 336 0 1.000000000000e-15
R336 336 337 1.000000000000e+00
C336 337 0 1.000000000000e-15
R337 337 338 1.000000000000e+00
C337 338 0 1.000000000000e-15
R338 338 339 1.000000000000e+00
C338 339 0 1.000000000000e-15
R339 339 340 1.000000000000e+00
C339 340 0 1.000000000000e-15
R340 340 341 1.000000000000e+00
C340 341 0 1.000000000000e-15
R341 341 342 1.000000000000e+00
C341 342 0 1.000000000000e-15
R342 342 343 1.000000000000e+00
C342 343 0 1.000000000000e-15
R343 343 344 1.000000000000e+00
C343 344 0 1.000000000000e-15
R344 344 345 1.000000000000e+00
C344 345 0 1.000000000000e-15
R345 345 346 1.000000000000e+00
C345 346 0 1.000000000000e-15
R346 346 347 1.000000000000e+00
C346 347 0 1.000000000000e-15
R347 347 348 1.000000000000e+00
C347 348 0 1.000000000000e-15
R348 348 349 1.000000000000e+00
C348 349 0 1.000000000000e-15
R349 349 350 1.000000000000e+00
C349 350 0 1.000000000000e-15
R350 350 351 1.000000000000e+00
C350 351 0 1.000000000000e-15
R351 351 352 1.000000000000e+00
C351 352 0 1.000000000000e-15
R352 352 353 1.000000000000e+00
C352 353 0 1.000000000000e-15
R353 353 354 1.000000000000e+00
C353 354 0 1.000000000000e-15
R354 354 355 1.000000000000e+00
C354 355 0 1.000000000000e-15
R355 355 356 1.000000000000e+00
C355 356 0 1.000000000000e-15
R356 356 357 1.000000000000e+00
C356 357 0 1.000000000000e-15
R357 357 358 1.000000000000e+00
C357 358 0 1.000000000000e-15
R358 358 359 1.000000000000e+00
C358 359 0 1.000000000000e-15
R359 359 360 1.000000000000e+00
C359 360 0 1.000000000000e-15
R360 360 361 1.000000000000e+00
C360 361 0 1.000000000000e-15
R361 361 362 1.000000000000e+00
C361 362 0 1.000000000000e-15
R362 362 363 1.000000000000e+00
C362 363 0 1.000000000000e-15
R363 363 364 1.000000000000e+00
C363 364 0 1.000000000000e-15
R364 364 365 1.000000000000e+00
C364 365 0 1.000000000000e-15
R365 365 366 1.000000000000e+00
C365 366 0 1.000000000000e-15
R366 366 367 1.000000000000e+00
C366 367 0 1.000000000000e-15
R367 367 368 1.000000000000e+00
C367 368 0 1.000000000000e-15
R368 368 369 1.000000000000e+00
C368 369 0 1.000000000000e-15
R369 369 370 1.000000000000e+00
C369 370 0 1.000000000000e-15
R370 370 371 1.000000000000e+00
C370 371 0 1.000000000000e-15
R371 371 372 1.000000000000e+00
C371 372 0 1.000000000000e-15
R372 372 373 1.000000000000e+00
C372 373 0 1.000000000000e-15
R373 373 374 1.000000000000e+00
C373 374 0 1.000000000000e-15
R374 374 375 1.000000000000e+00
C374 375 0 1.000000000000e-15
R375 375 376 1.000000000000e+00
C375 376 0 1.000000000000e-15
R376 376 377 1.000000000000e+00
C376 377 0 1.000000000000e-15
R377 377 378 1.000000000000e+00
C377 378 0 1.000000000000e-15
R378 378 379 1.000000000000e+00
C378 379 0 1.000000000000e-15
R379 379 380 1.000000000000e+00
C379 380 0 1.000000000000e-15
R380 380 381 1.000000000000e+00
C380 381 0 1.000000000000e-15
R381 381 382 1.000000000000e+00
C381 382 0 1.000000000000e-15
R382 382 383 1.000000000000e+00
C382 383 0 1.000000000000e-15
R383 383 384 1.000000000000e+00
C383 384 0 1.000000000000e-15
R384 384 385 1.000000000000e+00
C384 385 0 1.000000000000e-15
R385 385 386 1.000000000000e+00
C385 386 0 1.000000000000e-15
R386 386 387 1.000000000000e+00
C386 387 0 1.000000000000e-15
R387 387 388 1.000000000000e+00
C387 388 0 1.000000000000e-15
R388 388 389 1.000000000000e+00
C388 389 0 1.000000000000e-15
R389 389 390 1.000000000000e+00
C389 390 0 1.000000000000e-15
R390 390 391 1.000000000000e+00
C390 391 0 1.000000000000e-15
R391 391 392 1.000000000000e+00
C391 392 0 1.000000000000e-15
R392 392 393 1.000000000000e+00
C392 393 0 1.000000000000e-15
R393 393 394 1.000000000000e+00
C393 394 0 1.000000000000e-15
R394 394 395 1.000000000000e+00
C394 395 0 1.000000000000e-15
R395 395 396 1.000000000000e+00
C395 396 0 1.000000000000e-15
R396 396 397 1.000000000000e+00
C396 397 0 1.000000000000e-15
R397 397 398 1.000000000000e+00
C397 398 0 1.000000000000e-15
R398 398 399 1.000000000000e+00
C398 399 0 1.000000000000e-15
R399 399 400 1.000000000000e+00
C399 400 0 1.000000000000e-15
R400 400 401 1.000000000000e+00
C400 401 0 1.000000000000e-15
R401 401 402 1.000000000000e+00
C401 402 0 1.000000000000e-15
R402 402 403 1.000000000000e+00
C402 403 0 1.000000000000e-15
R403 403 404 1.000000000000e+00
C403 404 0 1.000000000000e-15
R404 404 405 1.000000000000e+00
C404 405 0 1.000000000000e-15
R405 405 406 1.000000000000e+00
C405 406 0 1.000000000000e-15
R406 406 407 1.000000000000e+00
C406 407 0 1.000000000000e-15
R407 407 408 1.000000000000e+00
C407 408 0 1.000000000000e-15
R408 408 409 1.000000000000e+00
C408 409 0 1.000000000000e-15
R409 409 410 1.000000000000e+00
C409 410 0 1.000000000000e-15
R410 410 411 1.000000000000e+00
C410 411 0 1.000000000000e-15
R411 411 412 1.000000000000e+00
C411 412 0 1.000000000000e-15
R412 412 413 1.000000000000e+00
C412 413 0 1.000000000000e-15
R413 413 414 1.000000000000e+00
C413 414 0 1.000000000000e-15
R414 414 415 1.000000000000e+00
C414 415 0 1.000000000000e-15
R415 415 416 1.000000000000e+00
C415 416 0 1.000000000000e-15
R416 416 417 1.000000000000e+00
C416 417 0 1.000000000000e-15
R417 417 418 1.000000000000e+00
C417 418 0 1.000000000000e-15
R418 418 419 1.000000000000e+00
C418 419 0 1.000000000000e-15
R419 419 420 1.000000000000e+00
C419 420 0 1.000000000000e-15
R420 420 421 1.000000000000e+00
C420 421 0 1.000000000000e-15
R421 421 422 1.000000000000e+00
C421 422 0 1.000000000000e-15
R422 422 423 1.000000000000e+00
C422 423 0 1.000000000000e-15
R423 423 424 1.000000000000e+00
C423 424 0 1.000000000000e-15
R424 424 425 1.000000000000e+00
C424 425 0 1.000000000000e-15
R425 425 426 1.000000000000e+00
C425 426 0 1.000000000000e-15
R426 426 427 1.000000000000e+00
C426 427 0 1.000000000000e-15
R427 427 428 1.000000000000e+00
C427 428 0 1.000000000000e-15
R428 428 429 1.000000000000e+00
C428 429 0 1.000000000000e-15
R429 429 430 1.000000000000e+00
C429 430 0 1.000000000000e-15
R430 430 431 1.000000000000e+00
C430 431 0 1.000000000000e-15
R431 431 432 1.000000000000e+00
C431 432 0 1.000000000000e-15
R432 432 433 1.000000000000e+00
C432 433 0 1.000000000000e-15
R433 433 434 1.000000000000e+00
C433 434 0 1.000000000000e-15
R434 434 435 1.000000000000e+00
C434 435 0 1.000000000000e-15
R435 435 436 1.000000000000e+00
C435 436 0 1.000000000000e-15
R436 436 437 1.000000000000e+00
C436 437 0 1.000000000000e-15
R437 437 438 1.000000000000e+00
C437 438 0 1.000000000000e-15
R438 438 439 1.000000000000e+00
C438 439 0 1.000000000000e-15
R439 439 440 1.000000000000e+00
C439 440 0 1.000000000000e-15
R440 440 441 1.000000000000e+00
C440 441 0 1.000000000000e-15
R441 441 442 1.000000000000e+00
C441 442 0 1.000000000000e-15
R442 442 443 1.000000000000e+00
C442 443 0 1.000000000000e-15
R443 443 444 1.000000000000e+00
C443 444 0 1.000000000000e-15
R444 444 445 1.000000000000e+00
C444 445 0 1.000000000000e-15
R445 445 446 1.000000000000e+00
C445 446 0 1.000000000000e-15
R446 446 447 1.000000000000e+00
C446 447 0 1.000000000000e-15
R447 447 448 1.000000000000e+00
C447 448 0 1.000000000000e-15
R448 448 449 1.000000000000e+00
C448 449 0 1.000000000000e-15
R449 449 450 1.000000000000e+00
C449 450 0 1.000000000000e-15
R450 450 451 1.000000000000e+00
C450 451 0 1.000000000000e-15
R451 451 452 1.000000000000e+00
C451 452 0 1.000000000000e-15
R452 452 453 1.000000000000e+00
C452 453 0 1.000000000000e-15
R453 453 454 1.000000000000e+00
C453 454 0 1.000000000000e-15
R454 454 455 1.000000000000e+00
C454 455 0 1.000000000000e-15
R455 455 456 1.000000000000e+00
C455 456 0 1.000000000000e-15
R456 456 457 1.000000000000e+00
C456 457 0 1.000000000000e-15
R457 457 458 1.000000000000e+00
C457 458 0 1.000000000000e-15
R458 458 459 1.000000000000e+00
C458 459 0 1.000000000000e-15
R459 459 460 1.000000000000e+00
C459 460 0 1.000000000000e-15
R460 460 461 1.000000000000e+00
C460 461 0 1.000000000000e-15
R461 461 462 1.000000000000e+00
C461 462 0 1.000000000000e-15
R462 462 463 1.000000000000e+00
C462 463 0 1.000000000000e-15
R463 463 464 1.000000000000e+00
C463 464 0 1.000000000000e-15
R464 464 465 1.000000000000e+00
C464 465 0 1.000000000000e-15
R465 465 466 1.000000000000e+00
C465 466 0 1.000000000000e-15
R466 466 467 1.000000000000e+00
C466 467 0 1.000000000000e-15
R467 467 468 1.000000000000e+00
C467 468 0 1.000000000000e-15
R468 468 469 1.000000000000e+00
C468 469 0 1.000000000000e-15
R469 469 470 1.000000000000e+00
C469 470 0 1.000000000000e-15
R470 470 471 1.000000000000e+00
C470 471 0 1.000000000000e-15
R471 471 472 1.000000000000e+00
C471 472 0 1.000000000000e-15
R472 472 473 1.000000000000e+00
C472 473 0 1.000000000000e-15
R473 473 474 1.000000000000e+00
C473 474 0 1.000000000000e-15
R474 474 475 1.000000000000e+00
C474 475 0 1.000000000000e-15
R475 475 476 1.000000000000e+00
C475 476 0 1.000000000000e-15
R476 476 477 1.000000000000e+00
C476 477 0 1.000000000000e-15
R477 477 478 1.000000000000e+00
C477 478 0 1.000000000000e-15
R478 478 479 1.000000000000e+00
C478 479 0 1.000000000000e-15
R479 479 480 1.000000000000e+00
C479 480 0 1.000000000000e-15
R480 480 481 1.000000000000e+00
C480 481 0 1.000000000000e-15
R481 481 482 1.000000000000e+00
C481 482 0 1.000000000000e-15
R482 482 483 1.000000000000e+00
C482 483 0 1.000000000000e-15
R483 483 484 1.000000000000e+00
C483 484 0 1.000000000000e-15
R484 484 485 1.000000000000e+00
C484 485 0 1.000000000000e-15
R485 485 486 1.000000000000e+00
C485 486 0 1.000000000000e-15
R486 486 487 1.000000000000e+00
C486 487 0 1.000000000000e-15
R487 487 488 1.000000000000e+00
C487 488 0 1.000000000000e-15
R488 488 489 1.000000000000e+00
C488 489 0 1.000000000000e-15
R489 489 490 1.000000000000e+00
C489 490 0 1.000000000000e-15
R490 490 491 1.000000000000e+00
C490 491 0 1.000000000000e-15
R491 491 492 1.000000000000e+00
C491 492 0 1.000000000000e-15
R492 492 493 1.000000000000e+00
C492 493 0 1.000000000000e-15
R493 493 494 1.000000000000e+00
C493 494 0 1.000000000000e-15
R494 494 495 1.000000000000e+00
C494 495 0 1.000000000000e-15
R495 495 496 1.000000000000e+00
C495 496 0 1.000000000000e-15
R496 496 497 1.000000000000e+00
C496 497 0 1.000000000000e-15
R497 497 498 1.000000000000e+00
C497 498 0 1.000000000000e-15
R498 498 499 1.000000000000e+00
C498 499 0 1.000000000000e-15
R499 499 500 1.000000000000e+00
C499 500 0 1.000000000000e-15
R500 500 501 1.000000000000e+00
C500 501 0 1.000000000000e-15
R501 501 502 1.000000000000e+00
C501 502 0 1.000000000000e-15
R502 502 503 1.000000000000e+00
C502 503 0 1.000000000000e-15
R503 503 504 1.000000000000e+00
C503 504 0 1.000000000000e-15
R504 504 505 1.000000000000e+00
C504 505 0 1.000000000000e-15
R505 505 506 1.000000000000e+00
C505 506 0 1.000000000000e-15
R506 506 507 1.000000000000e+00
C506 507 0 1.000000000000e-15
R507 507 508 1.000000000000e+00
C507 508 0 1.000000000000e-15
R508 508 509 1.000000000000e+00
C508 509 0 1.000000000000e-15
R509 509 510 1.000000000000e+00
C509 510 0 1.000000000000e-15
R510 510 511 1.000000000000e+00
C510 511 0 1.000000000000e-15
R511 511 512 1.000000000000e+00
C511 512 0 1.000000000000e-15
R512 512 513 1.000000000000e+00
C512 513 0 1.000000000000e-15
R513 513 514 1.000000000000e+00
C513 514 0 1.000000000000e-15
R514 514 515 1.000000000000e+00
C514 515 0 1.000000000000e-15
R515 515 516 1.000000000000e+00
C515 516 0 1.000000000000e-15
R516 516 517 1.000000000000e+00
C516 517 0 1.000000000000e-15
R517 517 518 1.000000000000e+00
C517 518 0 1.000000000000e-15
R518 518 519 1.000000000000e+00
C518 519 0 1.000000000000e-15
R519 519 520 1.000000000000e+00
C519 520 0 1.000000000000e-15
R520 520 521 1.000000000000e+00
C520 521 0 1.000000000000e-15
R521 521 522 1.000000000000e+00
C521 522 0 1.000000000000e-15
R522 522 523 1.000000000000e+00
C522 523 0 1.000000000000e-15
R523 523 524 1.000000000000e+00
C523 524 0 1.000000000000e-15
R524 524 525 1.000000000000e+00
C524 525 0 1.000000000000e-15
R525 525 526 1.000000000000e+00
C525 526 0 1.000000000000e-15
R526 526 527 1.000000000000e+00
C526 527 0 1.000000000000e-15
R527 527 528 1.000000000000e+00
C527 528 0 1.000000000000e-15
R528 528 529 1.000000000000e+00
C528 529 0 1.000000000000e-15
R529 529 530 1.000000000000e+00
C529 530 0 1.000000000000e-15
R530 530 531 1.000000000000e+00
C530 531 0 1.000000000000e-15
R531 531 532 1.000000000000e+00
C531 532 0 1.000000000000e-15
R532 532 533 1.000000000000e+00
C532 533 0 1.000000000000e-15
R533 533 534 1.000000000000e+00
C533 534 0 1.000000000000e-15
R534 534 535 1.000000000000e+00
C534 535 0 1.000000000000e-15
R535 535 536 1.000000000000e+00
C535 536 0 1.000000000000e-15
R536 536 537 1.000000000000e+00
C536 537 0 1.000000000000e-15
R537 537 538 1.000000000000e+00
C537 538 0 1.000000000000e-15
R538 538 539 1.000000000000e+00
C538 539 0 1.000000000000e-15
R539 539 540 1.000000000000e+00
C539 540 0 1.000000000000e-15
R540 540 541 1.000000000000e+00
C540 541 0 1.000000000000e-15
R541 541 542 1.000000000000e+00
C541 542 0 1.000000000000e-15
R542 542 543 1.000000000000e+00
C542 543 0 1.000000000000e-15
R543 543 544 1.000000000000e+00
C543 544 0 1.000000000000e-15
R544 544 545 1.000000000000e+00
C544 545 0 1.000000000000e-15
R545 545 546 1.000000000000e+00
C545 546 0 1.000000000000e-15
R546 546 547 1.000000000000e+00
C546 547 0 1.000000000000e-15
R547 547 548 1.000000000000e+00
C547 548 0 1.000000000000e-15
R548 548 549 1.000000000000e+00
C548 549 0 1.000000000000e-15
R549 549 550 1.000000000000e+00
C549 550 0 1.000000000000e-15
R550 550 551 1.000000000000e+00
C550 551 0 1.000000000000e-15
R551 551 552 1.000000000000e+00
C551 552 0 1.000000000000e-15
R552 552 553 1.000000000000e+00
C552 553 0 1.000000000000e-15
R553 553 554 1.000000000000e+00
C553 554 0 1.000000000000e-15
R554 554 555 1.000000000000e+00
C554 555 0 1.000000000000e-15
R555 555 556 1.000000000000e+00
C555 556 0 1.000000000000e-15
R556 556 557 1.000000000000e+00
C556 557 0 1.000000000000e-15
R557 557 558 1.000000000000e+00
C557 558 0 1.000000000000e-15
R558 558 559 1.000000000000e+00
C558 559 0 1.000000000000e-15
R559 559 560 1.000000000000e+00
C559 560 0 1.000000000000e-15
R560 560 561 1.000000000000e+00
C560 561 0 1.000000000000e-15
R561 561 562 1.000000000000e+00
C561 562 0 1.000000000000e-15
R562 562 563 1.000000000000e+00
C562 563 0 1.000000000000e-15
R563 563 564 1.000000000000e+00
C563 564 0 1.000000000000e-15
R564 564 565 1.000000000000e+00
C564 565 0 1.000000000000e-15
R565 565 566 1.000000000000e+00
C565 566 0 1.000000000000e-15
R566 566 567 1.000000000000e+00
C566 567 0 1.000000000000e-15
R567 567 568 1.000000000000e+00
C567 568 0 1.000000000000e-15
R568 568 569 1.000000000000e+00
C568 569 0 1.000000000000e-15
R569 569 570 1.000000000000e+00
C569 570 0 1.000000000000e-15
R570 570 571 1.000000000000e+00
C570 571 0 1.000000000000e-15
R571 571 572 1.000000000000e+00
C571 572 0 1.000000000000e-15
R572 572 573 1.000000000000e+00
C572 573 0 1.000000000000e-15
R573 573 574 1.000000000000e+00
C573 574 0 1.000000000000e-15
R574 574 575 1.000000000000e+00
C574 575 0 1.000000000000e-15
R575 575 576 1.000000000000e+00
C575 576 0 1.000000000000e-15
R576 576 577 1.000000000000e+00
C576 577 0 1.000000000000e-15
R577 577 578 1.000000000000e+00
C577 578 0 1.000000000000e-15
R578 578 579 1.000000000000e+00
C578 579 0 1.000000000000e-15
R579 579 580 1.000000000000e+00
C579 580 0 1.000000000000e-15
R580 580 581 1.000000000000e+00
C580 581 0 1.000000000000e-15
R581 581 582 1.000000000000e+00
C581 582 0 1.000000000000e-15
R582 582 583 1.000000000000e+00
C582 583 0 1.000000000000e-15
R583 583 584 1.000000000000e+00
C583 584 0 1.000000000000e-15
R584 584 585 1.000000000000e+00
C584 585 0 1.000000000000e-15
R585 585 586 1.000000000000e+00
C585 586 0 1.000000000000e-15
R586 586 587 1.000000000000e+00
C586 587 0 1.000000000000e-15
R587 587 588 1.000000000000e+00
C587 588 0 1.000000000000e-15
R588 588 589 1.000000000000e+00
C588 589 0 1.000000000000e-15
R589 589 590 1.000000000000e+00
C589 590 0 1.000000000000e-15
R590 590 591 1.000000000000e+00
C590 591 0 1.000000000000e-15
R591 591 592 1.000000000000e+00
C591 592 0 1.000000000000e-15
R592 592 593 1.000000000000e+00
C592 593 0 1.000000000000e-15
R593 593 594 1.000000000000e+00
C593 594 0 1.000000000000e-15
R594 594 595 1.000000000000e+00
C594 595 0 1.000000000000e-15
R595 595 596 1.000000000000e+00
C595 596 0 1.000000000000e-15
R596 596 597 1.000000000000e+00
C596 597 0 1.000000000000e-15
R597 597 598 1.000000000000e+00
C597 598 0 1.000000000000e-15
R598 598 599 1.000000000000e+00
C598 599 0 1.000000000000e-15
R599 599 600 1.000000000000e+00
C599 600 0 1.000000000000e-15
R600 600 601 1.000000000000e+00
C600 601 0 1.000000000000e-15
R601 601 602 1.000000000000e+00
C601 602 0 1.000000000000e-15
R602 602 603 1.000000000000e+00
C602 603 0 1.000000000000e-15
R603 603 604 1.000000000000e+00
C603 604 0 1.000000000000e-15
R604 604 605 1.000000000000e+00
C604 605 0 1.000000000000e-15
R605 605 606 1.000000000000e+00
C605 606 0 1.000000000000e-15
R606 606 607 1.000000000000e+00
C606 607 0 1.000000000000e-15
R607 607 608 1.000000000000e+00
C607 608 0 1.000000000000e-15
R608 608 609 1.000000000000e+00
C608 609 0 1.000000000000e-15
R609 609 610 1.000000000000e+00
C609 610 0 1.000000000000e-15
R610 610 611 1.000000000000e+00
C610 611 0 1.000000000000e-15
R611 611 612 1.000000000000e+00
C611 612 0 1.000000000000e-15
R612 612 613 1.000000000000e+00
C612 613 0 1.000000000000e-15
R613 613 614 1.000000000000e+00
C613 614 0 1.000000000000e-15
R614 614 615 1.000000000000e+00
C614 615 0 1.000000000000e-15
R615 615 616 1.000000000000e+00
C615 616 0 1.000000000000e-15
R616 616 617 1.000000000000e+00
C616 617 0 1.000000000000e-15
R617 617 618 1.000000000000e+00
C617 618 0 1.000000000000e-15
R618 618 619 1.000000000000e+00
C618 619 0 1.000000000000e-15
R619 619 620 1.000000000000e+00
C619 620 0 1.000000000000e-15
R620 620 621 1.000000000000e+00
C620 621 0 1.000000000000e-15
R621 621 622 1.000000000000e+00
C621 622 0 1.000000000000e-15
R622 622 623 1.000000000000e+00
C622 623 0 1.000000000000e-15
R623 623 624 1.000000000000e+00
C623 624 0 1.000000000000e-15
R624 624 625 1.000000000000e+00
C624 625 0 1.000000000000e-15
R625 625 626 1.000000000000e+00
C625 626 0 1.000000000000e-15
R626 626 627 1.000000000000e+00
C626 627 0 1.000000000000e-15
R627 627 628 1.000000000000e+00
C627 628 0 1.000000000000e-15
R628 628 629 1.000000000000e+00
C628 629 0 1.000000000000e-15
R629 629 630 1.000000000000e+00
C629 630 0 1.000000000000e-15
R630 630 631 1.000000000000e+00
C630 631 0 1.000000000000e-15
R631 631 632 1.000000000000e+00
C631 632 0 1.000000000000e-15
R632 632 633 1.000000000000e+00
C632 633 0 1.000000000000e-15
R633 633 634 1.000000000000e+00
C633 634 0 1.000000000000e-15
R634 634 635 1.000000000000e+00
C634 635 0 1.000000000000e-15
R635 635 636 1.000000000000e+00
C635 636 0 1.000000000000e-15
R636 636 637 1.000000000000e+00
C636 637 0 1.000000000000e-15
R637 637 638 1.000000000000e+00
C637 638 0 1.000000000000e-15
R638 638 639 1.000000000000e+00
C638 639 0 1.000000000000e-15
R639 639 640 1.000000000000e+00
C639 640 0 1.000000000000e-15
R640 640 641 1.000000000000e+00
C640 641 0 1.000000000000e-15
R641 641 642 1.000000000000e+00
C641 642 0 1.000000000000e-15
R642 642 643 1.000000000000e+00
C642 643 0 1.000000000000e-15
R643 643 644 1.000000000000e+00
C643 644 0 1.000000000000e-15
R644 644 645 1.000000000000e+00
C644 645 0 1.000000000000e-15
R645 645 646 1.000000000000e+00
C645 646 0 1.000000000000e-15
R646 646 647 1.000000000000e+00
C646 647 0 1.000000000000e-15
R647 647 648 1.000000000000e+00
C647 648 0 1.000000000000e-15
R648 648 649 1.000000000000e+00
C648 649 0 1.000000000000e-15
R649 649 650 1.000000000000e+00
C649 650 0 1.000000000000e-15
R650 650 651 1.000000000000e+00
C650 651 0 1.000000000000e-15
R651 651 652 1.000000000000e+00
C651 652 0 1.000000000000e-15
R652 652 653 1.000000000000e+00
C652 653 0 1.000000000000e-15
R653 653 654 1.000000000000e+00
C653 654 0 1.000000000000e-15
R654 654 655 1.000000000000e+00
C654 655 0 1.000000000000e-15
R655 655 656 1.000000000000e+00
C655 656 0 1.000000000000e-15
R656 656 657 1.000000000000e+00
C656 657 0 1.000000000000e-15
R657 657 658 1.000000000000e+00
C657 658 0 1.000000000000e-15
R658 658 659 1.000000000000e+00
C658 659 0 1.000000000000e-15
R659 659 660 1.000000000000e+00
C659 660 0 1.000000000000e-15
R660 660 661 1.000000000000e+00
C660 661 0 1.000000000000e-15
R661 661 662 1.000000000000e+00
C661 662 0 1.000000000000e-15
R662 662 663 1.000000000000e+00
C662 663 0 1.000000000000e-15
R663 663 664 1.000000000000e+00
C663 664 0 1.000000000000e-15
R664 664 665 1.000000000000e+00
C664 665 0 1.000000000000e-15
R665 665 666 1.000000000000e+00
C665 666 0 1.000000000000e-15
R666 666 667 1.000000000000e+00
C666 667 0 1.000000000000e-15
R667 667 668 1.000000000000e+00
C667 668 0 1.000000000000e-15
R668 668 669 1.000000000000e+00
C668 669 0 1.000000000000e-15
R669 669 670 1.000000000000e+00
C669 670 0 1.000000000000e-15
R670 670 671 1.000000000000e+00
C670 671 0 1.000000000000e-15
R671 671 672 1.000000000000e+00
C671 672 0 1.000000000000e-15
R672 672 673 1.000000000000e+00
C672 673 0 1.000000000000e-15
R673 673 674 1.000000000000e+00
C673 674 0 1.000000000000e-15
R674 674 675 1.000000000000e+00
C674 675 0 1.000000000000e-15
R675 675 676 1.000000000000e+00
C675 676 0 1.000000000000e-15
R676 676 677 1.000000000000e+00
C676 677 0 1.000000000000e-15
R677 677 678 1.000000000000e+00
C677 678 0 1.000000000000e-15
R678 678 679 1.000000000000e+00
C678 679 0 1.000000000000e-15
R679 679 680 1.000000000000e+00
C679 680 0 1.000000000000e-15
R680 680 681 1.000000000000e+00
C680 681 0 1.000000000000e-15
R681 681 682 1.000000000000e+00
C681 682 0 1.000000000000e-15
R682 682 683 1.000000000000e+00
C682 683 0 1.000000000000e-15
R683 683 684 1.000000000000e+00
C683 684 0 1.000000000000e-15
R684 684 685 1.000000000000e+00
C684 685 0 1.000000000000e-15
R685 685 686 1.000000000000e+00
C685 686 0 1.000000000000e-15
R686 686 687 1.000000000000e+00
C686 687 0 1.000000000000e-15
R687 687 688 1.000000000000e+00
C687 688 0 1.000000000000e-15
R688 688 689 1.000000000000e+00
C688 689 0 1.000000000000e-15
R689 689 690 1.000000000000e+00
C689 690 0 1.000000000000e-15
R690 690 691 1.000000000000e+00
C690 691 0 1.000000000000e-15
R691 691 692 1.000000000000e+00
C691 692 0 1.000000000000e-15
R692 692 693 1.000000000000e+00
C692 693 0 1.000000000000e-15
R693 693 694 1.000000000000e+00
C693 694 0 1.000000000000e-15
R694 694 695 1.000000000000e+00
C694 695 0 1.000000000000e-15
R695 695 696 1.000000000000e+00
C695 696 0 1.000000000000e-15
R696 696 697 1.000000000000e+00
C696 697 0 1.000000000000e-15
R697 697 698 1.000000000000e+00
C697 698 0 1.000000000000e-15
R698 698 699 1.000000000000e+00
C698 699 0 1.000000000000e-15
R699 699 700 1.000000000000e+00
C699 700 0 1.000000000000e-15
R700 700 701 1.000000000000e+00
C700 701 0 1.000000000000e-15
R701 701 702 1.000000000000e+00
C701 702 0 1.000000000000e-15
R702 702 703 1.000000000000e+00
C702 703 0 1.000000000000e-15
R703 703 704 1.000000000000e+00
C703 704 0 1.000000000000e-15
R704 704 705 1.000000000000e+00
C704 705 0 1.000000000000e-15
R705 705 706 1.000000000000e+00
C705 706 0 1.000000000000e-15
R706 706 707 1.000000000000e+00
C706 707 0 1.000000000000e-15
R707 707 708 1.000000000000e+00
C707 708 0 1.000000000000e-15
R708 708 709 1.000000000000e+00
C708 709 0 1.000000000000e-15
R709 709 710 1.000000000000e+00
C709 710 0 1.000000000000e-15
R710 710 711 1.000000000000e+00
C710 711 0 1.000000000000e-15
R711 711 712 1.000000000000e+00
C711 712 0 1.000000000000e-15
R712 712 713 1.000000000000e+00
C712 713 0 1.000000000000e-15
R713 713 714 1.000000000000e+00
C713 714 0 1.000000000000e-15
R714 714 715 1.000000000000e+00
C714 715 0 1.000000000000e-15
R715 715 716 1.000000000000e+00
C715 716 0 1.000000000000e-15
R716 716 717 1.000000000000e+00
C716 717 0 1.000000000000e-15
R717 717 718 1.000000000000e+00
C717 718 0 1.000000000000e-15
R718 718 719 1.000000000000e+00
C718 719 0 1.000000000000e-15
R719 719 720 1.000000000000e+00
C719 720 0 1.000000000000e-15
R720 720 721 1.000000000000e+00
C720 721 0 1.000000000000e-15
R721 721 722 1.000000000000e+00
C721 722 0 1.000000000000e-15
R722 722 723 1.000000000000e+00
C722 723 0 1.000000000000e-15
R723 723 724 1.000000000000e+00
C723 724 0 1.000000000000e-15
R724 724 725 1.000000000000e+00
C724 725 0 1.000000000000e-15
R725 725 726 1.000000000000e+00
C725 726 0 1.000000000000e-15
R726 726 727 1.000000000000e+00
C726 727 0 1.000000000000e-15
R727 727 728 1.000000000000e+00
C727 728 0 1.000000000000e-15
R728 728 729 1.000000000000e+00
C728 729 0 1.000000000000e-15
R729 729 730 1.000000000000e+00
C729 730 0 1.000000000000e-15
R730 730 731 1.000000000000e+00
C730 731 0 1.000000000000e-15
R731 731 732 1.000000000000e+00
C731 732 0 1.000000000000e-15
R732 732 733 1.000000000000e+00
C732 733 0 1.000000000000e-15
R733 733 734 1.000000000000e+00
C733 734 0 1.000000000000e-15
R734 734 735 1.000000000000e+00
C734 735 0 1.000000000000e-15
R735 735 736 1.000000000000e+00
C735 736 0 1.000000000000e-15
R736 736 737 1.000000000000e+00
C736 737 0 1.000000000000e-15
R737 737 738 1.000000000000e+00
C737 738 0 1.000000000000e-15
R738 738 739 1.000000000000e+00
C738 739 0 1.000000000000e-15
R739 739 740 1.000000000000e+00
C739 740 0 1.000000000000e-15
R740 740 741 1.000000000000e+00
C740 741 0 1.000000000000e-15
R741 741 742 1.000000000000e+00
C741 742 0 1.000000000000e-15
R742 742 743 1.000000000000e+00
C742 743 0 1.000000000000e-15
R743 743 744 1.000000000000e+00
C743 744 0 1.000000000000e-15
R744 744 745 1.000000000000e+00
C744 745 0 1.000000000000e-15
R745 745 746 1.000000000000e+00
C745 746 0 1.000000000000e-15
R746 746 747 1.000000000000e+00
C746 747 0 1.000000000000e-15
R747 747 748 1.000000000000e+00
C747 748 0 1.000000000000e-15
R748 748 749 1.000000000000e+00
C748 749 0 1.000000000000e-15
R749 749 750 1.000000000000e+00
C749 750 0 1.000000000000e-15
R750 750 751 1.000000000000e+00
C750 751 0 1.000000000000e-15
R751 751 752 1.000000000000e+00
C751 752 0 1.000000000000e-15
R752 752 753 1.000000000000e+00
C752 753 0 1.000000000000e-15
R753 753 754 1.000000000000e+00
C753 754 0 1.000000000000e-15
R754 754 755 1.000000000000e+00
C754 755 0 1.000000000000e-15
R755 755 756 1.000000000000e+00
C755 756 0 1.000000000000e-15
R756 756 757 1.000000000000e+00
C756 757 0 1.000000000000e-15
R757 757 758 1.000000000000e+00
C757 758 0 1.000000000000e-15
R758 758 759 1.000000000000e+00
C758 759 0 1.000000000000e-15
R759 759 760 1.000000000000e+00
C759 760 0 1.000000000000e-15
R760 760 761 1.000000000000e+00
C760 761 0 1.000000000000e-15
R761 761 762 1.000000000000e+00
C761 762 0 1.000000000000e-15
R762 762 763 1.000000000000e+00
C762 763 0 1.000000000000e-15
R763 763 764 1.000000000000e+00
C763 764 0 1.000000000000e-15
R764 764 765 1.000000000000e+00
C764 765 0 1.000000000000e-15
R765 765 766 1.000000000000e+00
C765 766 0 1.000000000000e-15
R766 766 767 1.000000000000e+00
C766 767 0 1.000000000000e-15
R767 767 768 1.000000000000e+00
C767 768 0 1.000000000000e-15
R768 768 769 1.000000000000e+00
C768 769 0 1.000000000000e-15
R769 769 770 1.000000000000e+00
C769 770 0 1.000000000000e-15
R770 770 771 1.000000000000e+00
C770 771 0 1.000000000000e-15
R771 771 772 1.000000000000e+00
C771 772 0 1.000000000000e-15
R772 772 773 1.000000000000e+00
C772 773 0 1.000000000000e-15
R773 773 774 1.000000000000e+00
C773 774 0 1.000000000000e-15
R774 774 775 1.000000000000e+00
C774 775 0 1.000000000000e-15
R775 775 776 1.000000000000e+00
C775 776 0 1.000000000000e-15
R776 776 777 1.000000000000e+00
C776 777 0 1.000000000000e-15
R777 777 778 1.000000000000e+00
C777 778 0 1.000000000000e-15
R778 778 779 1.000000000000e+00
C778 779 0 1.000000000000e-15
R779 779 780 1.000000000000e+00
C779 780 0 1.000000000000e-15
R780 780 781 1.000000000000e+00
C780 781 0 1.000000000000e-15
R781 781 782 1.000000000000e+00
C781 782 0 1.000000000000e-15
R782 782 783 1.000000000000e+00
C782 783 0 1.000000000000e-15
R783 783 784 1.000000000000e+00
C783 784 0 1.000000000000e-15
R784 784 785 1.000000000000e+00
C784 785 0 1.000000000000e-15
R785 785 786 1.000000000000e+00
C785 786 0 1.000000000000e-15
R786 786 787 1.000000000000e+00
C786 787 0 1.000000000000e-15
R787 787 788 1.000000000000e+00
C787 788 0 1.000000000000e-15
R788 788 789 1.000000000000e+00
C788 789 0 1.000000000000e-15
R789 789 790 1.000000000000e+00
C789 790 0 1.000000000000e-15
R790 790 791 1.000000000000e+00
C790 791 0 1.000000000000e-15
R791 791 792 1.000000000000e+00
C791 792 0 1.000000000000e-15
R792 792 793 1.000000000000e+00
C792 793 0 1.000000000000e-15
R793 793 794 1.000000000000e+00
C793 794 0 1.000000000000e-15
R794 794 795 1.000000000000e+00
C794 795 0 1.000000000000e-15
R795 795 796 1.000000000000e+00
C795 796 0 1.000000000000e-15
R796 796 797 1.000000000000e+00
C796 797 0 1.000000000000e-15
R797 797 798 1.000000000000e+00
C797 798 0 1.000000000000e-15
R798 798 799 1.000000000000e+00
C798 799 0 1.000000000000e-15
R799 799 800 1.000000000000e+00
C799 800 0 1.000000000000e-15
R800 800 801 1.000000000000e+00
C800 801 0 1.000000000000e-15
R801 801 802 1.000000000000e+00
C801 802 0 1.000000000000e-15
R802 802 803 1.000000000000e+00
C802 803 0 1.000000000000e-15
R803 803 804 1.000000000000e+00
C803 804 0 1.000000000000e-15
R804 804 805 1.000000000000e+00
C804 805 0 1.000000000000e-15
R805 805 806 1.000000000000e+00
C805 806 0 1.000000000000e-15
R806 806 807 1.000000000000e+00
C806 807 0 1.000000000000e-15
R807 807 808 1.000000000000e+00
C807 808 0 1.000000000000e-15
R808 808 809 1.000000000000e+00
C808 809 0 1.000000000000e-15
R809 809 810 1.000000000000e+00
C809 810 0 1.000000000000e-15
R810 810 811 1.000000000000e+00
C810 811 0 1.000000000000e-15
R811 811 812 1.000000000000e+00
C811 812 0 1.000000000000e-15
R812 812 813 1.000000000000e+00
C812 813 0 1.000000000000e-15
R813 813 814 1.000000000000e+00
C813 814 0 1.000000000000e-15
R814 814 815 1.000000000000e+00
C814 815 0 1.000000000000e-15
R815 815 816 1.000000000000e+00
C815 816 0 1.000000000000e-15
R816 816 817 1.000000000000e+00
C816 817 0 1.000000000000e-15
R817 817 818 1.000000000000e+00
C817 818 0 1.000000000000e-15
R818 818 819 1.000000000000e+00
C818 819 0 1.000000000000e-15
R819 819 820 1.000000000000e+00
C819 820 0 1.000000000000e-15
R820 820 821 1.000000000000e+00
C820 821 0 1.000000000000e-15
R821 821 822 1.000000000000e+00
C821 822 0 1.000000000000e-15
R822 822 823 1.000000000000e+00
C822 823 0 1.000000000000e-15
R823 823 824 1.000000000000e+00
C823 824 0 1.000000000000e-15
R824 824 825 1.000000000000e+00
C824 825 0 1.000000000000e-15
R825 825 826 1.000000000000e+00
C825 826 0 1.000000000000e-15
R826 826 827 1.000000000000e+00
C826 827 0 1.000000000000e-15
R827 827 828 1.000000000000e+00
C827 828 0 1.000000000000e-15
R828 828 829 1.000000000000e+00
C828 829 0 1.000000000000e-15
R829 829 830 1.000000000000e+00
C829 830 0 1.000000000000e-15
R830 830 831 1.000000000000e+00
C830 831 0 1.000000000000e-15
R831 831 832 1.000000000000e+00
C831 832 0 1.000000000000e-15
R832 832 833 1.000000000000e+00
C832 833 0 1.000000000000e-15
R833 833 834 1.000000000000e+00
C833 834 0 1.000000000000e-15
R834 834 835 1.000000000000e+00
C834 835 0 1.000000000000e-15
R835 835 836 1.000000000000e+00
C835 836 0 1.000000000000e-15
R836 836 837 1.000000000000e+00
C836 837 0 1.000000000000e-15
R837 837 838 1.000000000000e+00
C837 838 0 1.000000000000e-15
R838 838 839 1.000000000000e+00
C838 839 0 1.000000000000e-15
R839 839 840 1.000000000000e+00
C839 840 0 1.000000000000e-15
R840 840 841 1.000000000000e+00
C840 841 0 1.000000000000e-15
R841 841 842 1.000000000000e+00
C841 842 0 1.000000000000e-15
R842 842 843 1.000000000000e+00
C842 843 0 1.000000000000e-15
R843 843 844 1.000000000000e+00
C843 844 0 1.000000000000e-15
R844 844 845 1.000000000000e+00
C844 845 0 1.000000000000e-15
R845 845 846 1.000000000000e+00
C845 846 0 1.000000000000e-15
R846 846 847 1.000000000000e+00
C846 847 0 1.000000000000e-15
R847 847 848 1.000000000000e+00
C847 848 0 1.000000000000e-15
R848 848 849 1.000000000000e+00
C848 849 0 1.000000000000e-15
R849 849 850 1.000000000000e+00
C849 850 0 1.000000000000e-15
R850 850 851 1.000000000000e+00
C850 851 0 1.000000000000e-15
R851 851 852 1.000000000000e+00
C851 852 0 1.000000000000e-15
R852 852 853 1.000000000000e+00
C852 853 0 1.000000000000e-15
R853 853 854 1.000000000000e+00
C853 854 0 1.000000000000e-15
R854 854 855 1.000000000000e+00
C854 855 0 1.000000000000e-15
R855 855 856 1.000000000000e+00
C855 856 0 1.000000000000e-15
R856 856 857 1.000000000000e+00
C856 857 0 1.000000000000e-15
R857 857 858 1.000000000000e+00
C857 858 0 1.000000000000e-15
R858 858 859 1.000000000000e+00
C858 859 0 1.000000000000e-15
R859 859 860 1.000000000000e+00
C859 860 0 1.000000000000e-15
R860 860 861 1.000000000000e+00
C860 861 0 1.000000000000e-15
R861 861 862 1.000000000000e+00
C861 862 0 1.000000000000e-15
R862 862 863 1.000000000000e+00
C862 863 0 1.000000000000e-15
R863 863 864 1.000000000000e+00
C863 864 0 1.000000000000e-15
R864 864 865 1.000000000000e+00
C864 865 0 1.000000000000e-15
R865 865 866 1.000000000000e+00
C865 866 0 1.000000000000e-15
R866 866 867 1.000000000000e+00
C866 867 0 1.000000000000e-15
R867 867 868 1.000000000000e+00
C867 868 0 1.000000000000e-15
R868 868 869 1.000000000000e+00
C868 869 0 1.000000000000e-15
R869 869 870 1.000000000000e+00
C869 870 0 1.000000000000e-15
R870 870 871 1.000000000000e+00
C870 871 0 1.000000000000e-15
R871 871 872 1.000000000000e+00
C871 872 0 1.000000000000e-15
R872 872 873 1.000000000000e+00
C872 873 0 1.000000000000e-15
R873 873 874 1.000000000000e+00
C873 874 0 1.000000000000e-15
R874 874 875 1.000000000000e+00
C874 875 0 1.000000000000e-15
R875 875 876 1.000000000000e+00
C875 876 0 1.000000000000e-15
R876 876 877 1.000000000000e+00
C876 877 0 1.000000000000e-15
R877 877 878 1.000000000000e+00
C877 878 0 1.000000000000e-15
R878 878 879 1.000000000000e+00
C878 879 0 1.000000000000e-15
R879 879 880 1.000000000000e+00
C879 880 0 1.000000000000e-15
R880 880 881 1.000000000000e+00
C880 881 0 1.000000000000e-15
R881 881 882 1.000000000000e+00
C881 882 0 1.000000000000e-15
R882 882 883 1.000000000000e+00
C882 883 0 1.000000000000e-15
R883 883 884 1.000000000000e+00
C883 884 0 1.000000000000e-15
R884 884 885 1.000000000000e+00
C884 885 0 1.000000000000e-15
R885 885 886 1.000000000000e+00
C885 886 0 1.000000000000e-15
R886 886 887 1.000000000000e+00
C886 887 0 1.000000000000e-15
R887 887 888 1.000000000000e+00
C887 888 0 1.000000000000e-15
R888 888 889 1.000000000000e+00
C888 889 0 1.000000000000e-15
R889 889 890 1.000000000000e+00
C889 890 0 1.000000000000e-15
R890 890 891 1.000000000000e+00
C890 891 0 1.000000000000e-15
R891 891 892 1.000000000000e+00
C891 892 0 1.000000000000e-15
R892 892 893 1.000000000000e+00
C892 893 0 1.000000000000e-15
R893 893 894 1.000000000000e+00
C893 894 0 1.000000000000e-15
R894 894 895 1.000000000000e+00
C894 895 0 1.000000000000e-15
R895 895 896 1.000000000000e+00
C895 896 0 1.000000000000e-15
R896 896 897 1.000000000000e+00
C896 897 0 1.000000000000e-15
R897 897 898 1.000000000000e+00
C897 898 0 1.000000000000e-15
R898 898 899 1.000000000000e+00
C898 899 0 1.000000000000e-15
R899 899 900 1.000000000000e+00
C899 900 0 1.000000000000e-15
R900 900 901 1.000000000000e+00
C900 901 0 1.000000000000e-15
R901 901 902 1.000000000000e+00
C901 902 0 1.000000000000e-15
R902 902 903 1.000000000000e+00
C902 903 0 1.000000000000e-15
R903 903 904 1.000000000000e+00
C903 904 0 1.000000000000e-15
R904 904 905 1.000000000000e+00
C904 905 0 1.000000000000e-15
R905 905 906 1.000000000000e+00
C905 906 0 1.000000000000e-15
R906 906 907 1.000000000000e+00
C906 907 0 1.000000000000e-15
R907 907 908 1.000000000000e+00
C907 908 0 1.000000000000e-15
R908 908 909 1.000000000000e+00
C908 909 0 1.000000000000e-15
R909 909 910 1.000000000000e+00
C909 910 0 1.000000000000e-15
R910 910 911 1.000000000000e+00
C910 911 0 1.000000000000e-15
R911 911 912 1.000000000000e+00
C911 912 0 1.000000000000e-15
R912 912 913 1.000000000000e+00
C912 913 0 1.000000000000e-15
R913 913 914 1.000000000000e+00
C913 914 0 1.000000000000e-15
R914 914 915 1.000000000000e+00
C914 915 0 1.000000000000e-15
R915 915 916 1.000000000000e+00
C915 916 0 1.000000000000e-15
R916 916 917 1.000000000000e+00
C916 917 0 1.000000000000e-15
R917 917 918 1.000000000000e+00
C917 918 0 1.000000000000e-15
R918 918 919 1.000000000000e+00
C918 919 0 1.000000000000e-15
R919 919 920 1.000000000000e+00
C919 920 0 1.000000000000e-15
R920 920 921 1.000000000000e+00
C920 921 0 1.000000000000e-15
R921 921 922 1.000000000000e+00
C921 922 0 1.000000000000e-15
R922 922 923 1.000000000000e+00
C922 923 0 1.000000000000e-15
R923 923 924 1.000000000000e+00
C923 924 0 1.000000000000e-15
R924 924 925 1.000000000000e+00
C924 925 0 1.000000000000e-15
R925 925 926 1.000000000000e+00
C925 926 0 1.000000000000e-15
R926 926 927 1.000000000000e+00
C926 927 0 1.000000000000e-15
R927 927 928 1.000000000000e+00
C927 928 0 1.000000000000e-15
R928 928 929 1.000000000000e+00
C928 929 0 1.000000000000e-15
R929 929 930 1.000000000000e+00
C929 930 0 1.000000000000e-15
R930 930 931 1.000000000000e+00
C930 931 0 1.000000000000e-15
R931 931 932 1.000000000000e+00
C931 932 0 1.000000000000e-15
R932 932 933 1.000000000000e+00
C932 933 0 1.000000000000e-15
R933 933 934 1.000000000000e+00
C933 934 0 1.000000000000e-15
R934 934 935 1.000000000000e+00
C934 935 0 1.000000000000e-15
R935 935 936 1.000000000000e+00
C935 936 0 1.000000000000e-15
R936 936 937 1.000000000000e+00
C936 937 0 1.000000000000e-15
R937 937 938 1.000000000000e+00
C937 938 0 1.000000000000e-15
R938 938 939 1.000000000000e+00
C938 939 0 1.000000000000e-15
R939 939 940 1.000000000000e+00
C939 940 0 1.000000000000e-15
R940 940 941 1.000000000000e+00
C940 941 0 1.000000000000e-15
R941 941 942 1.000000000000e+00
C941 942 0 1.000000000000e-15
R942 942 943 1.000000000000e+00
C942 943 0 1.000000000000e-15
R943 943 944 1.000000000000e+00
C943 944 0 1.000000000000e-15
R944 944 945 1.000000000000e+00
C944 945 0 1.000000000000e-15
R945 945 946 1.000000000000e+00
C945 946 0 1.000000000000e-15
R946 946 947 1.000000000000e+00
C946 947 0 1.000000000000e-15
R947 947 948 1.000000000000e+00
C947 948 0 1.000000000000e-15
R948 948 949 1.000000000000e+00
C948 949 0 1.000000000000e-15
R949 949 950 1.000000000000e+00
C949 950 0 1.000000000000e-15
R950 950 951 1.000000000000e+00
C950 951 0 1.000000000000e-15
R951 951 952 1.000000000000e+00
C951 952 0 1.000000000000e-15
R952 952 953 1.000000000000e+00
C952 953 0 1.000000000000e-15
R953 953 954 1.000000000000e+00
C953 954 0 1.000000000000e-15
R954 954 955 1.000000000000e+00
C954 955 0 1.000000000000e-15
R955 955 956 1.000000000000e+00
C955 956 0 1.000000000000e-15
R956 956 957 1.000000000000e+00
C956 957 0 1.000000000000e-15
R957 957 958 1.000000000000e+00
C957 958 0 1.000000000000e-15
R958 958 959 1.000000000000e+00
C958 959 0 1.000000000000e-15
R959 959 960 1.000000000000e+00
C959 960 0 1.000000000000e-15
R960 960 961 1.000000000000e+00
C960 961 0 1.000000000000e-15
R961 961 962 1.000000000000e+00
C961 962 0 1.000000000000e-15
R962 962 963 1.000000000000e+00
C962 963 0 1.000000000000e-15
R963 963 964 1.000000000000e+00
C963 964 0 1.000000000000e-15
R964 964 965 1.000000000000e+00
C964 965 0 1.000000000000e-15
R965 965 966 1.000000000000e+00
C965 966 0 1.000000000000e-15
R966 966 967 1.000000000000e+00
C966 967 0 1.000000000000e-15
R967 967 968 1.000000000000e+00
C967 968 0 1.000000000000e-15
R968 968 969 1.000000000000e+00
C968 969 0 1.000000000000e-15
R969 969 970 1.000000000000e+00
C969 970 0 1.000000000000e-15
R970 970 971 1.000000000000e+00
C970 971 0 1.000000000000e-15
R971 971 972 1.000000000000e+00
C971 972 0 1.000000000000e-15
R972 972 973 1.000000000000e+00
C972 973 0 1.000000000000e-15
R973 973 974 1.000000000000e+00
C973 974 0 1.000000000000e-15
R974 974 975 1.000000000000e+00
C974 975 0 1.000000000000e-15
R975 975 976 1.000000000000e+00
C975 976 0 1.000000000000e-15
R976 976 977 1.000000000000e+00
C976 977 0 1.000000000000e-15
R977 977 978 1.000000000000e+00
C977 978 0 1.000000000000e-15
R978 978 979 1.000000000000e+00
C978 979 0 1.000000000000e-15
R979 979 980 1.000000000000e+00
C979 980 0 1.000000000000e-15
R980 980 981 1.000000000000e+00
C980 981 0 1.000000000000e-15
R981 981 982 1.000000000000e+00
C981 982 0 1.000000000000e-15
R982 982 983 1.000000000000e+00
C982 983 0 1.000000000000e-15
R983 983 984 1.000000000000e+00
C983 984 0 1.000000000000e-15
R984 984 985 1.000000000000e+00
C984 985 0 1.000000000000e-15
R985 985 986 1.000000000000e+00
C985 986 0 1.000000000000e-15
R986 986 987 1.000000000000e+00
C986 987 0 1.000000000000e-15
R987 987 988 1.000000000000e+00
C987 988 0 1.000000000000e-15
R988 988 989 1.000000000000e+00
C988 989 0 1.000000000000e-15
R989 989 990 1.000000000000e+00
C989 990 0 1.000000000000e-15
R990 990 991 1.000000000000e+00
C990 991 0 1.000000000000e-15
R991 991 992 1.000000000000e+00
C991 992 0 1.000000000000e-15
R992 992 993 1.000000000000e+00
C992 993 0 1.000000000000e-15
R993 993 994 1.000000000000e+00
C993 994 0 1.000000000000e-15
R994 994 995 1.000000000000e+00
C994 995 0 1.000000000000e-15
R995 995 996 1.000000000000e+00
C995 996 0 1.000000000000e-15
R996 996 997 1.000000000000e+00
C996 997 0 1.000000000000e-15
R997 997 998 1.000000000000e+00
C997 998 0 1.000000000000e-15
R998 998 999 1.000000000000e+00
C998 999 0 1.000000000000e-15
R999 999 1000 1.000000000000e+00
C999 1000 0 1.000000000000e-15
R1000 1000 1001 1.000000000000e+00
C1000 1001 0 1.000000000000e-15

.tran 5.0000ps 100.0000ps
.options timeint method=gear debuglevel=-100 reltol=1.0e-6 abstol=1.0e-6
.options device debuglevel=-100
.options nonlin debuglevel=-100
.options nonlin-tran debuglevel=-100

.print tran format=tecplot V(1) V(1001)

.sens objfunc={V(1001)} param=R1:R,C1:C,R2:R,C2:C,R3:R,C3:C,R4:R,C4:C,R5:R,C5:C,R6:R,C6:C,R7:R,C7:C,R8:R,C8:C,R9:R,C9:C,R10:R,C10:C,R11:R,C11:C,R12:R,C12:C,R13:R,C13:C,R14:R,C14:C,R15:R,C15:C,R16:R,C16:C,R17:R,C17:C,R18:R,C18:C,R19:R,C19:C,R20:R,C20:C,R21:R,C21:C,R22:R,C22:C,R23:R,C23:C,R24:R,C24:C,R25:R,C25:C,R26:R,C26:C,R27:R,C27:C,R28:R,C28:C,R29:R,C29:C,R30:R,C30:C,R31:R,C31:C,R32:R,C32:C,R33:R,C33:C,R34:R,C34:C,R35:R,C35:C,R36:R,C36:C,R37:R,C37:C,R38:R,C38:C,R39:R,C39:C,R40:R,C40:C,R41:R,C41:C,R42:R,C42:C,R43:R,C43:C,R44:R,C44:C,R45:R,C45:C,R46:R,C46:C,R47:R,C47:C,R48:R,C48:C,R49:R,C49:C,R50:R,C50:C,R51:R,C51:C,R52:R,C52:C,R53:R,C53:C,R54:R,C54:C,R55:R,C55:C,R56:R,C56:C,R57:R,C57:C,R58:R,C58:C,R59:R,C59:C,R60:R,C60:C,R61:R,C61:C,R62:R,C62:C,R63:R,C63:C,R64:R,C64:C,R65:R,C65:C,R66:R,C66:C,R67:R,C67:C,R68:R,C68:C,R69:R,C69:C,R70:R,C70:C,R71:R,C71:C,R72:R,C72:C,R73:R,C73:C,R74:R,C74:C,R75:R,C75:C,R76:R,C76:C,R77:R,C77:C,R78:R,C78:C,R79:R,C79:C,R80:R,C80:C,R81:R,C81:C,R82:R,C82:C,R83:R,C83:C,R84:R,C84:C,R85:R,C85:C,R86:R,C86:C,R87:R,C87:C,R88:R,C88:C,R89:R,C89:C,R90:R,C90:C,R91:R,C91:C,R92:R,C92:C,R93:R,C93:C,R94:R,C94:C,R95:R,C95:C,R96:R,C96:C,R97:R,C97:C,R98:R,C98:C,R99:R,C99:C,R100:R,C100:C,R101:R,C101:C,R102:R,C102:C,R103:R,C103:C,R104:R,C104:C,R105:R,C105:C,R106:R,C106:C,R107:R,C107:C,R108:R,C108:C,R109:R,C109:C,R110:R,C110:C,R111:R,C111:C,R112:R,C112:C,R113:R,C113:C,R114:R,C114:C,R115:R,C115:C,R116:R,C116:C,R117:R,C117:C,R118:R,C118:C,R119:R,C119:C,R120:R,C120:C,R121:R,C121:C,R122:R,C122:C,R123:R,C123:C,R124:R,C124:C,R125:R,C125:C,R126:R,C126:C,R127:R,C127:C,R128:R,C128:C,R129:R,C129:C,R130:R,C130:C,R131:R,C131:C,R132:R,C132:C,R133:R,C133:C,R134:R,C134:C,R135:R,C135:C,R136:R,C136:C,R137:R,C137:C,R138:R,C138:C,R139:R,C139:C,R140:R,C140:C,R141:R,C141:C,R142:R,C142:C,R143:R,C143:C,R144:R,C144:C,R145:R,C145:C,R146:R,C146:C,R147:R,C147:C,R148:R,C148:C,R149:R,C149:C,R150:R,C150:C,R151:R,C151:C,R152:R,C152:C,R153:R,C153:C,R154:R,C154:C,R155:R,C155:C,R156:R,C156:C,R157:R,C157:C,R158:R,C158:C,R159:R,C159:C,R160:R,C160:C,R161:R,C161:C,R162:R,C162:C,R163:R,C163:C,R164:R,C164:C,R165:R,C165:C,R166:R,C166:C,R167:R,C167:C,R168:R,C168:C,R169:R,C169:C,R170:R,C170:C,R171:R,C171:C,R172:R,C172:C,R173:R,C173:C,R174:R,C174:C,R175:R,C175:C,R176:R,C176:C,R177:R,C177:C,R178:R,C178:C,R179:R,C179:C,R180:R,C180:C,R181:R,C181:C,R182:R,C182:C,R183:R,C183:C,R184:R,C184:C,R185:R,C185:C,R186:R,C186:C,R187:R,C187:C,R188:R,C188:C,R189:R,C189:C,R190:R,C190:C,R191:R,C191:C,R192:R,C192:C,R193:R,C193:C,R194:R,C194:C,R195:R,C195:C,R196:R,C196:C,R197:R,C197:C,R198:R,C198:C,R199:R,C199:C,R200:R,C200:C,R201:R,C201:C,R202:R,C202:C,R203:R,C203:C,R204:R,C204:C,R205:R,C205:C,R206:R,C206:C,R207:R,C207:C,R208:R,C208:C,R209:R,C209:C,R210:R,C210:C,R211:R,C211:C,R212:R,C212:C,R213:R,C213:C,R214:R,C214:C,R215:R,C215:C,R216:R,C216:C,R217:R,C217:C,R218:R,C218:C,R219:R,C219:C,R220:R,C220:C,R221:R,C221:C,R222:R,C222:C,R223:R,C223:C,R224:R,C224:C,R225:R,C225:C,R226:R,C226:C,R227:R,C227:C,R228:R,C228:C,R229:R,C229:C,R230:R,C230:C,R231:R,C231:C,R232:R,C232:C,R233:R,C233:C,R234:R,C234:C,R235:R,C235:C,R236:R,C236:C,R237:R,C237:C,R238:R,C238:C,R239:R,C239:C,R240:R,C240:C,R241:R,C241:C,R242:R,C242:C,R243:R,C243:C,R244:R,C244:C,R245:R,C245:C,R246:R,C246:C,R247:R,C247:C,R248:R,C248:C,R249:R,C249:C,R250:R,C250:C,R251:R,C251:C,R252:R,C252:C,R253:R,C253:C,R254:R,C254:C,R255:R,C255:C,R256:R,C256:C,R257:R,C257:C,R258:R,C258:C,R259:R,C259:C,R260:R,C260:C,R261:R,C261:C,R262:R,C262:C,R263:R,C263:C,R264:R,C264:C,R265:R,C265:C,R266:R,C266:C,R267:R,C267:C,R268:R,C268:C,R269:R,C269:C,R270:R,C270:C,R271:R,C271:C,R272:R,C272:C,R273:R,C273:C,R274:R,C274:C,R275:R,C275:C,R276:R,C276:C,R277:R,C277:C,R278:R,C278:C,R279:R,C279:C,R280:R,C280:C,R281:R,C281:C,R282:R,C282:C,R283:R,C283:C,R284:R,C284:C,R285:R,C285:C,R286:R,C286:C,R287:R,C287:C,R288:R,C288:C,R289:R,C289:C,R290:R,C290:C,R291:R,C291:C,R292:R,C292:C,R293:R,C293:C,R294:R,C294:C,R295:R,C295:C,R296:R,C296:C,R297:R,C297:C,R298:R,C298:C,R299:R,C299:C,R300:R,C300:C,R301:R,C301:C,R302:R,C302:C,R303:R,C303:C,R304:R,C304:C,R305:R,C305:C,R306:R,C306:C,R307:R,C307:C,R308:R,C308:C,R309:R,C309:C,R310:R,C310:C,R311:R,C311:C,R312:R,C312:C,R313:R,C313:C,R314:R,C314:C,R315:R,C315:C,R316:R,C316:C,R317:R,C317:C,R318:R,C318:C,R319:R,C319:C,R320:R,C320:C,R321:R,C321:C,R322:R,C322:C,R323:R,C323:C,R324:R,C324:C,R325:R,C325:C,R326:R,C326:C,R327:R,C327:C,R328:R,C328:C,R329:R,C329:C,R330:R,C330:C,R331:R,C331:C,R332:R,C332:C,R333:R,C333:C,R334:R,C334:C,R335:R,C335:C,R336:R,C336:C,R337:R,C337:C,R338:R,C338:C,R339:R,C339:C,R340:R,C340:C,R341:R,C341:C,R342:R,C342:C,R343:R,C343:C,R344:R,C344:C,R345:R,C345:C,R346:R,C346:C,R347:R,C347:C,R348:R,C348:C,R349:R,C349:C,R350:R,C350:C,R351:R,C351:C,R352:R,C352:C,R353:R,C353:C,R354:R,C354:C,R355:R,C355:C,R356:R,C356:C,R357:R,C357:C,R358:R,C358:C,R359:R,C359:C,R360:R,C360:C,R361:R,C361:C,R362:R,C362:C,R363:R,C363:C,R364:R,C364:C,R365:R,C365:C,R366:R,C366:C,R367:R,C367:C,R368:R,C368:C,R369:R,C369:C,R370:R,C370:C,R371:R,C371:C,R372:R,C372:C,R373:R,C373:C,R374:R,C374:C,R375:R,C375:C,R376:R,C376:C,R377:R,C377:C,R378:R,C378:C,R379:R,C379:C,R380:R,C380:C,R381:R,C381:C,R382:R,C382:C,R383:R,C383:C,R384:R,C384:C,R385:R,C385:C,R386:R,C386:C,R387:R,C387:C,R388:R,C388:C,R389:R,C389:C,R390:R,C390:C,R391:R,C391:C,R392:R,C392:C,R393:R,C393:C,R394:R,C394:C,R395:R,C395:C,R396:R,C396:C,R397:R,C397:C,R398:R,C398:C,R399:R,C399:C,R400:R,C400:C,R401:R,C401:C,R402:R,C402:C,R403:R,C403:C,R404:R,C404:C,R405:R,C405:C,R406:R,C406:C,R407:R,C407:C,R408:R,C408:C,R409:R,C409:C,R410:R,C410:C,R411:R,C411:C,R412:R,C412:C,R413:R,C413:C,R414:R,C414:C,R415:R,C415:C,R416:R,C416:C,R417:R,C417:C,R418:R,C418:C,R419:R,C419:C,R420:R,C420:C,R421:R,C421:C,R422:R,C422:C,R423:R,C423:C,R424:R,C424:C,R425:R,C425:C,R426:R,C426:C,R427:R,C427:C,R428:R,C428:C,R429:R,C429:C,R430:R,C430:C,R431:R,C431:C,R432:R,C432:C,R433:R,C433:C,R434:R,C434:C,R435:R,C435:C,R436:R,C436:C,R437:R,C437:C,R438:R,C438:C,R439:R,C439:C,R440:R,C440:C,R441:R,C441:C,R442:R,C442:C,R443:R,C443:C,R444:R,C444:C,R445:R,C445:C,R446:R,C446:C,R447:R,C447:C,R448:R,C448:C,R449:R,C449:C,R450:R,C450:C,R451:R,C451:C,R452:R,C452:C,R453:R,C453:C,R454:R,C454:C,R455:R,C455:C,R456:R,C456:C,R457:R,C457:C,R458:R,C458:C,R459:R,C459:C,R460:R,C460:C,R461:R,C461:C,R462:R,C462:C,R463:R,C463:C,R464:R,C464:C,R465:R,C465:C,R466:R,C466:C,R467:R,C467:C,R468:R,C468:C,R469:R,C469:C,R470:R,C470:C,R471:R,C471:C,R472:R,C472:C,R473:R,C473:C,R474:R,C474:C,R475:R,C475:C,R476:R,C476:C,R477:R,C477:C,R478:R,C478:C,R479:R,C479:C,R480:R,C480:C,R481:R,C481:C,R482:R,C482:C,R483:R,C483:C,R484:R,C484:C,R485:R,C485:C,R486:R,C486:C,R487:R,C487:C,R488:R,C488:C,R489:R,C489:C,R490:R,C490:C,R491:R,C491:C,R492:R,C492:C,R493:R,C493:C,R494:R,C494:C,R495:R,C495:C,R496:R,C496:C,R497:R,C497:C,R498:R,C498:C,R499:R,C499:C,R500:R,C500:C,R501:R,C501:C,R502:R,C502:C,R503:R,C503:C,R504:R,C504:C,R505:R,C505:C,R506:R,C506:C,R507:R,C507:C,R508:R,C508:C,R509:R,C509:C,R510:R,C510:C,R511:R,C511:C,R512:R,C512:C,R513:R,C513:C,R514:R,C514:C,R515:R,C515:C,R516:R,C516:C,R517:R,C517:C,R518:R,C518:C,R519:R,C519:C,R520:R,C520:C,R521:R,C521:C,R522:R,C522:C,R523:R,C523:C,R524:R,C524:C,R525:R,C525:C,R526:R,C526:C,R527:R,C527:C,R528:R,C528:C,R529:R,C529:C,R530:R,C530:C,R531:R,C531:C,R532:R,C532:C,R533:R,C533:C,R534:R,C534:C,R535:R,C535:C,R536:R,C536:C,R537:R,C537:C,R538:R,C538:C,R539:R,C539:C,R540:R,C540:C,R541:R,C541:C,R542:R,C542:C,R543:R,C543:C,R544:R,C544:C,R545:R,C545:C,R546:R,C546:C,R547:R,C547:C,R548:R,C548:C,R549:R,C549:C,R550:R,C550:C,R551:R,C551:C,R552:R,C552:C,R553:R,C553:C,R554:R,C554:C,R555:R,C555:C,R556:R,C556:C,R557:R,C557:C,R558:R,C558:C,R559:R,C559:C,R560:R,C560:C,R561:R,C561:C,R562:R,C562:C,R563:R,C563:C,R564:R,C564:C,R565:R,C565:C,R566:R,C566:C,R567:R,C567:C,R568:R,C568:C,R569:R,C569:C,R570:R,C570:C,R571:R,C571:C,R572:R,C572:C,R573:R,C573:C,R574:R,C574:C,R575:R,C575:C,R576:R,C576:C,R577:R,C577:C,R578:R,C578:C,R579:R,C579:C,R580:R,C580:C,R581:R,C581:C,R582:R,C582:C,R583:R,C583:C,R584:R,C584:C,R585:R,C585:C,R586:R,C586:C,R587:R,C587:C,R588:R,C588:C,R589:R,C589:C,R590:R,C590:C,R591:R,C591:C,R592:R,C592:C,R593:R,C593:C,R594:R,C594:C,R595:R,C595:C,R596:R,C596:C,R597:R,C597:C,R598:R,C598:C,R599:R,C599:C,R600:R,C600:C,R601:R,C601:C,R602:R,C602:C,R603:R,C603:C,R604:R,C604:C,R605:R,C605:C,R606:R,C606:C,R607:R,C607:C,R608:R,C608:C,R609:R,C609:C,R610:R,C610:C,R611:R,C611:C,R612:R,C612:C,R613:R,C613:C,R614:R,C614:C,R615:R,C615:C,R616:R,C616:C,R617:R,C617:C,R618:R,C618:C,R619:R,C619:C,R620:R,C620:C,R621:R,C621:C,R622:R,C622:C,R623:R,C623:C,R624:R,C624:C,R625:R,C625:C,R626:R,C626:C,R627:R,C627:C,R628:R,C628:C,R629:R,C629:C,R630:R,C630:C,R631:R,C631:C,R632:R,C632:C,R633:R,C633:C,R634:R,C634:C,R635:R,C635:C,R636:R,C636:C,R637:R,C637:C,R638:R,C638:C,R639:R,C639:C,R640:R,C640:C,R641:R,C641:C,R642:R,C642:C,R643:R,C643:C,R644:R,C644:C,R645:R,C645:C,R646:R,C646:C,R647:R,C647:C,R648:R,C648:C,R649:R,C649:C,R650:R,C650:C,R651:R,C651:C,R652:R,C652:C,R653:R,C653:C,R654:R,C654:C,R655:R,C655:C,R656:R,C656:C,R657:R,C657:C,R658:R,C658:C,R659:R,C659:C,R660:R,C660:C,R661:R,C661:C,R662:R,C662:C,R663:R,C663:C,R664:R,C664:C,R665:R,C665:C,R666:R,C666:C,R667:R,C667:C,R668:R,C668:C,R669:R,C669:C,R670:R,C670:C,R671:R,C671:C,R672:R,C672:C,R673:R,C673:C,R674:R,C674:C,R675:R,C675:C,R676:R,C676:C,R677:R,C677:C,R678:R,C678:C,R679:R,C679:C,R680:R,C680:C,R681:R,C681:C,R682:R,C682:C,R683:R,C683:C,R684:R,C684:C,R685:R,C685:C,R686:R,C686:C,R687:R,C687:C,R688:R,C688:C,R689:R,C689:C,R690:R,C690:C,R691:R,C691:C,R692:R,C692:C,R693:R,C693:C,R694:R,C694:C,R695:R,C695:C,R696:R,C696:C,R697:R,C697:C,R698:R,C698:C,R699:R,C699:C,R700:R,C700:C,R701:R,C701:C,R702:R,C702:C,R703:R,C703:C,R704:R,C704:C,R705:R,C705:C,R706:R,C706:C,R707:R,C707:C,R708:R,C708:C,R709:R,C709:C,R710:R,C710:C,R711:R,C711:C,R712:R,C712:C,R713:R,C713:C,R714:R,C714:C,R715:R,C715:C,R716:R,C716:C,R717:R,C717:C,R718:R,C718:C,R719:R,C719:C,R720:R,C720:C,R721:R,C721:C,R722:R,C722:C,R723:R,C723:C,R724:R,C724:C,R725:R,C725:C,R726:R,C726:C,R727:R,C727:C,R728:R,C728:C,R729:R,C729:C,R730:R,C730:C,R731:R,C731:C,R732:R,C732:C,R733:R,C733:C,R734:R,C734:C,R735:R,C735:C,R736:R,C736:C,R737:R,C737:C,R738:R,C738:C,R739:R,C739:C,R740:R,C740:C,R741:R,C741:C,R742:R,C742:C,R743:R,C743:C,R744:R,C744:C,R745:R,C745:C,R746:R,C746:C,R747:R,C747:C,R748:R,C748:C,R749:R,C749:C,R750:R,C750:C,R751:R,C751:C,R752:R,C752:C,R753:R,C753:C,R754:R,C754:C,R755:R,C755:C,R756:R,C756:C,R757:R,C757:C,R758:R,C758:C,R759:R,C759:C,R760:R,C760:C,R761:R,C761:C,R762:R,C762:C,R763:R,C763:C,R764:R,C764:C,R765:R,C765:C,R766:R,C766:C,R767:R,C767:C,R768:R,C768:C,R769:R,C769:C,R770:R,C770:C,R771:R,C771:C,R772:R,C772:C,R773:R,C773:C,R774:R,C774:C,R775:R,C775:C,R776:R,C776:C,R777:R,C777:C,R778:R,C778:C,R779:R,C779:C,R780:R,C780:C,R781:R,C781:C,R782:R,C782:C,R783:R,C783:C,R784:R,C784:C,R785:R,C785:C,R786:R,C786:C,R787:R,C787:C,R788:R,C788:C,R789:R,C789:C,R790:R,C790:C,R791:R,C791:C,R792:R,C792:C,R793:R,C793:C,R794:R,C794:C,R795:R,C795:C,R796:R,C796:C,R797:R,C797:C,R798:R,C798:C,R799:R,C799:C,R800:R,C800:C,R801:R,C801:C,R802:R,C802:C,R803:R,C803:C,R804:R,C804:C,R805:R,C805:C,R806:R,C806:C,R807:R,C807:C,R808:R,C808:C,R809:R,C809:C,R810:R,C810:C,R811:R,C811:C,R812:R,C812:C,R813:R,C813:C,R814:R,C814:C,R815:R,C815:C,R816:R,C816:C,R817:R,C817:C,R818:R,C818:C,R819:R,C819:C,R820:R,C820:C,R821:R,C821:C,R822:R,C822:C,R823:R,C823:C,R824:R,C824:C,R825:R,C825:C,R826:R,C826:C,R827:R,C827:C,R828:R,C828:C,R829:R,C829:C,R830:R,C830:C,R831:R,C831:C,R832:R,C832:C,R833:R,C833:C,R834:R,C834:C,R835:R,C835:C,R836:R,C836:C,R837:R,C837:C,R838:R,C838:C,R839:R,C839:C,R840:R,C840:C,R841:R,C841:C,R842:R,C842:C,R843:R,C843:C,R844:R,C844:C,R845:R,C845:C,R846:R,C846:C,R847:R,C847:C,R848:R,C848:C,R849:R,C849:C,R850:R,C850:C,R851:R,C851:C,R852:R,C852:C,R853:R,C853:C,R854:R,C854:C,R855:R,C855:C,R856:R,C856:C,R857:R,C857:C,R858:R,C858:C,R859:R,C859:C,R860:R,C860:C,R861:R,C861:C,R862:R,C862:C,R863:R,C863:C,R864:R,C864:C,R865:R,C865:C,R866:R,C866:C,R867:R,C867:C,R868:R,C868:C,R869:R,C869:C,R870:R,C870:C,R871:R,C871:C,R872:R,C872:C,R873:R,C873:C,R874:R,C874:C,R875:R,C875:C,R876:R,C876:C,R877:R,C877:C,R878:R,C878:C,R879:R,C879:C,R880:R,C880:C,R881:R,C881:C,R882:R,C882:C,R883:R,C883:C,R884:R,C884:C,R885:R,C885:C,R886:R,C886:C,R887:R,C887:C,R888:R,C888:C,R889:R,C889:C,R890:R,C890:C,R891:R,C891:C,R892:R,C892:C,R893:R,C893:C,R894:R,C894:C,R895:R,C895:C,R896:R,C896:C,R897:R,C897:C,R898:R,C898:C,R899:R,C899:C,R900:R,C900:C,R901:R,C901:C,R902:R,C902:C,R903:R,C903:C,R904:R,C904:C,R905:R,C905:C,R906:R,C906:C,R907:R,C907:C,R908:R,C908:C,R909:R,C909:C,R910:R,C910:C,R911:R,C911:C,R912:R,C912:C,R913:R,C913:C,R914:R,C914:C,R915:R,C915:C,R916:R,C916:C,R917:R,C917:C,R918:R,C918:C,R919:R,C919:C,R920:R,C920:C,R921:R,C921:C,R922:R,C922:C,R923:R,C923:C,R924:R,C924:C,R925:R,C925:C,R926:R,C926:C,R927:R,C927:C,R928:R,C928:C,R929:R,C929:C,R930:R,C930:C,R931:R,C931:C,R932:R,C932:C,R933:R,C933:C,R934:R,C934:C,R935:R,C935:C,R936:R,C936:C,R937:R,C937:C,R938:R,C938:C,R939:R,C939:C,R940:R,C940:C,R941:R,C941:C,R942:R,C942:C,R943:R,C943:C,R944:R,C944:C,R945:R,C945:C,R946:R,C946:C,R947:R,C947:C,R948:R,C948:C,R949:R,C949:C,R950:R,C950:C,R951:R,C951:C,R952:R,C952:C,R953:R,C953:C,R954:R,C954:C,R955:R,C955:C,R956:R,C956:C,R957:R,C957:C,R958:R,C958:C,R959:R,C959:C,R960:R,C960:C,R961:R,C961:C,R962:R,C962:C,R963:R,C963:C,R964:R,C964:C,R965:R,C965:C,R966:R,C966:C,R967:R,C967:C,R968:R,C968:C,R969:R,C969:C,R970:R,C970:C,R971:R,C971:C,R972:R,C972:C,R973:R,C973:C,R974:R,C974:C,R975:R,C975:C,R976:R,C976:C,R977:R,C977:C,R978:R,C978:C,R979:R,C979:C,R980:R,C980:C,R981:R,C981:C,R982:R,C982:C,R983:R,C983:C,R984:R,C984:C,R985:R,C985:C,R986:R,C986:C,R987:R,C987:C,R988:R,C988:C,R989:R,C989:C,R990:R,C990:C,R991:R,C991:C,R992:R,C992:C,R993:R,C993:C,R994:R,C994:C,R995:R,C995:C,R996:R,C996:C,R997:R,C997:C,R998:R,C998:C,R999:R,C999:C,R1000:R,C1000:C
.options sensitivity direct=0 adjoint=1 adjointtimepoints=75.0000ps,85.0000ps
.print tranadjoint
.print sens
