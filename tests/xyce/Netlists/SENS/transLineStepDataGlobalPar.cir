* 3 stage RC Ladder.
*
* Generated by running RC_ladder.pl 3 <return>, where 3 is the number of parallel resistor-capacitor
* with shunt capacitor subcircuits in series.
*
.global_param cap=1e-8
.global_param res=1k

Vs 1 0 sin (0.0 1.0  100k)
Rgs 1 2 0.02

.subckt RCBlock IN OUT GND
R1 IN OUT {res}
C1 IN OUT {cap}
Cg1 OUT GND 1e-9
.ends

X1 2 3 0 RCBlock
X2 3 4 0 RCBlock
X3 4 5 0 RCBlock

.print tran format=tecplot v(2) v(5)
.tran 10p 2e-5

.SENS objfunc={V(5)} param=cap,res
.options SENSITIVITY direct=1 adjoint=0  diagnosticfile=0  stdoutput=0
.print sens format=tecplot v(2)

.data eric
+ cap res
+ 1e-8 1k
+ 2e-8 0.5k
+ 3e-8 0.25k
+ 4e-8 0.125k
.enddata

.step data=eric
