Transmission Line Circuit
*********************************************************************
* This tests the error messages generated by the T device.
* The instance line for the T device, TLINE1, is completely bogus,
* and is missing all of its required parameters.
*
* TLINE2 and TLINE3 are missing the Z0 parameter.
*
*
*
*********************************************************************
VIN 1 0 PULSE(0 5 0 0.1N 0.1N 5N 25N)
RIN 1 2 50

* this instance line is completely bogus.  It is missing all
* of its required parameters
TLINE1 2 0 3 0

* Z0 must be specified
TLINE2 2 0 3 0 TD=10ns
TLINE3 2 0 3 0 F=1GHZ NL=10

RL 3 0 50
.TRAN 0.25N 50N
.PRINT TRAN V(2) V(3)
.END
