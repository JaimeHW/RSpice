Transmission Line Circuit
*********************************************************************
* This tests the error messages generated by the T device when the
* instance line parameters are invalid (e.g, zero or negative).
*
*
*
*
*
*
*
*
*********************************************************************
VIN 1 0 PULSE(0 5 0 0.1N 0.1N 5N 25N)
RIN 1 2 50

* Z0 must be positive
TLINE1 2 0 3 0 Z0=0 TD=10ns

* time delay must be positive
TLINE2 2 0 3 0 Z0=50 TD=0ns

* Both F and NL must be positive
TLINE3 2 0 3 0 Z0=50 F=1GHz NL=-1
TLINE4 2 0 3 0 ZO=50 F=0
TLINE5 2 0 3 0 Z0=50 F=-1GHz

RL 3 0 50
.TRAN 0.25N 50N
.PRINT TRAN V(2) V(3)
.END
