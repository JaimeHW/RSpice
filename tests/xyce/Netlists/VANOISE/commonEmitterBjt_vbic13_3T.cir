* gnetlist -g spice-sdb CommonEmitterI.sch
*********************************************************
* Spice file generated by gnetlist                      *
* spice-sdb version 4.28.2007 by SDB --                 *
* provides advanced spice netlisting capability.        *
* Documentation at http://www.brorson.com/gEDA/SPICE/   *
*********************************************************
*==============  Begin SPICE netlist of main design ============
.noise V(OUT) V1 oct 10 .01 1e3 1
.print noise {sqrt(abs(ONOISE))} {SQRT(ABS(INOISE))}
+ {pow(abs(DNO(r3)),1/3)}
+ {pow(abs(DNO(r1)),1/3)}
+ {pow(abs(DNO(r5)),1/3)}
+ {pow(abs(DNO(r4)),1/3)}
+ {pow(abs(DNO(q1,white_bi_ei_ibei_shot_noise)),1/3)}
+ {pow(abs(DNO(q1,flicker_bi_ei_ibei_flicker_noise)),1/3)}
+ {pow(abs(DNO(q1,white_bx_ei_ibex_shot_noise)),1/3)}
+ {pow(abs(DNO(q1,flicker_bx_ei_ibex_flicker_noise)),1/3)}
+ {pow(abs(DNO(q1,white_ci_ei_transport_current_shot_noise)),1/3)}
+ {pow(abs(DNO(q1,white_bx_bp_ibep_shot_noise)),1/3)}
+ {pow(abs(DNO(q1,flicker_bx_bp_ibep_flicker_noise)),1/3)}
+ {pow(abs(DNO(q1,white_c_cx_rcx_thermal_noise)),1/3)}
+ {pow(abs(DNO(q1,white_cx_ci_rci_thermal_noise)),1/3)}
+ {pow(abs(DNO(q1,white_b_bx_rbx_thermal_noise)),1/3)}
+ {pow(abs(DNO(q1,white_bx_bi_rbi_thermal_noise)),1/3)}
+ {pow(abs(DNO(q1,white_e_ei_re_thermal_noise)),1/3)}
+ {pow(abs(DNO(q1,white_bp_cx_rbp_thermal_noise)),1/3)}
+ {pow(abs(DNO(q1)),1/3)}
+ {pow(abs(DNO(r2)),1/3)}
+ {pow(abs(DNI(r3)),1/3)}
+ {pow(abs(DNI(r1)),1/3)}
+ {pow(abs(DNI(r5)),1/3)}
+ {pow(abs(DNI(r4)),1/3)}
+ {pow(abs(DNI(q1,white_bi_ei_ibei_shot_noise)),1/3)}
+ {pow(abs(DNI(q1,flicker_bi_ei_ibei_flicker_noise)),1/3)}
+ {pow(abs(DNI(q1,white_bx_ei_ibex_shot_noise)),1/3)}
+ {pow(abs(DNI(q1,flicker_bx_ei_ibex_flicker_noise)),1/3)}
+ {pow(abs(DNI(q1,white_ci_ei_transport_current_shot_noise)),1/3)}
+ {pow(abs(DNI(q1,white_bx_bp_ibep_shot_noise)),1/3)}
+ {pow(abs(DNI(q1,flicker_bx_bp_ibep_flicker_noise)),1/3)}
+ {pow(abs(DNI(q1,white_c_cx_rcx_thermal_noise)),1/3)}
+ {pow(abs(DNI(q1,white_cx_ci_rci_thermal_noise)),1/3)}
+ {pow(abs(DNI(q1,white_b_bx_rbx_thermal_noise)),1/3)}
+ {pow(abs(DNI(q1,white_bx_bi_rbi_thermal_noise)),1/3)}
+ {pow(abs(DNI(q1,white_e_ei_re_thermal_noise)),1/3)}
+ {pow(abs(DNI(q1,white_bp_cx_rbp_thermal_noise)),1/3)}
+ {pow(abs(DNI(q1)),1/3)}
+ {pow(abs(DNI(r2)),1/3)}

.options device temp=27
R5 0 OUT 1MEG
V1 1 0 sin 0 1 1meg AC 1
V2 Vcc 0 12
C2 Vc OUT 10u
R4 0 Ve 270
R3 Vc Vcc 1.5k
Q1 Vc Vb Ve myModel
.model mymodel npn level=11
+ IS=1e-16
+ IBEI=1e-18
+ IBEN=5e-15
+ IBCI=2e-17
+ IBCN=5e-15
+ ISP=1e-15
+ RCX=10
+ RCI=60
+ RBX=10
+ RBI=40
+ RE=2
+ RS=20
+ RBP=40
+ VEF=10
+ VER=4
+ IKF=2e-3
+ ITF=8e-2
+ XTF=20
+ IKR=2e-4
+ IKP=2e-4
+ CJE=1e-13
+ CJC=2e-14
+ CJEP=1e-13
+ CJCP=4e-13
+ VO=2
+ GAMM=2e-11
+ HRCF=2
+ QCO=1e-12
+ AVC1=2
+ AVC2=15
+ TF=10e-12
+ TR=100e-12
+ TD=1.0e-20
+ RTH=300
+ GMIN=0.0
+sw_noise=1

R2 0 Vb 6.8k
R1 Vb Vcc 39k
C1 1 Vb 10u
.end
