* dc directive
* Xyce netlist for corresponding Spectre netlist.
* Netlist tests XDM will properly translate the dc
* directive in Spectre into Xyce. A nuance of this
* test is that XDM should properly translate the
* swept device name in the dc directive. Since Spectre
* sources aren't identified by the first character
* as in other SPICE languages, XDM will rename sources
* to start with "I" or "V" depending on if it is a
* current or voltage source, respectively. The changed
* source name needs to be reflected in the dc directive.
* See issues #144 and #148 on XDM gitlab

Via 1 0 DC 0
Rr1 1 2 R=10
Rr2 2 0 R=10
.DC LIN Via 0 10 1

.PRINT DC V(1) V(2)
