embedded sampling version of a CMOS inverter
*
* This "circuit" exists to provide a meaningful .PRINT line to xyce_verify.pl.
*
* It isn't supposed to be run, and will exit with error.
*

*COMP {v(drain)}_quad_pce_mean      OFFSET=1.0
*COMP {v(drain)}_quad_pce_meanPlus  OFFSET=1.0
*COMP {v(drain)}_quad_pce_meanMinus OFFSET=1.0
*COMP {v(drain)}_quad_pce_meanPlusTwoSigma  OFFSET=1.0
*COMP {v(drain)}_quad_pce_meanMinusTwoSigma OFFSET=1.0
*COMP {v(drain)}_quad_pce_stddev    OFFSET=1.0
*COMP {v(drain)}_quad_pce_variance  OFFSET=1.0

*COMP {v(5)}_quad_pce_mean       OFFSET=1.0
*COMP {v(5)}_quad_pce_meanPlus   OFFSET=1.0
*COMP {v(5)}_quad_pce_meanMinus  OFFSET=1.0
*COMP {v(5)}_quad_pce_meanPlusTwoSigma   OFFSET=1.0
*COMP {v(5)}_quad_pce_meanMinusTwoSigma  OFFSET=1.0
*COMP {v(5)}_quad_pce_stddev     OFFSET=1.0
*COMP {v(5)}_quad_pce_variance   OFFSET=1.0
*COMP {v(2)}_quad_pce_mean       OFFSET=1.0
*COMP {v(2)}_quad_pce_meanPlus   OFFSET=1.0
*COMP {v(2)}_quad_pce_meanMinus  OFFSET=1.0
*COMP {v(2)}_quad_pce_meanPlusTwoSigma   OFFSET=1.0
*COMP {v(2)}_quad_pce_meanMinusTwoSigma  OFFSET=1.0
*COMP {v(2)}_quad_pce_stddev     OFFSET=1.0
*COMP {v(2)}_quad_pce_variance   OFFSET=1.0

.print tran {V(5)}_mean    {V(5)}_meanPlus    {V(5)}_meanMinus    {V(5)}_meanPlusTwoSigma    {V(5)}_meanMinusTwoSigma    {V(5)}_stddev    {V(5)}_variance    {V(5)}_quad_pce_mean    {V(5)}_quad_pce_meanPlus    {V(5)}_quad_pce_meanMinus    {V(5)}_quad_pce_meanPlusTwoSigma    {V(5)}_quad_pce_meanMinusTwoSigma    {V(5)}_quad_pce_stddev    {V(5)}_quad_pce_variance    {V(2)}_mean    {V(2)}_meanPlus    {V(2)}_meanMinus    {V(2)}_meanPlusTwoSigma    {V(2)}_meanMinusTwoSigma    {V(2)}_stddev    {V(2)}_variance    {V(2)}_quad_pce_mean    {V(2)}_quad_pce_meanPlus    {V(2)}_quad_pce_meanMinus    {V(2)}_quad_pce_meanPlusTwoSigma    {V(2)}_quad_pce_meanMinusTwoSigma    {V(2)}_quad_pce_stddev    {V(2)}_quad_pce_variance

.tran 1ns 1.5e-6
