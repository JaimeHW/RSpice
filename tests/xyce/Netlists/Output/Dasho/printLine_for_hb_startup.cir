* This "circuit" exists to provide a meaningful .PRINT line
* to xyce_verify.pl for the .PRINT HB_STARTUP line in the hb.cir test.
*
* It isn't supposed to be run, and will exit with error.
*

.PRINT HB ir(r1) ii(r1)
.HB 1e4
