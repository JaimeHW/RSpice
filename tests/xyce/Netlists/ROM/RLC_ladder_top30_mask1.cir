* 100 stage RC Ladder.
*
* Generated by running RC_ladder.pl 100 <return>, where 100 is the number of resistor
* with shunt capacitor subcircuits in series.
*
* Author: Heidi Thornquist
* Date: 04/15/2008
*
Vs 1 0 PULSE(0 1 0 10n 10n 20n 1m)

YROM ROM1 1 out BASE_FILENAME=RLC_ladder100_mor.cir MASK_VARS=true

.print tran {v(out)+0.2}

.options timeint reltol=1e-4

.tran 10p 5e-7
