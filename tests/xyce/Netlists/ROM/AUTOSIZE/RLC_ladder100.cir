* 100 stage RLC Ladder.
*
* Generated by running RLC_ladder.pl 100 <return>, where 100 is the number of series resistor-inductor
* and shunt capacitor subcircuits.
*
* Author: Heidi Thornquist
* Date: 04/15/2008
*
Vs 1 0 PULSE(0 1 0 10n 10n 20n 10m)

.subckt RLCBlock IN MID OUT GND
R1 IN MID 0.2
L1 MID OUT 1e-9
C1 OUT GND 0.5e-12
.ends

X1 1 2 3 0 RLCBlock
X2 3 4 5 0 RLCBlock
X3 5 6 7 0 RLCBlock
X4 7 8 9 0 RLCBlock
X5 9 10 11 0 RLCBlock
X6 11 12 13 0 RLCBlock
X7 13 14 15 0 RLCBlock
X8 15 16 17 0 RLCBlock
X9 17 18 19 0 RLCBlock
X10 19 20 21 0 RLCBlock
X11 21 22 23 0 RLCBlock
X12 23 24 25 0 RLCBlock
X13 25 26 27 0 RLCBlock
X14 27 28 29 0 RLCBlock
X15 29 30 31 0 RLCBlock
X16 31 32 33 0 RLCBlock
X17 33 34 35 0 RLCBlock
X18 35 36 37 0 RLCBlock
X19 37 38 39 0 RLCBlock
X20 39 40 41 0 RLCBlock
X21 41 42 43 0 RLCBlock
X22 43 44 45 0 RLCBlock
X23 45 46 47 0 RLCBlock
X24 47 48 49 0 RLCBlock
X25 49 50 51 0 RLCBlock
X26 51 52 53 0 RLCBlock
X27 53 54 55 0 RLCBlock
X28 55 56 57 0 RLCBlock
X29 57 58 59 0 RLCBlock
X30 59 60 61 0 RLCBlock
X31 61 62 63 0 RLCBlock
X32 63 64 65 0 RLCBlock
X33 65 66 67 0 RLCBlock
X34 67 68 69 0 RLCBlock
X35 69 70 71 0 RLCBlock
X36 71 72 73 0 RLCBlock
X37 73 74 75 0 RLCBlock
X38 75 76 77 0 RLCBlock
X39 77 78 79 0 RLCBlock
X40 79 80 81 0 RLCBlock
X41 81 82 83 0 RLCBlock
X42 83 84 85 0 RLCBlock
X43 85 86 87 0 RLCBlock
X44 87 88 89 0 RLCBlock
X45 89 90 91 0 RLCBlock
X46 91 92 93 0 RLCBlock
X47 93 94 95 0 RLCBlock
X48 95 96 97 0 RLCBlock
X49 97 98 99 0 RLCBlock
X50 99 100 101 0 RLCBlock
X51 101 102 103 0 RLCBlock
X52 103 104 105 0 RLCBlock
X53 105 106 107 0 RLCBlock
X54 107 108 109 0 RLCBlock
X55 109 110 111 0 RLCBlock
X56 111 112 113 0 RLCBlock
X57 113 114 115 0 RLCBlock
X58 115 116 117 0 RLCBlock
X59 117 118 119 0 RLCBlock
X60 119 120 121 0 RLCBlock
X61 121 122 123 0 RLCBlock
X62 123 124 125 0 RLCBlock
X63 125 126 127 0 RLCBlock
X64 127 128 129 0 RLCBlock
X65 129 130 131 0 RLCBlock
X66 131 132 133 0 RLCBlock
X67 133 134 135 0 RLCBlock
X68 135 136 137 0 RLCBlock
X69 137 138 139 0 RLCBlock
X70 139 140 141 0 RLCBlock
X71 141 142 143 0 RLCBlock
X72 143 144 145 0 RLCBlock
X73 145 146 147 0 RLCBlock
X74 147 148 149 0 RLCBlock
X75 149 150 151 0 RLCBlock
X76 151 152 153 0 RLCBlock
X77 153 154 155 0 RLCBlock
X78 155 156 157 0 RLCBlock
X79 157 158 159 0 RLCBlock
X80 159 160 161 0 RLCBlock
X81 161 162 163 0 RLCBlock
X82 163 164 165 0 RLCBlock
X83 165 166 167 0 RLCBlock
X84 167 168 169 0 RLCBlock
X85 169 170 171 0 RLCBlock
X86 171 172 173 0 RLCBlock
X87 173 174 175 0 RLCBlock
X88 175 176 177 0 RLCBlock
X89 177 178 179 0 RLCBlock
X90 179 180 181 0 RLCBlock
X91 181 182 183 0 RLCBlock
X92 183 184 185 0 RLCBlock
X93 185 186 187 0 RLCBlock
X94 187 188 189 0 RLCBlock
X95 189 190 191 0 RLCBlock
X96 191 192 193 0 RLCBlock
X97 193 194 195 0 RLCBlock
X98 195 196 197 0 RLCBlock
X99 197 198 199 0 RLCBlock
X100 199 200 out 0 RLCBlock

.print tran {v(out)+0.2}
*COMP {v(out)+0.2} reltol=0.02

.tran 10p 500e-9
