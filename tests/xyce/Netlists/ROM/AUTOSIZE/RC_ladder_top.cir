* 100 stage RC Ladder.
*
* Generated by running RC_ladder.pl 100 <return>, where 100 is the number of resistor
* with shunt capacitor subcircuits in series.
*
* Author: Heidi Thornquist
* Date: 04/15/2008
*
Vs 1 0 PULSE(1 2 25e-9 25e-9 25e-9 400e-9 1m)

YROM ROM1 1 101 BASE_FILENAME=RC_ladder100_autosize.cir

.print tran v(101)

.tran 10p 1.2us
