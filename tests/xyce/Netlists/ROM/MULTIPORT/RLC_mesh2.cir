* 12 line RLC mesh.
*
* Generated by running RLC_meshline.pl 2 <return>,
* where 2 is the number of RLC lines in one direction of the mesh
* and the mesh is assumed to be square.
*
* Author: Heidi Thornquist
* Date: 06/11/2008
*
* Based on circuit in:
* 'MIMO Interconnects Order Reductions by Using the Global Arnoldi Algorithm'
* by Lai, Chu, and Feng.
*
Vs1 1 0 PULSE(1 2 10n 1u 1u 1u 4u)
Vs2 2 0 PULSE(1 2 10n 1u 1u 1u 4u)

.subckt RLCBlock IN MID OUT GND
R1 IN MID 1e-3
L1 MID OUT .15e-9
C1 OUT GND 0.5e-12
.ends

.subckt RLCLine IN2 OUT2 GND
X1 IN2 n2 n3 GND RLCBlock
X2 n3 n4 n5 GND RLCBlock
X3 n5 n6 n7 GND RLCBlock
X4 n7 n8 n9 GND RLCBlock
X5 n9 n10 n11 GND RLCBlock
X6 n11 n12 n13 GND RLCBlock
X7 n13 n14 n15 GND RLCBlock
X8 n15 n16 n17 GND RLCBlock
X9 n17 n18 n19 GND RLCBlock
X10 n19 n20 n21 GND RLCBlock

X11 n21 n22 n23 GND RLCBlock
X12 n23 n24 n25 GND RLCBlock
X13 n25 n26 n27 GND RLCBlock
X14 n27 n28 n29 GND RLCBlock
X15 n29 n30 n31 GND RLCBlock
X16 n31 n32 n33 GND RLCBlock
X17 n33 n34 n35 GND RLCBlock
X18 n35 n36 n37 GND RLCBlock
X19 n37 n38 n39 GND RLCBlock
X20 n39 n40 n41 GND RLCBlock

X21 n41 n42 n43 GND RLCBlock
X22 n43 n44 n45 GND RLCBlock
X23 n45 n46 n47 GND RLCBlock
X24 n47 n48 n49 GND RLCBlock
X25 n49 n50 n51 GND RLCBlock
X26 n51 n52 n53 GND RLCBlock
X27 n53 n54 n55 GND RLCBlock
X28 n55 n56 n57 GND RLCBlock
X29 n57 n58 n59 GND RLCBlock
X30 n59 n60 OUT2 GND RLCBlock
.ends

Rgs1 1 3 3.0
Rgs2 2 6 3.0

* Horizontal set of lines in mesh
CLine3 3 0 1e-12
XLineH3 3 4 0 RLCLine
CLine4 4 0 1e-12
XLineH4 4 5 0 RLCLine
Cline5 5 0 1e-12

* Vertical set of lines in mesh
XLineV3 3 6 0 RLCLine
XLineV4 4 7 0 RLCLine
XLineV5 5 8 0 RLCLine

* Horizontal set of lines in mesh
CLine6 6 0 1e-12
XLineH6 6 7 0 RLCLine
CLine7 7 0 1e-12
XLineH7 7 8 0 RLCLine
Cline8 8 0 1e-12

* Vertical set of lines in mesh
XLineV6 6 9 0 RLCLine
XLineV7 7 10 0 RLCLine
XLineV8 8 11 0 RLCLine

* Horizontal set of lines in mesh
CLine9 9 0 1e-12
XLineH9 9 10 0 RLCLine
CLine10 10 0 1e-12
XLineH10 10 11 0 RLCLine
Cline11 11 0 1e-12

R1 8 0 1e3
R2 11 0 1e3

.print tran v(1) v(2) v(8) v(11)

.tran 10p 5u
