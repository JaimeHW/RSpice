* 12 line RLC mesh.
*
* Generated by running RLC_meshline.pl 2 <return>,
* where 2 is the number of RLC lines in one direction of the mesh
* and the mesh is assumed to be square.
*
* Author: Heidi Thornquist
* Date: 06/11/2008
*
* Based on circuit in:
* 'MIMO Interconnects Order Reductions by Using the Global Arnoldi Algorithm'
* by Lai, Chu, and Feng.
*
Vs1 1 0 PULSE(1 2 10n 1u 1u 1u 4u)
Vs2 2 0 PULSE(1 2 10n 1u 1u 1u 4u)

YROM MESH_ROM 1 2 8 11 BASE_FILENAME=RLC_mesh2_mor.cir

R1 8 0 1e3
R2 11 0 1e3

.print tran v(1) v(2) v(8) v(11)

.tran 10p 5u
